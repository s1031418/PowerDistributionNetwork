#Comments
V_VDD1_1 METAL6_1200000_0 gnd 1
R_VDD1_1 METAL6_1200000_0 METAL6_1200000_9500 0.019
R_VDD1_2 METAL6_1200000_9500 METAL6_1200000_21500 0.024
R_VDD1_3 METAL6_1200000_21500 METAL6_1200000_28600 0.0142
R_VDD1_4 METAL6_1200000_28600 METAL6_1200000_40600 0.024
R_VDD1_5 METAL6_1200000_40600 METAL6_1200000_52600 0.024
R_VDD1_6 METAL6_1200000_52600 METAL6_1200000_64600 0.024
R_VDD1_7 METAL6_1200000_64600 METAL6_1200000_76600 0.024
R_VDD1_8 METAL6_1200000_76600 METAL6_1200000_83600 0.014
R_VDD1_9 METAL6_1200000_83600 METAL6_1204400_83600 0.0088
R_VDD1_10 METAL6_1204400_83600 METAL6_1204400_88000 0.0088
R_VDD1_11 METAL6_1204400_88000 METAL6_1206700_88000 0.0046
R_VDD1_12 METAL6_1206700_88000 METAL6_1210300_88000 0.0072
R_VDD1_13 METAL6_1210300_88000 METAL6_1211800_88000 0.003
R_VDD1_14 METAL6_1211800_88000 METAL6_1211800_88600 0.0012
R_VDD1_15 METAL6_1211800_88600 METAL6_1211800_100000 0.0228
R_VDD1_16 METAL6_1211800_100000 METAL6_1211800_112000 0.024
R_VDD1_17 METAL6_1211800_112000 METAL6_1211800_159600 0.0952
R_VDD1_18 METAL6_1211800_159600 METAL6_1211800_166600 0.014
R_VDD1_19 METAL6_1211800_166600 METAL6_1211800_176000 0.0188
R_VDD1_20 METAL6_1211800_176000 METAL6_1211800_178600 0.0052
R_VDD1_21 METAL6_1211800_178600 METAL6_1211800_188000 0.0188
R_VDD1_22 METAL6_1211800_188000 METAL6_1211800_190600 0.0052
R_VDD1_23 METAL6_1211800_190600 METAL6_1211800_200000 0.0188
R_VDD1_24 METAL6_1211800_200000 METAL6_1211800_212000 0.024
R_VDD1_25 METAL6_1211800_212000 METAL6_1211800_248300 0.0726
R_VDD1_26 METAL6_1211800_248300 METAL6_1211800_251000 0.0054
R_VDD1_27 METAL6_1211800_251000 METAL6_1211800_260300 0.0186
R_VDD1_28 METAL6_1211800_260300 METAL6_1211800_263000 0.0054
R_VDD1_29 METAL6_1211800_263000 METAL6_1211800_272300 0.0186
R_VDD1_30 METAL6_1211800_272300 METAL6_1211800_275000 0.0054
R_VDD1_31 METAL6_1211800_275000 METAL6_1211800_279300 0.0086
R_VDD1_32 METAL6_1211800_279300 METAL6_1211800_287000 0.0154
R_VDD1_33 METAL6_1211800_287000 METAL6_1211800_288000 0.002
R_VDD1_34 METAL6_1211800_288000 METAL6_1211800_299000 0.022
R_VDD1_35 METAL6_1211800_299000 METAL6_1211800_300000 0.002
R_VDD1_36 METAL6_1211800_300000 METAL6_1211800_312000 0.024
R_VDD1_37 METAL6_1211800_312000 METAL6_1211800_355300 0.0866
R_VDD1_38 METAL6_1211800_355300 METAL6_1211800_362300 0.014
R_VDD1_39 METAL6_1211800_362300 METAL6_1211800_366800 0.009
R_VDD1_40 METAL6_1211800_366800 METAL6_1211800_374300 0.015
R_VDD1_41 METAL6_1211800_374300 METAL6_1211800_378800 0.009
R_VDD1_42 METAL6_1211800_378800 METAL6_1211800_386300 0.015
R_VDD1_43 METAL6_1211800_386300 METAL6_1211800_388000 0.0034
R_VDD1_44 METAL6_1211800_388000 METAL6_1211800_390800 0.0056
R_VDD1_45 METAL6_1211800_390800 METAL6_1211800_400000 0.0184
R_VDD1_46 METAL6_1211800_400000 METAL6_1211800_402800 0.0056
R_VDD1_47 METAL6_1211800_402800 METAL6_1211800_412000 0.0184
R_VDD1_48 METAL6_1211800_412000 METAL6_1211800_413000 0.002
R_VDD1_49 METAL6_1211800_413000 METAL6_1211800_414800 0.0036
R_VDD1_50 METAL6_1211800_414800 METAL6_1211800_425000 0.0204
R_VDD1_51 METAL6_1211800_425000 METAL6_1211800_437000 0.024
R_VDD1_52 METAL6_1211800_437000 METAL6_1211800_449000 0.024
R_VDD1_53 METAL6_1211800_449000 METAL6_1212000_449000 0.0004
R_VDD1_54 METAL6_1212000_449000 METAL6_1216400_449000 0.0088
R_VDD1_55 METAL6_1216400_449000 METAL6_1218700_449000 0.0046
R_VDD1_56 METAL6_1218700_449000 METAL6_1222300_449000 0.0072
R_VDD1_57 METAL6_1222300_449000 METAL6_1223800_449000 0.003
R_VDD1_58 METAL6_1223800_449000 METAL6_1224000_449000 0.0004
R_VDD1_59 METAL6_1224000_449000 METAL6_1230700_449000 0.0134
R_VDD1_60 METAL6_1230700_449000 METAL6_1234300_449000 0.0072
R_VDD1_61 METAL6_1234300_449000 METAL6_1235800_449000 0.003
R_VDD1_62 METAL6_1235800_449000 METAL6_1242700_449000 0.0138
R_VDD1_63 METAL6_1242700_449000 METAL6_1246300_449000 0.0072
R_VDD1_64 METAL6_1246300_449000 METAL6_1247800_449000 0.003
R_VDD1_65 METAL6_1247800_449000 METAL6_1253300_449000 0.011
R_VDD1_66 METAL6_1253300_449000 METAL6_1254700_449000 0.0028
R_VDD1_67 METAL6_1254700_449000 METAL6_1258300_449000 0.0072
R_VDD1_68 METAL6_1258300_449000 METAL6_1259800_449000 0.003
R_VDD1_69 METAL6_1259800_449000 METAL6_1262700_449000 0.0058
R_VDD1_70 METAL6_1262700_449000 METAL6_1266800_449000 0.0082
R_VDD1_71 METAL6_1266800_449000 METAL6_1274700_449000 0.0158
R_VDD1_72 METAL6_1274700_449000 METAL6_1286700_449000 0.024
R_VDD1_73 METAL6_1286700_449000 METAL6_1287800_449000 0.0022
R_VDD1_74 METAL6_1287800_449000 METAL6_1288000_449000 0.0004
R_VDD1_75 METAL6_1288000_449000 METAL6_1289000_449000 0.002
R_VDD1_76 METAL6_1289000_449000 METAL6_1299800_449000 0.0216
R_VDD1_77 METAL6_1299800_449000 METAL6_1300000_449000 0.0004
R_VDD1_78 METAL6_1300000_449000 METAL6_1301000_449000 0.002
R_VDD1_79 METAL6_1301000_449000 METAL6_1311800_449000 0.0216
R_VDD1_80 METAL6_1311800_449000 METAL6_1312000_449000 0.0004
R_VDD1_81 METAL6_1312000_449000 METAL6_1313000_449000 0.002
R_VDD1_82 METAL6_1313000_449000 METAL6_1323800_449000 0.0216
R_VDD1_83 METAL6_1323800_449000 METAL6_1324000_449000 0.0004
R_VDD1_84 METAL6_1324000_449000 METAL6_1325000_449000 0.002
R_VDD1_85 METAL6_1325000_449000 METAL6_1337000_449000 0.024
R_VDD1_86 METAL6_1337000_449000 METAL6_1388000_449000 0.102
R_VDD1_87 METAL6_1388000_449000 METAL6_1400000_449000 0.024
R_VDD1_88 METAL6_1400000_449000 METAL6_1412000_449000 0.024
R_VDD1_89 METAL6_1412000_449000 METAL6_1419700_449000 0.0154
R_VDD1_90 METAL6_1419700_449000 METAL6_1424000_449000 0.0086
R_VDD1_91 METAL6_1424000_449000 METAL6_1431700_449000 0.0154
R_VDD1_92 METAL6_1431700_449000 METAL6_1432800_449000 0.0022
R_VDD1_93 METAL6_1432800_449000 METAL6_1443700_449000 0.0218
R_VDD1_94 METAL6_1443700_449000 METAL6_1479400_449000 0.0714
R_VDD1_95 METAL6_1479400_449000 METAL6_1488000_449000 0.0172
R_VDD1_96 METAL6_1488000_449000 METAL6_1491400_449000 0.0068
R_VDD1_97 METAL6_1491400_449000 METAL6_1498300_449000 0.0138
R_VDD1_98 METAL6_1498300_449000 METAL6_1500000_449000 0.0034
R_VDD1_99 METAL6_1500000_449000 METAL6_1503400_449000 0.0068
R_VDD1_100 METAL6_1503400_449000 METAL6_1510400_449000 0.014
R_VDD1_101 METAL6_1510400_449000 METAL6_1512000_449000 0.0032
R_VDD1_102 METAL6_1512000_449000 METAL6_1527800_449000 0.0316
R_VDD1_103 METAL6_1527800_449000 METAL6_1539800_449000 0.024
R_VDD1_104 METAL6_1539800_449000 METAL6_1551800_449000 0.024
R_VDD1_105 METAL6_1551800_449000 METAL6_1555400_449000 0.0072
R_VDD1_106 METAL6_1555400_449000 METAL6_1557000_449000 0.0032
R_VDD1_107 METAL6_1557000_449000 METAL6_1574700_449000 0.0354
R_VDD1_108 METAL6_1574700_449000 METAL6_1576000_449000 0.0026
R_VDD1_109 METAL6_1576000_449000 METAL5_1576000_449000 0.1
R_VDD1_110 METAL5_1576000_449000 METAL5_1576700_449000 0.0028
R_VDD1_111 METAL5_1576700_449000 METAL5_1579800_449000 0.0124
R_VDD1_112 METAL5_1579800_449000 METAL5_1588000_449000 0.0328
R_VDD1_113 METAL5_1588000_449000 METAL5_1588700_449000 0.0028
R_VDD1_114 METAL5_1588700_449000 METAL5_1591800_449000 0.0124
R_VDD1_115 METAL5_1591800_449000 METAL5_1600000_449000 0.0328
R_VDD1_116 METAL5_1600000_449000 METAL6_1600000_449000 0.1
R_VDD1_117 METAL6_1600000_449000 METAL6_1600700_449000 0.0014
R_VDD1_118 METAL6_1600700_449000 METAL6_1603800_449000 0.0062
R_VDD1_119 METAL6_1603800_449000 METAL6_1607900_449000 0.0082
R_VDD1_120 METAL6_1607900_449000 METAL6_1612000_449000 0.0082
R_VDD1_121 METAL6_1612000_449000 METAL6_1612700_449000 0.0014
R_VDD1_122 METAL6_1612700_449000 METAL6_1615800_449000 0.0062
R_VDD1_123 METAL6_1615800_449000 METAL6_1627800_449000 0.024
R_VDD1_124 METAL6_1627800_449000 METAL6_1632800_449000 0.01
R_VDD1_125 METAL6_1632800_449000 METAL6_1634800_449000 0.004
R_VDD1_126 METAL6_1634800_449000 METAL6_1646800_449000 0.024
R_VDD1_127 METAL6_1646800_449000 METAL6_1658800_449000 0.024
R_VDD1_128 METAL6_1658800_449000 METAL6_1668000_449000 0.0184
R_VDD1_129 METAL6_1668000_449000 METAL6_1670800_449000 0.0056
R_VDD1_130 METAL6_1670800_449000 METAL6_1680000_449000 0.0184
R_VDD1_131 METAL6_1680000_449000 METAL6_1692000_449000 0.024
R_VDD1_132 METAL6_1692000_449000 METAL6_1699000_449000 0.014
R_VDD1_133 METAL6_1699000_449000 METAL6_1707700_449000 0.0174
R_VDD1_134 METAL6_1707700_449000 METAL6_1710800_449000 0.0062
R_VDD1_135 METAL6_1710800_449000 METAL6_1717800_449000 0.014
R_VDD1_136 METAL6_1717800_449000 METAL6_1719700_449000 0.0038
R_VDD1_137 METAL6_1719700_449000 METAL6_1727800_449000 0.0162
R_VDD1_138 METAL6_1727800_449000 METAL6_1729800_449000 0.004
R_VDD1_139 METAL6_1729800_449000 METAL6_1731700_449000 0.0038
R_VDD1_140 METAL6_1731700_449000 METAL6_1739800_449000 0.0162
R_VDD1_141 METAL6_1739800_449000 METAL6_1741800_449000 0.004
R_VDD1_142 METAL6_1741800_449000 METAL6_1743700_449000 0.0038
R_VDD1_143 METAL6_1743700_449000 METAL6_1744000_449000 0.0006
R_VDD1_144 METAL6_1744000_449000 METAL6_1751400_449000 0.0148
R_VDD1_145 METAL6_1751400_449000 METAL6_1751400_453000 0.008
R_VDD1_146 METAL6_1751400_453000 METAL6_1751400_459000 0.012
R_VDD1_147 METAL6_1751400_459000 METAL6_1751400_461000 0.004
R_VDD1_148 METAL6_1751400_461000 METAL6_1751400_465000 0.008
R_VDD1_149 METAL6_1751400_465000 METAL6_1751400_468400 0.0068
R_VDD1_150 METAL6_1751400_468400 METAL6_1751400_471000 0.0052
R_VDD1_151 METAL6_1751400_471000 METAL6_1751400_477000 0.012
R_VDD1_152 METAL6_1751400_477000 METAL6_1751400_480400 0.0068
R_VDD1_153 METAL6_1751400_480400 METAL6_1751400_483000 0.0052
R_VDD1_154 METAL6_1751400_483000 METAL6_1751400_488000 0.01
R_VDD1_155 METAL6_1751400_488000 METAL6_1751400_492400 0.0088
R_VDD1_156 METAL6_1751400_492400 METAL6_1751400_495000 0.0052
R_VDD1_157 METAL6_1751400_495000 METAL6_1751400_500000 0.01
R_VDD1_158 METAL6_1751400_500000 METAL6_1751400_504000 0.008
R_VDD1_159 METAL6_1751400_504000 METAL6_1751400_507000 0.006
R_VDD1_160 METAL6_1751400_507000 METAL6_1751400_507800 0.0016
R_VDD1_161 METAL6_1751400_507800 METAL6_1751400_512000 0.0084
R_VDD1_162 METAL6_1751400_512000 METAL6_1751400_516000 0.008
R_VDD1_163 METAL6_1751400_516000 METAL6_1751400_519000 0.006
R_VDD1_164 METAL6_1751400_519000 METAL6_1751400_520200 0.0024
R_VDD1_165 METAL6_1751400_520200 METAL6_1751400_528000 0.0156
R_VDD1_166 METAL6_1751400_528000 METAL6_1751400_532200 0.0084
R_VDD1_167 METAL6_1751400_532200 METAL6_1751400_535400 0.0064
R_VDD1_168 METAL6_1751400_535400 METAL6_1751400_544200 0.0176
R_VDD1_169 METAL6_1751400_544200 METAL6_1751400_547400 0.0064
R_VDD1_170 METAL6_1751400_547400 METAL6_1751400_550400 0.006
R_VDD1_171 METAL6_1751400_550400 METAL6_1751400_556200 0.0116
R_VDD1_172 METAL6_1751400_556200 METAL6_1751400_559400 0.0064
R_VDD1_173 METAL6_1751400_559400 METAL6_1751400_561000 0.0032
R_VDD1_174 METAL6_1751400_561000 METAL6_1751400_562400 0.0028
R_VDD1_175 METAL6_1751400_562400 METAL6_1751400_573000 0.0212
R_VDD1_176 METAL6_1751400_573000 METAL6_1751400_574400 0.0028
R_VDD1_177 METAL6_1751400_574400 METAL6_1751400_579800 0.0108
R_VDD1_178 METAL6_1751400_579800 METAL6_1751400_585000 0.0104
R_VDD1_179 METAL6_1751400_585000 METAL6_1751400_586400 0.0028
R_VDD1_180 METAL6_1751400_586400 METAL6_1751400_588000 0.0032
R_VDD1_181 METAL6_1751400_588000 METAL6_1751400_598400 0.0208
R_VDD1_182 METAL6_1751400_598400 METAL6_1751400_600000 0.0032
R_VDD1_183 METAL6_1751400_600000 METAL6_1751400_612000 0.024
R_VDD1_184 METAL6_1751400_612000 METAL6_1751400_637800 0.0516
R_VDD1_185 METAL6_1751400_637800 METAL6_1751400_641400 0.0072
R_VDD1_186 METAL6_1751400_641400 METAL6_1751400_649800 0.0168
R_VDD1_187 METAL6_1751400_649800 METAL6_1751400_653400 0.0072
R_VDD1_188 METAL6_1751400_653400 METAL6_1751400_661800 0.0168
R_VDD1_189 METAL6_1751400_661800 METAL6_1751400_665400 0.0072
R_VDD1_190 METAL6_1751400_665400 METAL6_1751400_688000 0.0452
R_VDD1_191 METAL6_1751400_688000 METAL6_1751400_697800 0.0196
R_VDD1_192 METAL6_1751400_697800 METAL6_1751400_700000 0.0044
R_VDD1_193 METAL6_1751400_700000 METAL6_1751400_702800 0.0056
R_VDD1_194 METAL6_1751400_702800 METAL6_1751400_709800 0.014
R_VDD1_195 METAL6_1751400_709800 METAL6_1751400_712000 0.0044
R_VDD1_196 METAL6_1751400_712000 METAL6_1751400_716800 0.0096
R_VDD1_197 METAL6_1751400_716800 METAL6_1751400_721800 0.01
R_VDD1_198 METAL6_1751400_721800 METAL6_1751400_733800 0.024
R_VDD1_199 METAL6_1751400_733800 METAL6_1751400_735400 0.0032
R_VDD1_200 METAL6_1751400_735400 METAL6_1751400_742400 0.014
R_VDD1_201 METAL6_1751400_742400 METAL6_1751400_745800 0.0068
R_VDD1_202 METAL6_1751400_745800 METAL6_1751400_754400 0.0172
R_VDD1_203 METAL6_1751400_754400 METAL6_1751400_758400 0.008
R_VDD1_204 METAL6_1751400_758400 METAL6_1751800_758400 0.0008
R_VDD1_205 METAL6_1751800_758400 METAL6_1753800_758400 0.004
R_VDD1_206 METAL6_1753800_758400 METAL6_1755700_758400 0.0038
R_VDD1_207 METAL6_1755700_758400 METAL6_1788000_758400 0.0646
R_VDD1_208 METAL6_1788000_758400 METAL6_1800000_758400 0.024
R_VDD1_209 METAL6_1800000_758400 METAL6_1812000_758400 0.024
R_VDD1_210 METAL6_1812000_758400 METAL6_1820800_758400 0.0176
R_VDD1_211 METAL6_1820800_758400 METAL6_1822400_758400 0.0032
R_VDD1_212 METAL6_1822400_758400 METAL6_1822600_758400 0.0004
R_VDD1_213 METAL6_1822600_758400 METAL6_1832800_758400 0.0204
R_VDD1_214 METAL6_1832800_758400 METAL6_1834400_758400 0.0032
R_VDD1_215 METAL6_1834400_758400 METAL6_1834600_758400 0.0004
R_VDD1_216 METAL6_1834600_758400 METAL5_1834600_758400 0.1
R_VDD1_217 METAL5_1834600_758400 METAL5_1841400_758400 0.0272
R_VDD1_218 METAL5_1841400_758400 METAL5_1844800_758400 0.0136
R_VDD1_219 METAL5_1844800_758400 METAL5_1846400_758400 0.0064
R_VDD1_220 METAL5_1846400_758400 METAL5_1846600_758400 0.0008
R_VDD1_221 METAL5_1846600_758400 METAL5_1846800_758400 0.0008
R_VDD1_222 METAL5_1846800_758400 METAL5_1847200_758400 0.0016
R_VDD1_223 METAL5_1847200_758400 METAL5_1852700_758400 0.022
R_VDD1_224 METAL5_1852700_758400 METAL5_1853400_758400 0.0028
R_VDD1_225 METAL5_1853400_758400 METAL5_1858400_758400 0.02
R_VDD1_226 METAL5_1858400_758400 METAL5_1858600_758400 0.0008
R_VDD1_227 METAL5_1858600_758400 METAL5_1859200_758400 0.0024
R_VDD1_228 METAL5_1859200_758400 METAL5_1864700_758400 0.022
R_VDD1_229 METAL5_1864700_758400 METAL5_1865400_758400 0.0028
R_VDD1_230 METAL5_1865400_758400 METAL5_1865600_758400 0.0008
R_VDD1_231 METAL5_1865600_758400 METAL5_1870600_758400 0.02
R_VDD1_232 METAL5_1870600_758400 METAL5_1871200_758400 0.0024
R_VDD1_233 METAL5_1871200_758400 METAL5_1874700_758400 0.014
R_VDD1_234 METAL5_1874700_758400 METAL5_1876700_758400 0.008
R_VDD1_235 METAL5_1876700_758400 METAL6_1876700_758400 0.1
R_VDD1_236 METAL6_1876700_758400 METAL6_1876700_763000 0.0092
R_VDD1_237 METAL6_1876700_763000 METAL6_1876700_766400 0.0068
R_VDD1_238 METAL6_1876700_766400 METAL6_1876700_770400 0.008
R_VDD1_239 METAL6_1876700_770400 METAL6_1876700_772000 0.0032
R_VDD1_240 METAL6_1876700_772000 METAL6_1876700_778400 0.0128
R_VDD1_241 METAL6_1876700_778400 METAL6_1876700_779200 0.0016
R_VDD1_242 METAL6_1876700_779200 METAL6_1876700_782400 0.0064
R_VDD1_243 METAL6_1876700_782400 METAL6_1877400_782400 0.0014
R_VDD1_244 METAL6_1877400_782400 METAL6_1877600_782400 0.0004
R_VDD1_245 METAL6_1877600_782400 METAL6_1883200_782400 0.0112
R_VDD1_246 METAL6_1883200_782400 METAL6_1888700_782400 0.011
R_VDD1_247 METAL6_1888700_782400 METAL6_1889400_782400 0.0014
R_VDD1_248 METAL6_1889400_782400 METAL6_1889600_782400 0.0004
R_VDD1_249 METAL6_1889600_782400 METAL6_1895200_782400 0.0112
R_VDD1_250 METAL6_1895200_782400 METAL6_1900700_782400 0.011
R_VDD1_251 METAL6_1900700_782400 METAL6_1901600_782400 0.0018
R_VDD1_252 METAL6_1901600_782400 METAL6_1907200_782400 0.0112
R_VDD1_253 METAL6_1907200_782400 METAL6_1907400_782400 0.0004
R_VDD1_254 METAL6_1907400_782400 METAL6_1913600_782400 0.0124
R_VDD1_255 METAL6_1913600_782400 METAL6_1919200_782400 0.0112
R_VDD1_256 METAL6_1919200_782400 METAL6_1925600_782400 0.0128
R_VDD1_257 METAL6_1925600_782400 METAL6_1925600_784500 0.0042
R_VDD1_258 METAL6_1925600_784500 METAL6_1925600_788000 0.007
R_VDD1_259 METAL6_1925600_788000 METAL6_1925600_790400 0.0048
R_VDD1_260 METAL6_1925600_790400 METAL6_1925600_791200 0.0016
R_VDD1_261 METAL6_1925600_791200 METAL6_1925600_794400 0.0064
R_VDD1_262 METAL6_1925600_794400 METAL6_1926200_794400 0.0012
R_VDD1_263 METAL6_1926200_794400 METAL6_1927800_794400 0.0032
R_VDD1_264 METAL6_1927800_794400 METAL6_1931200_794400 0.0068
R_VDD1_265 METAL6_1931200_794400 METAL6_1939800_794400 0.0172
R_VDD1_266 METAL6_1939800_794400 METAL6_1939800_794800 0.0008
R_VDD1_267 METAL6_1939800_794800 METAL6_1939800_800000 0.0104
R_VDD1_268 METAL6_1939800_800000 METAL6_1939800_802400 0.0048
R_VDD1_269 METAL6_1939800_802400 METAL6_1939800_803200 0.0016
R_VDD1_270 METAL6_1939800_803200 METAL6_1939800_806400 0.0064
R_VDD1_271 METAL6_1939800_806400 METAL6_1939800_808000 0.0032
R_VDD1_272 METAL6_1939800_808000 METAL6_1939800_812000 0.008
R_VDD1_273 METAL6_1939800_812000 METAL6_1939800_814400 0.0048
R_VDD1_274 METAL6_1939800_814400 METAL6_1939800_818400 0.008
R_VDD1_275 METAL6_1939800_818400 METAL6_1939800_820000 0.0032
R_VDD1_276 METAL6_1939800_820000 METAL6_1939800_830400 0.0208
R_VDD1_277 METAL6_1939800_830400 METAL6_1939800_832000 0.0032
R_VDD1_278 METAL6_1939800_832000 METAL6_1939800_839500 0.015
R_VDD1_279 METAL6_1939800_839500 METAL6_1939800_840700 0.0024
R_VDD1_280 METAL6_1939800_840700 METAL6_1939800_851500 0.0216
R_VDD1_281 METAL6_1939800_851500 METAL6_1939800_858200 0.0134
R_VDD1_282 METAL6_1939800_858200 METAL6_1939800_863500 0.0106
R_VDD1_283 METAL6_1939800_863500 METAL6_1939800_887000 0.047
R_VDD1_284 METAL6_1939800_887000 METAL6_1939800_888000 0.002
R_VDD1_285 METAL6_1939800_888000 METAL6_1939800_900000 0.024
R_VDD1_286 METAL6_1939800_900000 METAL6_1939800_900400 0.0008
R_VDD1_287 METAL6_1939800_900400 METAL6_1939800_912000 0.0232
R_VDD1_288 METAL6_1939800_912000 METAL6_1939800_927300 0.0306
R_VDD1_289 METAL6_1939800_927300 METAL6_1939800_947000 0.0394
R_VDD1_290 METAL6_1939800_947000 METAL6_1939800_959000 0.024
R_VDD1_291 METAL6_1939800_959000 METAL6_1939800_971000 0.024
R_VDD1_292 METAL6_1939800_971000 METAL6_1939800_976000 0.01
R_VDD1_293 METAL6_1939800_976000 METAL6_1939800_988000 0.024
R_VDD1_294 METAL6_1939800_988000 METAL6_1939800_995000 0.014
R_VDD1_295 METAL6_1939800_995000 METAL6_1939800_1000000 0.01
R_VDD1_296 METAL6_1939800_1000000 METAL6_1939800_1007000 0.014
R_VDD1_297 METAL6_1939800_1007000 METAL6_1939800_1012000 0.01
R_VDD1_298 METAL6_1939800_1012000 METAL6_1939800_1014000 0.004
R_VDD1_299 METAL6_1939800_1014000 METAL6_1939800_1019000 0.01
R_VDD1_300 METAL6_1939800_1019000 METAL6_1939800_1023700 0.0094
R_VDD1_301 METAL6_1939800_1023700 METAL6_1939800_1025400 0.0034
R_VDD1_302 METAL6_1939800_1025400 METAL6_1939800_1026000 0.0012
R_VDD1_303 METAL6_1939800_1026000 METAL6_1939800_1029800 0.0076
R_VDD1_304 METAL6_1939800_1029800 METAL6_1939800_1031000 0.0024
R_VDD1_305 METAL6_1939800_1031000 METAL6_1939800_1035700 0.0094
R_VDD1_306 METAL6_1939800_1035700 METAL6_1939800_1037400 0.0034
R_VDD1_307 METAL6_1939800_1037400 METAL6_1939800_1038000 0.0012
R_VDD1_308 METAL6_1939800_1038000 METAL6_1939800_1041800 0.0076
R_VDD1_309 METAL6_1939800_1041800 METAL6_1939800_1042700 0.0018
R_VDD1_310 METAL6_1939800_1042700 METAL6_1939800_1047700 0.01
R_VDD1_311 METAL6_1939800_1047700 METAL6_1939800_1049400 0.0034
R_VDD1_312 METAL6_1939800_1049400 METAL6_1939800_1049800 0.0008
R_VDD1_313 METAL6_1939800_1049800 METAL6_1939800_1053800 0.008
R_VDD1_314 METAL6_1939800_1053800 METAL6_1939800_1054700 0.0018
R_VDD1_315 METAL6_1939800_1054700 METAL6_1939800_1061400 0.0134
R_VDD1_316 METAL6_1939800_1061400 METAL6_1939800_1061800 0.0008
R_VDD1_317 METAL6_1939800_1061800 METAL6_1939800_1066700 0.0098
R_VDD1_318 METAL6_1939800_1066700 METAL6_1939800_1073800 0.0142
R_VDD1_319 METAL6_1939800_1073800 METAL6_1939800_1074000 0.0004
R_VDD1_320 METAL6_1939800_1074000 METAL6_1939800_1086000 0.024
R_VDD1_321 METAL6_1939800_1086000 METAL6_1939800_1086300 0.0006
R_VDD1_322 METAL6_1939800_1086300 METAL6_1939800_1086500 0.0004
R_VDD1_323 METAL6_1939800_1086500 METAL6_1939800_1088000 0.003
R_VDD1_324 METAL6_1939800_1088000 METAL6_1939800_1096800 0.0176
R_VDD1_325 METAL6_1939800_1096800 METAL6_1939800_1098000 0.0024
R_VDD1_326 METAL6_1939800_1098000 METAL6_1939800_1098300 0.0006
R_VDD1_327 METAL6_1939800_1098300 METAL6_1939800_1098500 0.0004
R_VDD1_328 METAL6_1939800_1098500 METAL6_1939800_1100000 0.003
R_VDD1_329 METAL6_1939800_1100000 METAL6_1939800_1108800 0.0176
R_VDD1_330 METAL6_1939800_1108800 METAL6_1939800_1110300 0.003
R_VDD1_331 METAL6_1939800_1110300 METAL6_1939900_1110300 0.0002
R_VDD1_332 METAL6_1939900_1110300 METAL6_1951800_1110300 0.0238
R_VDD1_333 METAL6_1951800_1110300 METAL6_1951900_1110300 0.0002
R_VDD1_334 METAL6_1951900_1110300 METAL6_1963900_1110300 0.024
R_VDD1_335 METAL6_1963900_1110300 METAL6_1988000_1110300 0.0482
R_VDD1_336 METAL6_1988000_1110300 METAL6_2000000_1110300 0.024
R_VDD1_337 METAL6_2000000_1110300 METAL6_2002400_1110300 0.0048
R_VDD1_338 METAL6_2002400_1110300 METAL6_2006900_1110300 0.009
R_VDD1_339 METAL6_2006900_1110300 METAL6_2007700_1110300 0.0016
R_VDD1_340 METAL6_2007700_1110300 METAL6_2012000_1110300 0.0086
R_VDD1_341 METAL6_2012000_1110300 METAL6_2014400_1110300 0.0048
R_VDD1_342 METAL6_2014400_1110300 METAL6_2018900_1110300 0.009
R_VDD1_343 METAL6_2018900_1110300 METAL6_2019700_1110300 0.0016
R_VDD1_344 METAL6_2019700_1110300 METAL6_2021200_1110300 0.003
R_VDD1_345 METAL6_2021200_1110300 METAL6_2026400_1110300 0.0104
R_VDD1_346 METAL6_2026400_1110300 METAL6_2030900_1110300 0.009
R_VDD1_347 METAL6_2030900_1110300 METAL6_2031700_1110300 0.0016
R_VDD1_348 METAL6_2031700_1110300 METAL6_2034800_1110300 0.0062
R_VDD1_349 METAL6_2034800_1110300 METAL6_2043700_1110300 0.0178
R_VDD1_350 METAL6_2043700_1110300 METAL6_2046400_1110300 0.0054
R_VDD1_351 METAL6_2046400_1110300 METAL6_2046600_1110300 0.0004
R_VDD1_352 METAL6_2046600_1110300 METAL6_2046800_1110300 0.0004
R_VDD1_353 METAL6_2046800_1110300 METAL6_2055700_1110300 0.0178
R_VDD1_354 METAL6_2055700_1110300 METAL6_2058800_1110300 0.0062
R_VDD1_355 METAL6_2058800_1110300 METAL6_2060600_1110300 0.0036
R_VDD1_356 METAL6_2060600_1110300 METAL6_2067700_1110300 0.0142
R_VDD1_357 METAL6_2067700_1110300 METAL6_2077900_1110300 0.0204
R_VDD1_358 METAL6_2077900_1110300 METAL6_2079700_1110300 0.0036
R_VDD1_359 METAL6_2079700_1110300 METAL6_2089900_1110300 0.0204
R_VDD1_360 METAL6_2089900_1110300 METAL6_2101600_1110300 0.0234
R_VDD1_361 METAL6_2101600_1110300 METAL6_2101900_1110300 0.0006
R_VDD1_362 METAL6_2101900_1110300 METAL6_2105900_1110300 0.008
R_VDD1_363 METAL6_2105900_1110300 METAL6_2113600_1110300 0.0154
R_VDD1_364 METAL6_2113600_1110300 METAL6_2113900_1110300 0.0006
R_VDD1_365 METAL6_2113900_1110300 METAL6_2117900_1110300 0.008
R_VDD1_366 METAL6_2117900_1110300 METAL6_2121400_1110300 0.007
R_VDD1_367 METAL6_2121400_1110300 METAL6_2125600_1110300 0.0084
R_VDD1_368 METAL6_2125600_1110300 METAL6_2129700_1110300 0.0082
R_VDD1_369 METAL6_2129700_1110300 METAL6_2129900_1110300 0.0004
R_VDD1_370 METAL6_2129900_1110300 METAL6_2141400_1110300 0.023
R_VDD1_371 METAL6_2141400_1110300 METAL6_2141900_1110300 0.001
R_VDD1_372 METAL6_2141900_1110300 METAL6_2151900_1110300 0.02
R_VDD1_373 METAL6_2151900_1110300 METAL6_2153400_1110300 0.003
R_VDD1_374 METAL6_2153400_1110300 METAL6_2153900_1110300 0.001
R_VDD1_375 METAL6_2153900_1110300 METAL6_2165400_1110300 0.023
R_VDD1_376 METAL6_2165400_1110300 METAL6_2165900_1110300 0.001
R_VDD1_377 METAL6_2165900_1110300 METAL6_2176700_1110300 0.0216
R_VDD1_378 METAL6_2176700_1110300 METAL6_2177900_1110300 0.0024
R_VDD1_379 METAL6_2177900_1110300 METAL6_2188700_1110300 0.0216
R_VDD1_380 METAL6_2188700_1110300 METAL6_2189900_1110300 0.0024
R_VDD1_381 METAL6_2189900_1110300 METAL6_2200700_1110300 0.0216
R_VDD1_382 METAL6_2200700_1110300 METAL5_2200700_1110300 0.1
R_VDD1_383 METAL5_2200700_1110300 METAL5_2209900_1110300 0.0368
R_VDD1_384 METAL5_2209900_1110300 METAL5_2210600_1110300 0.0028
R_VDD1_385 METAL5_2210600_1110300 METAL5_2212700_1110300 0.0084
R_VDD1_386 METAL5_2212700_1110300 METAL5_2221900_1110300 0.0368
R_VDD1_387 METAL5_2221900_1110300 METAL5_2222600_1110300 0.0028
R_VDD1_388 METAL5_2222600_1110300 METAL5_2224700_1110300 0.0084
R_VDD1_389 METAL5_2224700_1110300 METAL6_2224700_1110300 0.1
R_VDD1_390 METAL6_2224700_1110300 METAL6_2233900_1110300 0.0184
R_VDD1_391 METAL6_2233900_1110300 METAL6_2234600_1110300 0.0014
R_VDD1_392 METAL6_2234600_1110300 METAL6_2236600_1110300 0.004
R_VDD1_393 METAL6_2236600_1110300 METAL6_2236600_1110500 0.0004
R_VDD1_394 METAL6_2236600_1110500 METAL6_2236600_1112000 0.003
R_VDD1_395 METAL6_2236600_1112000 METAL6_2236600_1120800 0.0176
R_VDD1_396 METAL6_2236600_1120800 METAL6_2236600_1122300 0.003
R_VDD1_397 METAL6_2236600_1122300 METAL6_2236600_1122500 0.0004
R_VDD1_398 METAL6_2236600_1122500 METAL6_2236600_1129300 0.0136
R_VDD1_399 METAL6_2236600_1129300 METAL6_2236600_1132800 0.007
R_VDD1_400 METAL6_2236600_1132800 METAL6_2236600_1134300 0.003
R_VDD1_401 METAL6_2236600_1134300 METAL6_2236600_1141300 0.014
R_VDD1_402 METAL6_2236600_1141300 METAL6_2236600_1153300 0.024
R_VDD1_403 METAL6_2236600_1153300 METAL6_2236600_1160600 0.0146
R_VDD1_404 METAL6_2236600_1160600 METAL6_2236600_1169700 0.0182
R_VDD1_405 METAL6_2236600_1169700 METAL6_2236600_1172600 0.0058
R_VDD1_406 METAL6_2236600_1172600 METAL6_2236600_1181700 0.0182
R_VDD1_407 METAL6_2236600_1181700 METAL6_2236600_1184600 0.0058
R_VDD1_408 METAL6_2236600_1184600 METAL6_2236600_1191600 0.014
R_VDD1_409 METAL6_2236600_1191600 METAL6_2236600_1193700 0.0042
R_VDD1_410 METAL6_2236600_1193700 METAL6_2236600_1193800 0.0002
R_VDD1_411 METAL6_2236600_1193800 METAL6_2236600_1205700 0.0238
R_VDD1_412 METAL6_2236600_1205700 METAL6_2236600_1217700 0.024
R_VDD1_413 METAL6_2236600_1217700 METAL6_2236600_1223700 0.012
R_VDD1_414 METAL6_2236600_1223700 METAL6_2236600_1229700 0.012
R_VDD1_415 METAL6_2236600_1229700 METAL6_2236600_1235700 0.012
R_VDD1_416 METAL6_2236600_1235700 METAL6_2236600_1238000 0.0046
R_VDD1_417 METAL6_2236600_1238000 METAL6_2236600_1247700 0.0194
R_VDD1_418 METAL6_2236600_1247700 METAL6_2236600_1250000 0.0046
R_VDD1_419 METAL6_2236600_1250000 METAL6_2236600_1259700 0.0194
R_VDD1_420 METAL6_2236600_1259700 METAL6_2236600_1261000 0.0026
R_VDD1_421 METAL6_2236600_1261000 METAL6_2236600_1262000 0.002
R_VDD1_422 METAL6_2236600_1262000 METAL6_2236600_1271700 0.0194
R_VDD1_423 METAL6_2236600_1271700 METAL6_2236600_1273000 0.0026
R_VDD1_424 METAL6_2236600_1273000 METAL6_2236600_1283700 0.0214
R_VDD1_425 METAL6_2236600_1283700 METAL6_2236600_1285000 0.0026
R_VDD1_426 METAL6_2236600_1285000 METAL6_2236600_1295700 0.0214
R_VDD1_427 METAL6_2236600_1295700 METAL5_2236600_1295700 0.1
R_VDD1_428 METAL5_2236600_1295700 METAL5_2236700_1295700 0.0004
R_VDD1_429 METAL5_2236700_1295700 METAL5_2246600_1295700 0.0396
R_VDD1_430 METAL5_2246600_1295700 METAL5_2248400_1295700 0.0072
R_VDD1_431 METAL5_2248400_1295700 METAL5_2248600_1295700 0.0008
R_VDD1_432 METAL5_2248600_1295700 METAL5_2248700_1295700 0.0004
R_VDD1_433 METAL5_2248700_1295700 METAL5_2258600_1295700 0.0396
R_VDD1_434 METAL5_2258600_1295700 METAL5_2260400_1295700 0.0072
R_VDD1_435 METAL5_2260400_1295700 METAL5_2260600_1295700 0.0008
R_VDD1_436 METAL5_2260600_1295700 METAL5_2272400_1295700 0.0472
R_VDD1_437 METAL5_2272400_1295700 METAL5_2272600_1295700 0.0008
R_VDD1_438 METAL5_2272600_1295700 METAL5_2284400_1295700 0.0472
R_VDD1_439 METAL5_2284400_1295700 METAL5_2284600_1295700 0.0008
R_VDD1_440 METAL5_2284600_1295700 METAL5_2286900_1295700 0.0092
R_VDD1_441 METAL5_2286900_1295700 METAL5_2296600_1295700 0.0388
R_VDD1_442 METAL5_2296600_1295700 METAL6_2296600_1295700 0.1
R_VDD1_443 METAL6_2296600_1295700 METAL6_2296600_1302000 0.0126
R_VDD1_444 METAL6_2296600_1302000 METAL6_2296600_1307700 0.0114
R_VDD1_445 METAL6_2296600_1307700 METAL6_2296600_1314000 0.0126
R_VDD1_446 METAL6_2296600_1314000 METAL6_2296600_1326000 0.024
R_VDD1_447 METAL6_2296600_1326000 METAL6_2296600_1338000 0.024
R_VDD1_448 METAL6_2296600_1338000 METAL6_2296600_1350000 0.024
R_VDD1_449 METAL6_2296600_1350000 METAL6_2296600_1357000 0.014
R_VDD1_450 METAL6_2296600_1357000 METAL6_2296600_1362000 0.01
R_VDD1_451 METAL6_2296600_1362000 METAL6_2296600_1369000 0.014
R_VDD1_452 METAL6_2296600_1369000 METAL6_2296600_1374000 0.01
R_VDD1_453 METAL6_2296600_1374000 METAL6_2296600_1381000 0.014
R_VDD1_454 METAL6_2296600_1381000 METAL6_2296600_1386600 0.0112
R_VDD1_455 METAL6_2296600_1386600 METAL6_2296600_1393000 0.0128
R_VDD1_456 METAL6_2296600_1393000 METAL6_2296600_1405000 0.024
R_VDD1_457 METAL6_2296600_1405000 METAL6_2296600_1437700 0.0654
R_VDD1_458 METAL6_2296600_1437700 METAL6_2296600_1449700 0.024
R_VDD1_459 METAL6_2296600_1449700 METAL6_2296600_1461700 0.024
R_VDD1_460 METAL6_2296600_1461700 METAL6_2296600_1492300 0.0612
R_VDD1_461 METAL6_2296600_1492300 METAL6_2296600_1504300 0.024
R_VDD1_462 METAL6_2296600_1504300 METAL6_2296600_1516300 0.024
R_VDD1_463 METAL6_2296600_1516300 METAL6_2296600_1528300 0.024
R_VDD1_464 METAL6_2296600_1528300 METAL6_2298900_1528300 0.0046
R_VDD1_465 METAL6_2298900_1528300 METAL6_2308600_1528300 0.0194
R_VDD1_466 METAL6_2308600_1528300 METAL6_2310900_1528300 0.0046
R_VDD1_467 METAL6_2310900_1528300 METAL6_2343700_1528300 0.0656
R_VDD1_468 METAL6_2343700_1528300 METAL6_2351900_1528300 0.0164
R_VDD1_469 METAL6_2351900_1528300 METAL6_2357600_1528300 0.0114
R_VDD1_470 METAL6_2357600_1528300 METAL6_2365900_1528300 0.0166
R_VDD1_471 METAL6_2365900_1528300 METAL6_2369600_1528300 0.0074
R_VDD1_472 METAL6_2369600_1528300 METAL6_2371100_1528300 0.003
R_VDD1_473 METAL6_2371100_1528300 METAL6_2381600_1528300 0.021
R_VDD1_474 METAL6_2381600_1528300 METAL6_2383100_1528300 0.003
R_VDD1_475 METAL6_2383100_1528300 METAL6_2393600_1528300 0.021
R_VDD1_476 METAL6_2393600_1528300 METAL6_2395100_1528300 0.003
R_VDD1_477 METAL6_2395100_1528300 METAL6_2402100_1528300 0.014
R_VDD1_478 METAL6_2402100_1528300 METAL6_2405600_1528300 0.007
R_VDD1_479 METAL6_2405600_1528300 METAL6_2407100_1528300 0.003
R_VDD1_480 METAL6_2407100_1528300 METAL6_2419100_1528300 0.024
R_VDD1_481 METAL6_2419100_1528300 METAL6_2436600_1528300 0.035
R_VDD1_482 METAL6_2436600_1528300 METAL6_2436600_1540300 0.024
R_VDD1_483 METAL6_2436600_1540300 METAL6_2436600_1552300 0.024
R_VDD1_484 METAL6_2436600_1552300 METAL6_2436600_1554500 0.0044
R_VDD1_485 METAL6_2436600_1554500 METAL6_2436600_1564300 0.0196
R_VDD1_486 METAL6_2436600_1564300 METAL6_2436600_1571300 0.014
R_VDD1_487 METAL6_2436600_1571300 METAL6_2436600_1576300 0.01
R_VDD1_488 METAL6_2436600_1576300 METAL6_2436600_1714500 0.2764
R_VDD1_489 METAL6_2436600_1714500 METAL6_2436600_1720500 0.012
R_VDD1_490 METAL6_2436600_1720500 METAL6_2436600_1726500 0.012
R_VDD1_491 METAL6_2436600_1726500 METAL6_2436600_1731700 0.0104
R_VDD1_492 METAL6_2436600_1731700 METAL6_2436600_1738500 0.0136
R_VDD1_493 METAL6_2436600_1738500 METAL6_2436600_1750500 0.024
R_VDD1_494 METAL6_2436600_1750500 METAL6_2436600_1762500 0.024
R_VDD1_495 METAL6_2436600_1762500 METAL6_2436600_1774500 0.024
R_VDD1_496 METAL6_2436600_1774500 METAL6_2436600_1802500 0.056
R_VDD1_497 METAL6_2436600_1802500 METAL6_2436600_1814500 0.024
R_VDD1_498 METAL6_2436600_1814500 METAL6_2436600_1826500 0.024
R_VDD1_499 METAL6_2436600_1826500 METAL6_2436600_1838500 0.024
R_VDD1_500 METAL6_2436600_1838500 METAL6_2436600_1852300 0.0276
R_VDD1_501 METAL6_2436600_1852300 METAL6_2436600_1866300 0.028
R_VDD1_502 METAL6_2436600_1866300 METAL6_2436600_1902500 0.0724
R_VDD1_503 METAL6_2436600_1902500 METAL6_2436600_1914500 0.024
R_VDD1_504 METAL6_2436600_1914500 METAL6_2436600_1926500 0.024
R_VDD1_505 METAL6_2436600_1926500 METAL6_2436600_1938500 0.024
R_VDD1_506 METAL6_2436600_1938500 METAL5_2436600_1938500 0.1
R_VDD1_507 METAL5_2436600_1938500 METAL5_2436600_1940500 0.008
R_VDD1_508 METAL5_2436600_1940500 METAL5_2436600_1950500 0.04
R_VDD1_509 METAL5_2436600_1950500 METAL5_2436600_1951000 0.002
R_VDD1_510 METAL5_2436600_1951000 METAL5_2436600_1952500 0.006
R_VDD1_511 METAL5_2436600_1952500 METAL5_2436600_1962500 0.04
R_VDD1_512 METAL5_2436600_1962500 METAL5_2436600_1963000 0.002
R_VDD1_513 METAL5_2436600_1963000 METAL5_2436600_1964500 0.006
R_VDD1_514 METAL5_2436600_1964500 METAL5_2436600_1975000 0.042
R_VDD1_515 METAL5_2436600_1975000 METAL5_2436600_1976500 0.006
R_VDD1_516 METAL5_2436600_1976500 METAL6_2436600_1976500 0.1
R_VDD1_517 METAL6_2436600_1976500 METAL6_2436600_1987000 0.021
R_VDD1_518 METAL6_2436600_1987000 METAL6_2436600_2014500 0.055
R_VDD1_519 METAL6_2436600_2014500 METAL6_2436600_2026500 0.024
R_VDD1_520 METAL6_2436600_2026500 METAL6_2436600_2038500 0.024
R_VDD1_521 METAL6_2436600_2038500 METAL6_2436600_2114500 0.152
R_VDD1_522 METAL6_2436600_2114500 METAL6_2436600_2126500 0.024
R_VDD1_523 METAL6_2436600_2126500 METAL6_2436600_2138500 0.024
R_VDD1_524 METAL6_2436600_2138500 METAL6_2446600_2138500 0.02
R_VDD1_525 METAL6_2446600_2138500 METAL6_2446600_2147300 0.0176
R_VDD1_526 METAL6_2446600_2147300 METAL6_2446600_2150500 0.0064
R_VDD1_527 METAL6_2446600_2150500 METAL6_2446600_2154300 0.0076
R_VDD1_528 METAL6_2446600_2154300 METAL6_2446600_2163000 0.0174
R_VDD1_529 METAL6_2446600_2163000 METAL6_2446600_2166300 0.0066
R_VDD1_530 METAL6_2446600_2166300 METAL6_2446600_2175000 0.0174
R_VDD1_531 METAL6_2446600_2175000 METAL6_2446600_2178300 0.0066
R_VDD1_532 METAL6_2446600_2178300 METAL6_2446600_2187000 0.0174
R_VDD1_533 METAL6_2446600_2187000 METAL6_2446600_2190300 0.0066
R_VDD1_534 METAL6_2446600_2190300 METAL6_2446600_2202300 0.024
R_VDD1_535 METAL6_2446600_2202300 METAL6_2446600_2222500 0.0404
R_VDD1_536 METAL6_2446600_2222500 METAL6_2446600_2234500 0.024
R_VDD1_537 METAL6_2446600_2234500 METAL6_2446600_2246500 0.024
R_VDD1_538 METAL6_2446600_2246500 METAL6_2446600_2268500 0.044
R_VDD1_539 METAL6_2446600_2268500 METAL6_2446600_2276000 0.015
R_VDD1_540 METAL6_2446600_2276000 METAL6_2446600_2288000 0.024
R_VDD1_541 METAL6_2446600_2288000 METAL6_2446600_2300000 0.024
R_VDD1_542 METAL6_2446600_2300000 METAL6_2446600_2304000 0.008
R_VDD1_543 METAL6_2446600_2304000 METAL5_2446600_2304000 0.1
R_VDD1_544 METAL5_2446600_2304000 METAL5_2446600_2305000 0.004
R_VDD1_545 METAL5_2446600_2305000 METAL5_2446600_2312000 0.028
R_VDD1_546 METAL5_2446600_2312000 METAL5_2446600_2314000 0.008
R_VDD1_547 METAL5_2446600_2314000 METAL5_2446600_2316000 0.008
R_VDD1_548 METAL5_2446600_2316000 METAL5_2446600_2317000 0.004
R_VDD1_549 METAL5_2446600_2317000 METAL5_2446600_2326000 0.036
R_VDD1_550 METAL5_2446600_2326000 METAL5_2446600_2328000 0.008
R_VDD1_551 METAL5_2446600_2328000 METAL6_2446600_2328000 0.1
R_VDD1_552 METAL6_2446600_2328000 METAL6_2448600_2328000 0.004
R_VDD1_553 METAL6_2448600_2328000 METAL6_2460600_2328000 0.024
R_VDD1_554 METAL6_2460600_2328000 METAL6_2464000_2328000 0.0068
R_VDD1_555 METAL6_2464000_2328000 METAL6_2465600_2328000 0.0032
R_VDD1_556 METAL6_2465600_2328000 METAL6_2469000_2328000 0.0068
R_VDD1_557 METAL6_2469000_2328000 METAL6_2472600_2328000 0.0072
R_VDD1_558 METAL6_2472600_2328000 METAL6_2476000_2328000 0.0068
R_VDD1_559 METAL6_2476000_2328000 METAL6_2477600_2328000 0.0032
R_VDD1_560 METAL6_2477600_2328000 METAL6_2481000_2328000 0.0068
R_VDD1_561 METAL6_2481000_2328000 METAL6_2486900_2328000 0.0118
R_VDD1_562 METAL6_2486900_2328000 METAL6_2488000_2328000 0.0022
R_VDD1_563 METAL6_2488000_2328000 METAL6_2489600_2328000 0.0032
R_VDD1_564 METAL6_2489600_2328000 METAL6_2493000_2328000 0.0068
R_VDD1_565 METAL6_2493000_2328000 METAL6_2498900_2328000 0.0118
R_VDD1_566 METAL6_2498900_2328000 METAL6_2500000_2328000 0.0022
R_VDD1_567 METAL6_2500000_2328000 METAL6_2501600_2328000 0.0032
R_VDD1_568 METAL6_2501600_2328000 METAL6_2504400_2328000 0.0056
R_VDD1_569 METAL6_2504400_2328000 METAL6_2504400_2329000 0.002
R_VDD1_570 METAL6_2504400_2329000 METAL6_2504400_2338000 0.018
R_VDD1_571 METAL6_2504400_2338000 METAL6_2504400_2340000 0.004
R_VDD1_572 METAL6_2504400_2340000 METAL6_2504400_2341000 0.002
R_VDD1_573 METAL6_2504400_2341000 METAL6_2504400_2350000 0.018
R_VDD1_574 METAL6_2504400_2350000 METAL6_2504400_2352000 0.004
R_VDD1_575 METAL6_2504400_2352000 METAL6_2504400_2353000 0.002
R_VDD1_576 METAL6_2504400_2353000 METAL6_2504400_2362000 0.018
R_VDD1_577 METAL6_2504400_2362000 METAL6_2504400_2364000 0.004
R_VDD1_578 METAL6_2504400_2364000 METAL6_2504400_2365000 0.002
R_VDD1_579 METAL6_2504400_2365000 METAL6_2504400_2374000 0.018
R_VDD1_580 METAL6_2504400_2374000 METAL6_2504400_2376000 0.004
R_VDD1_581 METAL6_2504400_2376000 METAL6_2504400_2377000 0.002
R_VDD1_582 METAL6_2504400_2377000 METAL6_2504400_2388000 0.022
R_VDD1_583 METAL6_2504400_2388000 METAL6_2504400_2389000 0.002
R_VDD1_584 METAL6_2504400_2389000 METAL6_2504400_2395000 0.012
R_VDD1_585 METAL6_2504400_2395000 METAL6_2504400_2400000 0.01
R_VDD1_586 METAL6_2504400_2400000 METAL6_2504400_2401000 0.002
R_VDD1_587 METAL6_2504400_2401000 METAL6_2504400_2407000 0.012
R_VDD1_588 METAL6_2504400_2407000 METAL6_2504400_2412000 0.01
R_VDD1_589 METAL6_2504400_2412000 METAL6_2504400_2413000 0.002
R_VDD1_590 METAL6_2504400_2413000 METAL6_2504400_2419000 0.012
R_VDD1_591 METAL6_2504400_2419000 METAL6_2504400_2424000 0.01
R_VDD1_592 METAL6_2504400_2424000 METAL6_2504400_2436000 0.024
R_VDD1_593 METAL6_2504400_2436000 METAL6_2504400_2438000 0.004
R_VDD1_594 METAL6_2504400_2438000 METAL6_2504400_2444000 0.012
R_VDD1_595 METAL6_2504400_2444000 METAL6_2504400_2450000 0.012
R_VDD1_596 METAL6_2504400_2450000 METAL6_2504400_2456000 0.012
R_VDD1_597 METAL6_2504400_2456000 METAL6_2504400_2462000 0.012
R_VDD1_598 METAL6_2504400_2462000 METAL6_2504400_2468000 0.012
R_VDD1_599 METAL6_2504400_2468000 METAL6_2504400_2481000 0.026
R_VDD1_600 METAL6_2504400_2481000 METAL6_2505000_2481000 0.0012
R_VDD1_601 METAL6_2505000_2481000 METAL6_2510900_2481000 0.0118
R_VDD1_602 METAL6_2510900_2481000 METAL6_2512000_2481000 0.0022
R_VDD1_603 METAL6_2512000_2481000 METAL6_2513600_2481000 0.0032
R_VDD1_604 METAL6_2513600_2481000 METAL6_2516400_2481000 0.0056
R_VDD1_605 METAL6_2516400_2481000 METAL6_2517000_2481000 0.0012
R_VDD1_606 METAL6_2517000_2481000 METAL6_2524000_2481000 0.014
R_VDD1_607 METAL6_2524000_2481000 METAL6_2525600_2481000 0.0032
R_VDD1_608 METAL6_2525600_2481000 METAL6_2528400_2481000 0.0056
R_VDD1_609 METAL6_2528400_2481000 METAL6_2529000_2481000 0.0012
R_VDD1_610 METAL6_2529000_2481000 METAL6_2535400_2481000 0.0128
R_VDD1_611 METAL6_2535400_2481000 METAL6_2536000_2481000 0.0012
R_VDD1_612 METAL6_2536000_2481000 METAL6_2537600_2481000 0.0032
R_VDD1_613 METAL6_2537600_2481000 METAL6_2548000_2481000 0.0208
R_VDD1_614 METAL6_2548000_2481000 METAL6_2551900_2481000 0.0078
R_VDD1_615 METAL6_2551900_2481000 METAL6_2556400_2481000 0.009
R_VDD1_616 METAL6_2556400_2481000 METAL6_2565900_2481000 0.019
R_VDD1_617 METAL6_2565900_2481000 METAL6_2568400_2481000 0.005
R_VDD1_618 METAL6_2568400_2481000 METAL6_2580400_2481000 0.024
R_VDD1_619 METAL6_2580400_2481000 METAL6_2592400_2481000 0.024
R_VDD1_620 METAL6_2592400_2481000 METAL6_2604400_2481000 0.024
R_VDD1_621 METAL6_2604400_2481000 METAL6_2646600_2481000 0.0844
R_VDD1_622 METAL6_2646600_2481000 METAL6_2652200_2481000 0.0112
R_VDD1_623 METAL6_2652200_2481000 METAL6_2660600_2481000 0.0168
R_VDD1_624 METAL6_2660600_2481000 METAL6_2664200_2481000 0.0072
R_VDD1_625 METAL6_2664200_2481000 METAL6_2676200_2481000 0.024
R_VDD1_626 METAL6_2676200_2481000 METAL6_2683200_2481000 0.014
R_VDD1_627 METAL6_2683200_2481000 METAL6_2686900_2481000 0.0074
R_VDD1_628 METAL6_2686900_2481000 METAL6_2698900_2481000 0.024
R_VDD1_629 METAL6_2698900_2481000 METAL6_2710900_2481000 0.024
R_VDD1_630 METAL6_2710900_2481000 METAL6_2728200_2481000 0.0346
R_VDD1_631 METAL6_2728200_2481000 METAL6_2751900_2481000 0.0474
R_VDD1_632 METAL6_2751900_2481000 METAL6_2765900_2481000 0.028
R_VDD1_633 METAL6_2765900_2481000 METAL6_2781600_2481000 0.0314
R_VDD1_634 METAL6_2781600_2481000 METAL6_2788000_2481000 0.0128
R_VDD1_635 METAL6_2788000_2481000 METAL6_2793600_2481000 0.0112
R_VDD1_636 METAL6_2793600_2481000 METAL6_2798800_2481000 0.0104
R_VDD1_637 METAL6_2798800_2481000 METAL6_2800000_2481000 0.0024
R_VDD1_638 METAL6_2800000_2481000 METAL6_2805600_2481000 0.0112
R_VDD1_639 METAL6_2805600_2481000 METAL6_2812000_2481000 0.0128
R_VDD1_640 METAL6_2812000_2481000 METAL6_2843800_2481000 0.0636
R_VDD1_641 METAL6_2843800_2481000 METAL6_2846600_2481000 0.0056
R_VDD1_642 METAL6_2846600_2481000 METAL6_2850800_2481000 0.0084
R_VDD1_643 METAL6_2850800_2481000 METAL6_2860600_2481000 0.0196
R_VDD1_644 METAL6_2860600_2481000 METAL6_2862800_2481000 0.0044
R_VDD1_645 METAL6_2862800_2481000 METAL6_2874800_2481000 0.024
R_VDD1_646 METAL6_2874800_2481000 METAL6_2886900_2481000 0.0242
R_VDD1_647 METAL6_2886900_2481000 METAL6_2897100_2481000 0.0204
R_VDD1_648 METAL6_2897100_2481000 METAL6_2898900_2481000 0.0036
R_VDD1_649 METAL6_2898900_2481000 METAL6_2901600_2481000 0.0054
R_VDD1_650 METAL6_2901600_2481000 METAL6_2910900_2481000 0.0186
R_VDD1_651 METAL6_2910900_2481000 METAL6_2913600_2481000 0.0054
R_VDD1_652 METAL6_2913600_2481000 METAL6_2918200_2481000 0.0092
R_VDD1_653 METAL6_2918200_2481000 METAL6_2925600_2481000 0.0148
R_VDD1_654 METAL6_2925600_2481000 METAL6_2930200_2481000 0.0092
R_VDD1_655 METAL6_2930200_2481000 METAL6_2942200_2481000 0.024
R_VDD1_656 METAL6_2942200_2481000 METAL6_2951900_2481000 0.0194
R_VDD1_657 METAL6_2951900_2481000 METAL6_2965900_2481000 0.028
R_VDD1_658 METAL6_2965900_2481000 METAL6_2970200_2481000 0.0086
R_VDD1_659 METAL6_2970200_2481000 METAL6_2975200_2481000 0.01
R_VDD1_660 METAL6_2975200_2481000 METAL6_2982200_2481000 0.014
R_VDD1_661 METAL6_2982200_2481000 METAL6_2988000_2481000 0.0116
R_VDD1_662 METAL6_2988000_2481000 METAL6_2993000_2481000 0.01
R_VDD1_663 METAL6_2993000_2481000 METAL6_2994200_2481000 0.0024
R_VDD1_664 METAL6_2994200_2481000 METAL6_3000000_2481000 0.0116
R_VDD1_665 METAL6_3000000_2481000 METAL6_3006200_2481000 0.0124
R_VDD1_666 METAL6_3006200_2481000 METAL6_3012000_2481000 0.0116
R_VDD1_667 METAL6_3012000_2481000 METAL6_3018200_2481000 0.0124
R_VDD1_668 METAL6_3018200_2481000 METAL6_3023200_2481000 0.01
R_VDD1_669 METAL6_3023200_2481000 METAL6_3052000_2481000 0.0576
R_VDD1_670 METAL6_3052000_2481000 METAL6_3060600_2481000 0.0172
R_VDD1_671 METAL6_3060600_2481000 METAL6_3064000_2481000 0.0068
R_VDD1_672 METAL6_3064000_2481000 METAL6_3068200_2481000 0.0084
R_VDD1_673 METAL6_3068200_2481000 METAL6_3075200_2481000 0.014
R_VDD1_674 METAL6_3075200_2481000 METAL6_3076000_2481000 0.0016
R_VDD1_675 METAL6_3076000_2481000 METAL6_3086900_2481000 0.0218
R_VDD1_676 METAL6_3086900_2481000 METAL6_3087200_2481000 0.0006
R_VDD1_677 METAL6_3087200_2481000 METAL6_3088000_2481000 0.0016
R_VDD1_678 METAL6_3088000_2481000 METAL6_3098900_2481000 0.0218
R_VDD1_679 METAL6_3098900_2481000 METAL6_3099200_2481000 0.0006
R_VDD1_680 METAL6_3099200_2481000 METAL6_3100000_2481000 0.0016
R_VDD1_681 METAL6_3100000_2481000 METAL6_3110900_2481000 0.0218
R_VDD1_682 METAL6_3110900_2481000 METAL6_3111200_2481000 0.0006
R_VDD1_683 METAL6_3111200_2481000 METAL6_3112000_2481000 0.0016
R_VDD1_684 METAL6_3112000_2481000 METAL6_3124000_2481000 0.024
R_VDD1_685 METAL6_3124000_2481000 METAL6_3155500_2481000 0.063
R_VDD1_686 METAL6_3155500_2481000 METAL6_3165900_2481000 0.0208
R_VDD1_687 METAL6_3165900_2481000 METAL6_3167500_2481000 0.0032
R_VDD1_688 METAL6_3167500_2481000 METAL6_3179500_2481000 0.024
R_VDD1_689 METAL6_3179500_2481000 METAL6_3188000_2481000 0.017
R_VDD1_690 METAL6_3188000_2481000 METAL6_3200000_2481000 0.024
R_VDD1_691 METAL6_3200000_2481000 METAL6_3200500_2481000 0.001
R_VDD1_692 METAL6_3200500_2481000 METAL6_3207500_2481000 0.014
R_VDD1_693 METAL6_3207500_2481000 METAL6_3212000_2481000 0.009
R_VDD1_694 METAL6_3212000_2481000 METAL6_3212500_2481000 0.001
R_VDD1_695 METAL6_3212500_2481000 METAL6_3219500_2481000 0.014
R_VDD1_696 METAL6_3219500_2481000 METAL6_3224500_2481000 0.01
R_VDD1_697 METAL6_3224500_2481000 METAL6_3231500_2481000 0.014
R_VDD1_698 METAL6_3231500_2481000 METAL6_3243500_2481000 0.024
R_VDD1_699 METAL6_3243500_2481000 METAL6_3260400_2481000 0.0338
R_VDD1_700 METAL6_3260400_2481000 METAL6_3263000_2481000 0.0052
R_VDD1_701 METAL6_3263000_2481000 METAL6_3275000_2481000 0.024
R_VDD1_702 METAL6_3275000_2481000 METAL6_3276400_2481000 0.0028
R_VDD1_703 METAL6_3276400_2481000 METAL6_3287000_2481000 0.0212
R_VDD1_704 METAL6_3287000_2481000 METAL6_3287000_2493000 0.024
R_VDD1_705 METAL6_3287000_2493000 METAL6_3288000_2493000 0.002
R_VDD1_706 METAL6_3288000_2493000 METAL6_3288400_2493000 0.0008
R_VDD1_707 METAL6_3288400_2493000 METAL6_3300000_2493000 0.0232
R_VDD1_708 METAL6_3300000_2493000 METAL6_3300400_2493000 0.0008
R_VDD1_709 METAL6_3300400_2493000 METAL6_3305400_2493000 0.01
R_VDD1_710 METAL6_3305400_2493000 METAL6_3312000_2493000 0.0132
R_VDD1_711 METAL6_3312000_2493000 METAL6_3312400_2493000 0.0008
R_VDD1_712 METAL6_3312400_2493000 METAL6_3324400_2493000 0.024
R_VDD1_713 METAL6_3324400_2493000 METAL6_3336400_2493000 0.024
R_VDD1_714 METAL6_3336400_2493000 METAL6_3348400_2493000 0.024
R_VDD1_715 METAL6_3348400_2493000 METAL6_3360400_2493000 0.024
R_VDD1_716 METAL6_3360400_2493000 METAL6_3442500_2493000 0.1642
R_VDD1_717 METAL6_3442500_2493000 METAL6_3453000_2493000 0.021
R_VDD1_718 METAL6_3453000_2493000 METAL6_3454500_2493000 0.003
R_VDD1_719 METAL6_3454500_2493000 METAL6_3465000_2493000 0.021
R_VDD1_720 METAL6_3465000_2505000 METAL6_3465000_2493000 0.024
R_VDD1_721 METAL6_2505000_1259700 METAL6_2500000_1259700 0.01
R_VDD1_722 METAL6_2500000_1259700 METAL6_2498900_1259700 0.0022
R_VDD1_723 METAL6_2498900_1259700 METAL6_2493000_1259700 0.0118
R_VDD1_724 METAL5_2286900_1295700 METAL5_2286900_1302000 0.0252
R_VDD1_725 METAL5_2286900_1302000 METAL5_2286900_1307700 0.0228
R_VDD1_726 METAL5_2286900_1307700 METAL5_2296600_1307700 0.0388
R_VDD1_727 METAL5_2296600_1307700 METAL5_2298900_1307700 0.0092
R_VDD1_728 METAL5_2298900_1307700 METAL5_2308600_1307700 0.0388
R_VDD1_729 METAL5_2308600_1307700 METAL6_2308600_1307700 0.1
R_VDD1_730 METAL6_2308600_1307700 METAL6_2308600_1302000 0.0114
R_VDD1_731 METAL6_2308600_1302000 METAL6_2308600_1295700 0.0126
R_VDD1_732 METAL6_2308600_1295700 METAL6_2308600_1285000 0.0214
R_VDD1_733 METAL6_2308600_1285000 METAL6_2310900_1285000 0.0046
R_VDD1_734 METAL6_2310900_1285000 METAL6_2343700_1285000 0.0656
R_VDD1_735 METAL6_2343700_1285000 METAL6_2351900_1285000 0.0164
R_VDD1_736 METAL6_2351900_1285000 METAL6_2357600_1285000 0.0114
R_VDD1_737 METAL6_2357600_1285000 METAL6_2365900_1285000 0.0166
R_VDD1_738 METAL6_2365900_1285000 METAL6_2369600_1285000 0.0074
R_VDD1_739 METAL6_2369600_1285000 METAL6_2371100_1285000 0.003
R_VDD1_740 METAL6_2371100_1285000 METAL6_2381600_1285000 0.021
R_VDD1_741 METAL6_2381600_1285000 METAL6_2383100_1285000 0.003
R_VDD1_742 METAL6_2383100_1285000 METAL6_2393600_1285000 0.021
R_VDD1_743 METAL6_2393600_1285000 METAL6_2395100_1285000 0.003
R_VDD1_744 METAL6_2395100_1285000 METAL6_2402100_1285000 0.014
R_VDD1_745 METAL6_2402100_1285000 METAL6_2405600_1285000 0.007
R_VDD1_746 METAL6_2405600_1285000 METAL6_2407100_1285000 0.003
R_VDD1_747 METAL6_2407100_1285000 METAL6_2419100_1285000 0.024
R_VDD1_748 METAL6_2419100_1285000 METAL6_2424600_1285000 0.011
R_VDD1_749 METAL6_2424600_1285000 METAL6_2434600_1285000 0.02
R_VDD1_750 METAL6_2434600_1285000 METAL6_2436600_1285000 0.004
R_VDD1_751 METAL6_2436600_1285000 METAL6_2436600_1283700 0.0026
R_VDD1_752 METAL6_2436600_1283700 METAL6_2446600_1283700 0.02
R_VDD1_753 METAL6_2446600_1283700 METAL6_2448600_1283700 0.004
R_VDD1_754 METAL6_2448600_1283700 METAL5_2448600_1283700 0.1
R_VDD1_755 METAL5_2448600_1283700 METAL5_2458600_1283700 0.04
R_VDD1_756 METAL5_2458600_1283700 METAL5_2460600_1283700 0.008
R_VDD1_757 METAL5_2460600_1283700 METAL5_2464000_1283700 0.0136
R_VDD1_758 METAL5_2464000_1283700 METAL5_2465600_1283700 0.0064
R_VDD1_759 METAL5_2465600_1283700 METAL5_2469000_1283700 0.0136
R_VDD1_760 METAL5_2469000_1283700 METAL5_2472600_1283700 0.0144
R_VDD1_761 METAL5_2472600_1283700 METAL6_2472600_1283700 0.1
R_VDD1_762 METAL6_2472600_1283700 METAL6_2476000_1283700 0.0068
R_VDD1_763 METAL6_2476000_1283700 METAL6_2477600_1283700 0.0032
R_VDD1_764 METAL6_2477600_1283700 METAL6_2481000_1283700 0.0068
R_VDD1_765 METAL6_2481000_1283700 METAL6_2486900_1283700 0.0118
R_VDD1_766 METAL6_2486900_1283700 METAL6_2488000_1283700 0.0022
R_VDD1_767 METAL6_2488000_1283700 METAL6_2489600_1283700 0.0032
R_VDD1_768 METAL6_2489600_1283700 METAL6_2489600_1273000 0.0214
R_VDD1_769 METAL6_2489600_1273000 METAL6_2492400_1273000 0.0056
R_VDD1_770 METAL6_2492400_1273000 METAL6_2492400_1271700 0.0026
R_VDD1_771 METAL6_2492400_1271700 METAL6_2493000_1271700 0.0012
R_VDD1_772 METAL6_2493000_1271700 METAL6_2493000_1262000 0.0194
R_VDD1_773 METAL6_2493000_1262000 METAL6_2493000_1261000 0.002
R_VDD1_774 METAL6_2493000_1261000 METAL6_2493000_1259700 0.0026
I_VDD1_1 METAL6_3465000_2505000 gnd 0.002
I_VDD1_2 METAL6_2505000_1259700 gnd 0.002

V_VDD10_2 METAL6_3000000_0 gnd 1
R_VDD10_775 METAL6_3000000_0 METAL6_3000000_9500 0.019
R_VDD10_776 METAL6_3000000_9500 METAL6_3000000_21500 0.024
R_VDD10_777 METAL6_3000000_21500 METAL6_3000000_52600 0.0622
R_VDD10_778 METAL6_3000000_52600 METAL6_2994200_52600 0.0116
R_VDD10_779 METAL6_2994200_52600 METAL6_2993000_52600 0.0024
R_VDD10_780 METAL6_2993000_52600 METAL6_2988000_52600 0.01
R_VDD10_781 METAL6_2988000_52600 METAL6_2982200_52600 0.0116
R_VDD10_782 METAL6_2982200_52600 METAL6_2975200_52600 0.014
R_VDD10_783 METAL6_2975200_52600 METAL6_2965900_52600 0.0186
R_VDD10_784 METAL6_2965900_52600 METAL6_2951900_52600 0.028
R_VDD10_785 METAL6_2951900_52600 METAL6_2930200_52600 0.0434
R_VDD10_786 METAL6_2930200_52600 METAL6_2925600_52600 0.0092
R_VDD10_787 METAL6_2925600_52600 METAL6_2913600_52600 0.024
R_VDD10_788 METAL6_2913600_52600 METAL6_2910900_52600 0.0054
R_VDD10_789 METAL6_2910900_52600 METAL6_2901600_52600 0.0186
R_VDD10_790 METAL6_2901600_52600 METAL6_2898900_52600 0.0054
R_VDD10_791 METAL6_2898900_52600 METAL6_2897100_52600 0.0036
R_VDD10_792 METAL6_2897100_52600 METAL6_2886900_52600 0.0204
R_VDD10_793 METAL6_2886900_52600 METAL6_2874800_52600 0.0242
R_VDD10_794 METAL6_2874800_52600 METAL6_2862800_52600 0.024
R_VDD10_795 METAL6_2862800_52600 METAL6_2860600_52600 0.0044
R_VDD10_796 METAL6_2860600_52600 METAL6_2850800_52600 0.0196
R_VDD10_797 METAL6_2850800_52600 METAL6_2846600_52600 0.0084
R_VDD10_798 METAL6_2846600_52600 METAL6_2843800_52600 0.0056
R_VDD10_799 METAL6_2843800_52600 METAL6_2812000_52600 0.0636
R_VDD10_800 METAL6_2812000_52600 METAL6_2805600_52600 0.0128
R_VDD10_801 METAL6_2805600_52600 METAL6_2800000_52600 0.0112
R_VDD10_802 METAL6_2800000_52600 METAL6_2798800_52600 0.0024
R_VDD10_803 METAL6_2798800_52600 METAL6_2793600_52600 0.0104
R_VDD10_804 METAL6_2793600_52600 METAL6_2788000_52600 0.0112
R_VDD10_805 METAL6_2788000_52600 METAL6_2781600_52600 0.0128
R_VDD10_806 METAL6_2781600_52600 METAL6_2765900_52600 0.0314
R_VDD10_807 METAL6_2765900_52600 METAL6_2751900_52600 0.028
R_VDD10_808 METAL6_2751900_52600 METAL6_2728200_52600 0.0474
R_VDD10_809 METAL6_2728200_52600 METAL6_2710900_52600 0.0346
R_VDD10_810 METAL6_2710900_52600 METAL6_2698900_52600 0.024
R_VDD10_811 METAL6_2698900_52600 METAL6_2686900_52600 0.024
R_VDD10_812 METAL6_2686900_52600 METAL6_2683200_52600 0.0074
R_VDD10_813 METAL6_2683200_52600 METAL6_2676200_52600 0.014
R_VDD10_814 METAL6_2676200_52600 METAL6_2664200_52600 0.024
R_VDD10_815 METAL6_2664200_52600 METAL6_2660600_52600 0.0072
R_VDD10_816 METAL6_2660600_52600 METAL6_2652200_52600 0.0168
R_VDD10_817 METAL6_2652200_52600 METAL6_2646600_52600 0.0112
R_VDD10_818 METAL6_2646600_52600 METAL6_2580400_52600 0.1324
R_VDD10_819 METAL6_2580400_52600 METAL6_2565900_52600 0.029
R_VDD10_820 METAL6_2565900_52600 METAL6_2551900_52600 0.028
R_VDD10_821 METAL6_2551900_52600 METAL6_2535400_52600 0.033
R_VDD10_822 METAL6_2535400_52600 METAL6_2528400_52600 0.014
R_VDD10_823 METAL6_2528400_52600 METAL6_2525600_52600 0.0056
R_VDD10_824 METAL6_2525600_52600 METAL6_2516400_52600 0.0184
R_VDD10_825 METAL6_2516400_52600 METAL6_2513600_52600 0.0056
R_VDD10_826 METAL6_2513600_52600 METAL6_2512000_52600 0.0032
R_VDD10_827 METAL6_2512000_52600 METAL6_2510900_52600 0.0022
R_VDD10_828 METAL6_2510900_52600 METAL6_2505000_52600 0.0118
R_VDD10_829 METAL6_2505000_52600 METAL6_2504400_52600 0.0012
R_VDD10_830 METAL6_2504400_52600 METAL6_2501600_52600 0.0056
R_VDD10_831 METAL6_2501600_52600 METAL6_2500000_52600 0.0032
R_VDD10_832 METAL6_2500000_52600 METAL6_2498900_52600 0.0022
R_VDD10_833 METAL6_2498900_52600 METAL6_2493000_52600 0.0118
R_VDD10_834 METAL6_2493000_52600 METAL6_2488000_52600 0.01
R_VDD10_835 METAL6_2488000_52600 METAL6_2486900_52600 0.0022
R_VDD10_836 METAL6_2486900_52600 METAL6_2481000_52600 0.0118
R_VDD10_837 METAL6_2481000_52600 METAL6_2476000_52600 0.01
R_VDD10_838 METAL6_2476000_52600 METAL6_2460600_52600 0.0308
R_VDD10_839 METAL6_2460600_52600 METAL6_2446600_52600 0.028
R_VDD10_840 METAL6_2446600_52600 METAL6_2407100_52600 0.079
R_VDD10_841 METAL6_2407100_52600 METAL6_2405600_52600 0.003
R_VDD10_842 METAL6_2405600_52600 METAL6_2402100_52600 0.007
R_VDD10_843 METAL6_2402100_52600 METAL6_2395100_52600 0.014
R_VDD10_844 METAL6_2395100_52600 METAL6_2393600_52600 0.003
R_VDD10_845 METAL6_2393600_52600 METAL6_2383100_52600 0.021
R_VDD10_846 METAL6_2383100_52600 METAL6_2381600_52600 0.003
R_VDD10_847 METAL6_2381600_52600 METAL6_2381600_64600 0.024
R_VDD10_848 METAL6_2381600_64600 METAL6_2371100_64600 0.021
R_VDD10_849 METAL6_2371100_64600 METAL6_2365900_64600 0.0104
R_VDD10_850 METAL6_2365900_64600 METAL6_2351900_64600 0.028
R_VDD10_851 METAL6_2351900_64600 METAL6_2343700_64600 0.0164
R_VDD10_852 METAL6_2343700_64600 METAL6_2310900_64600 0.0656
R_VDD10_853 METAL6_2310900_64600 METAL6_2298900_64600 0.024
R_VDD10_854 METAL6_2298900_64600 METAL6_2286900_64600 0.024
R_VDD10_855 METAL6_2286900_64600 METAL6_2272400_64600 0.029
R_VDD10_856 METAL6_2272400_64600 METAL6_2260600_64600 0.0236
R_VDD10_857 METAL6_2260600_64600 METAL6_2260400_64600 0.0004
R_VDD10_858 METAL6_2260400_64600 METAL6_2258600_64600 0.0036
R_VDD10_859 METAL6_2258600_64600 METAL6_2248700_64600 0.0198
R_VDD10_860 METAL6_2248700_64600 METAL6_2248400_64600 0.0006
R_VDD10_861 METAL6_2248400_64600 METAL6_2246600_64600 0.0036
R_VDD10_862 METAL6_2246600_64600 METAL6_2236700_64600 0.0198
R_VDD10_863 METAL6_2236700_64600 METAL6_2234600_64600 0.0042
R_VDD10_864 METAL6_2234600_64600 METAL6_2224700_64600 0.0198
R_VDD10_865 METAL6_2224700_64600 METAL6_2221900_64600 0.0056
R_VDD10_866 METAL6_2221900_64600 METAL6_2212700_64600 0.0184
R_VDD10_867 METAL6_2212700_64600 METAL6_2200700_64600 0.024
R_VDD10_868 METAL6_2200700_64600 METAL6_2188700_64600 0.024
R_VDD10_869 METAL6_2188700_64600 METAL6_2177900_64600 0.0216
R_VDD10_870 METAL6_2177900_64600 METAL6_2176700_64600 0.0024
R_VDD10_871 METAL6_2176700_64600 METAL6_2165900_64600 0.0216
R_VDD10_872 METAL6_2165900_64600 METAL6_2165400_64600 0.001
R_VDD10_873 METAL6_2165400_64600 METAL6_2153900_64600 0.023
R_VDD10_874 METAL6_2153900_64600 METAL6_2153400_64600 0.001
R_VDD10_875 METAL6_2153400_64600 METAL6_2151900_64600 0.003
R_VDD10_876 METAL6_2151900_64600 METAL6_2141400_64600 0.021
R_VDD10_877 METAL6_2141400_64600 METAL6_2129700_64600 0.0234
R_VDD10_878 METAL6_2129700_64600 METAL6_2125600_64600 0.0082
R_VDD10_879 METAL6_2125600_64600 METAL6_2121400_64600 0.0084
R_VDD10_880 METAL6_2121400_64600 METAL6_2113600_64600 0.0156
R_VDD10_881 METAL6_2113600_64600 METAL6_2101900_64600 0.0234
R_VDD10_882 METAL6_2101900_64600 METAL6_2101600_64600 0.0006
R_VDD10_883 METAL6_2101600_64600 METAL6_2089900_64600 0.0234
R_VDD10_884 METAL6_2089900_64600 METAL6_2077900_64600 0.024
R_VDD10_885 METAL6_2077900_64600 METAL6_2067700_64600 0.0204
R_VDD10_886 METAL6_2067700_64600 METAL6_2060600_64600 0.0142
R_VDD10_887 METAL6_2060600_64600 METAL6_2055700_64600 0.0098
R_VDD10_888 METAL6_2055700_64600 METAL6_2046800_64600 0.0178
R_VDD10_889 METAL6_2046800_64600 METAL6_2046600_64600 0.0004
R_VDD10_890 METAL6_2046600_64600 METAL6_2046400_64600 0.0004
R_VDD10_891 METAL6_2046400_64600 METAL6_2043700_64600 0.0054
R_VDD10_892 METAL6_2043700_64600 METAL6_2031700_64600 0.024
R_VDD10_893 METAL6_2031700_64600 METAL6_2030900_64600 0.0016
R_VDD10_894 METAL6_2030900_64600 METAL6_2026400_64600 0.009
R_VDD10_895 METAL6_2026400_64600 METAL6_2021200_64600 0.0104
R_VDD10_896 METAL6_2021200_64600 METAL6_2019700_64600 0.003
R_VDD10_897 METAL6_2019700_64600 METAL6_2018900_64600 0.0016
R_VDD10_898 METAL6_2018900_64600 METAL6_2014400_64600 0.009
R_VDD10_899 METAL6_2014400_64600 METAL6_2012000_64600 0.0048
R_VDD10_900 METAL6_2012000_64600 METAL6_2006900_64600 0.0102
R_VDD10_901 METAL6_2006900_64600 METAL6_2002400_64600 0.009
R_VDD10_902 METAL6_2002400_64600 METAL6_2000000_64600 0.0048
R_VDD10_903 METAL6_2000000_64600 METAL6_1988000_64600 0.024
R_VDD10_904 METAL6_1988000_64600 METAL6_1951900_64600 0.0722
R_VDD10_905 METAL6_1951900_64600 METAL6_1951800_64600 0.0002
R_VDD10_906 METAL6_1951800_64600 METAL6_1939800_64600 0.024
R_VDD10_907 METAL6_1939800_64600 METAL6_1927800_64600 0.024
R_VDD10_908 METAL6_1927800_64600 METAL6_1926200_64600 0.0032
R_VDD10_909 METAL6_1926200_64600 METAL6_1925600_64600 0.0012
R_VDD10_910 METAL6_1925600_64600 METAL6_1919200_64600 0.0128
R_VDD10_911 METAL6_1919200_64600 METAL6_1913600_64600 0.0112
R_VDD10_912 METAL6_1913600_64600 METAL6_1907400_64600 0.0124
R_VDD10_913 METAL6_1907400_64600 METAL6_1907200_64600 0.0004
R_VDD10_914 METAL6_1907200_64600 METAL6_1901600_64600 0.0112
R_VDD10_915 METAL6_1901600_64600 METAL6_1900700_64600 0.0018
R_VDD10_916 METAL6_1900700_64600 METAL6_1895200_64600 0.011
R_VDD10_917 METAL6_1895200_64600 METAL6_1888700_64600 0.013
R_VDD10_918 METAL6_1888700_64600 METAL6_1877400_64600 0.0226
R_VDD10_919 METAL6_1877400_64600 METAL6_1876700_64600 0.0014
R_VDD10_920 METAL6_1876700_64600 METAL6_1874700_64600 0.004
R_VDD10_921 METAL6_1874700_64600 METAL6_1865400_64600 0.0186
R_VDD10_922 METAL6_1865400_64600 METAL6_1864700_64600 0.0014
R_VDD10_923 METAL6_1864700_64600 METAL6_1858400_64600 0.0126
R_VDD10_924 METAL6_1858400_64600 METAL6_1853400_64600 0.01
R_VDD10_925 METAL6_1853400_64600 METAL6_1846800_64600 0.0132
R_VDD10_926 METAL6_1846800_64600 METAL6_1846600_64600 0.0004
R_VDD10_927 METAL6_1846600_64600 METAL6_1846600_76600 0.024
R_VDD10_928 METAL6_1846600_76600 METAL6_1846600_83600 0.014
R_VDD10_929 METAL6_1846600_83600 METAL6_1846600_88000 0.0088
R_VDD10_930 METAL6_1846600_88000 METAL6_1846600_88600 0.0012
R_VDD10_931 METAL6_1846600_88600 METAL6_1846600_100000 0.0228
R_VDD10_932 METAL6_1846600_100000 METAL6_1846600_112000 0.024
R_VDD10_933 METAL6_1846600_112000 METAL6_1846600_159600 0.0952
R_VDD10_934 METAL6_1846600_159600 METAL6_1846600_166600 0.014
R_VDD10_935 METAL6_1846600_166600 METAL6_1846600_178600 0.024
R_VDD10_936 METAL6_1846600_178600 METAL6_1846600_188000 0.0188
R_VDD10_937 METAL6_1846600_188000 METAL6_1846600_190600 0.0052
R_VDD10_938 METAL6_1846600_190600 METAL6_1846600_200000 0.0188
R_VDD10_939 METAL6_1846600_200000 METAL6_1846600_212000 0.024
R_VDD10_940 METAL6_1846600_212000 METAL6_1846600_248300 0.0726
R_VDD10_941 METAL6_1846600_248300 METAL6_1846600_260300 0.024
R_VDD10_942 METAL6_1846600_260300 METAL6_1846600_263000 0.0054
R_VDD10_943 METAL6_1846600_263000 METAL6_1846600_272300 0.0186
R_VDD10_944 METAL6_1846600_272300 METAL6_1846600_275000 0.0054
R_VDD10_945 METAL6_1846600_275000 METAL6_1846600_279300 0.0086
R_VDD10_946 METAL6_1846600_279300 METAL6_1846600_287000 0.0154
R_VDD10_947 METAL6_1846600_287000 METAL6_1846600_288000 0.002
R_VDD10_948 METAL6_1846600_288000 METAL6_1846600_299000 0.022
R_VDD10_949 METAL6_1846600_299000 METAL6_1846600_300000 0.002
R_VDD10_950 METAL6_1846600_300000 METAL6_1846600_312000 0.024
R_VDD10_951 METAL6_1846600_312000 METAL6_1846600_355300 0.0866
R_VDD10_952 METAL6_1846600_355300 METAL6_1846600_362300 0.014
R_VDD10_953 METAL6_1846600_362300 METAL6_1846600_374300 0.024
R_VDD10_954 METAL6_1846600_374300 METAL6_1846600_386300 0.024
R_VDD10_955 METAL6_1846600_386300 METAL6_1846600_388000 0.0034
R_VDD10_956 METAL6_1846600_388000 METAL6_1846600_400000 0.024
R_VDD10_957 METAL6_1846600_400000 METAL6_1846600_402800 0.0056
R_VDD10_958 METAL6_1846600_402800 METAL6_1846600_412000 0.0184
R_VDD10_959 METAL6_1846600_412000 METAL6_1846600_449000 0.074
R_VDD10_960 METAL6_1846600_449000 METAL6_1846600_453000 0.008
R_VDD10_961 METAL6_1846600_453000 METAL6_1846600_465000 0.024
R_VDD10_962 METAL6_1846600_465000 METAL6_1846600_477000 0.024
R_VDD10_963 METAL6_1846600_477000 METAL6_1846600_480400 0.0068
R_VDD10_964 METAL6_1846600_480400 METAL6_1846600_488000 0.0152
R_VDD10_965 METAL6_1846600_488000 METAL6_1846600_500000 0.024
R_VDD10_966 METAL6_1846600_500000 METAL6_1846600_504000 0.008
R_VDD10_967 METAL6_1846600_504000 METAL6_1846600_507000 0.006
R_VDD10_968 METAL6_1846600_507000 METAL6_1846600_507800 0.0016
R_VDD10_969 METAL6_1846600_507800 METAL6_1846600_512000 0.0084
R_VDD10_970 METAL6_1846600_512000 METAL6_1846600_516000 0.008
R_VDD10_971 METAL6_1846600_516000 METAL6_1846600_528000 0.024
R_VDD10_972 METAL6_1846600_528000 METAL6_1846600_535400 0.0148
R_VDD10_973 METAL6_1846600_535400 METAL6_1846600_544200 0.0176
R_VDD10_974 METAL6_1846600_544200 METAL6_1846600_547400 0.0064
R_VDD10_975 METAL6_1846600_547400 METAL6_1846600_559400 0.024
R_VDD10_976 METAL6_1846600_559400 METAL6_1846600_573000 0.0272
R_VDD10_977 METAL6_1846600_573000 METAL6_1846600_579800 0.0136
R_VDD10_978 METAL6_1846600_579800 METAL6_1846600_586400 0.0132
R_VDD10_979 METAL6_1846600_586400 METAL6_1846600_588000 0.0032
R_VDD10_980 METAL6_1846600_588000 METAL6_1846600_600000 0.024
R_VDD10_981 METAL6_1846600_600000 METAL6_1846600_612000 0.024
R_VDD10_982 METAL6_1846600_612000 METAL6_1846600_637800 0.0516
R_VDD10_983 METAL6_1846600_637800 METAL6_1846600_641400 0.0072
R_VDD10_984 METAL6_1846600_641400 METAL6_1846600_649800 0.0168
R_VDD10_985 METAL6_1846600_649800 METAL6_1846600_653400 0.0072
R_VDD10_986 METAL6_1846600_653400 METAL6_1846600_661800 0.0168
R_VDD10_987 METAL6_1846600_661800 METAL6_1846600_665400 0.0072
R_VDD10_988 METAL6_1846600_665400 METAL6_1846600_688000 0.0452
R_VDD10_989 METAL6_1846600_688000 METAL6_1846600_700000 0.024
R_VDD10_990 METAL6_1846600_700000 METAL6_1846600_702800 0.0056
R_VDD10_991 METAL6_1846600_702800 METAL6_1846600_709800 0.014
R_VDD10_992 METAL6_1846600_709800 METAL6_1846600_712000 0.0044
R_VDD10_993 METAL6_1846600_712000 METAL6_1846600_716800 0.0096
R_VDD10_994 METAL6_1846600_716800 METAL6_1846600_721800 0.01
R_VDD10_995 METAL6_1846600_721800 METAL6_1846600_733800 0.024
R_VDD10_996 METAL6_1846600_733800 METAL6_1846600_735400 0.0032
R_VDD10_997 METAL6_1846600_735400 METAL6_1846600_763000 0.0552
R_VDD10_998 METAL6_1846600_763000 METAL6_1846600_770400 0.0148
R_VDD10_999 METAL6_1846600_770400 METAL6_1846400_770400 0.0004
R_VDD10_1000 METAL6_1846400_770400 METAL6_1844800_770400 0.0032
R_VDD10_1001 METAL6_1844800_770400 METAL6_1834400_770400 0.0208
R_VDD10_1002 METAL6_1834400_770400 METAL6_1832800_770400 0.0032
R_VDD10_1003 METAL6_1832800_770400 METAL6_1820800_770400 0.024
R_VDD10_1004 METAL6_1820800_770400 METAL6_1812000_770400 0.0176
R_VDD10_1005 METAL6_1812000_770400 METAL6_1800000_770400 0.024
R_VDD10_1006 METAL6_1800000_770400 METAL6_1788000_770400 0.024
R_VDD10_1007 METAL6_1788000_770400 METAL6_1755700_770400 0.0646
R_VDD10_1008 METAL6_1755700_770400 METAL6_1751800_770400 0.0078
R_VDD10_1009 METAL6_1751800_770400 METAL6_1751400_770400 0.0008
R_VDD10_1010 METAL6_1751400_770400 METAL6_1744000_770400 0.0148
R_VDD10_1011 METAL6_1744000_770400 METAL6_1743700_770400 0.0006
R_VDD10_1012 METAL6_1743700_770400 METAL6_1741800_770400 0.0038
R_VDD10_1013 METAL6_1741800_770400 METAL6_1739800_770400 0.004
R_VDD10_1014 METAL6_1739800_770400 METAL6_1731700_770400 0.0162
R_VDD10_1015 METAL6_1731700_770400 METAL5_1731700_770400 0.1
R_VDD10_1016 METAL5_1731700_770400 METAL5_1731700_772000 0.0064
R_VDD10_1017 METAL5_1731700_772000 METAL5_1731700_778400 0.0256
R_VDD10_1018 METAL5_1731700_778400 METAL5_1731700_779200 0.0032
R_VDD10_1019 METAL5_1731700_779200 METAL5_1731700_782400 0.0128
R_VDD10_1020 METAL5_1731700_782400 METAL5_1731700_784500 0.0084
R_VDD10_1021 METAL5_1731700_784500 METAL5_1731700_788000 0.014
R_VDD10_1022 METAL5_1731700_788000 METAL5_1731700_790400 0.0096
R_VDD10_1023 METAL5_1731700_790400 METAL5_1731700_791200 0.0032
R_VDD10_1024 METAL5_1731700_791200 METAL5_1731700_794400 0.0128
R_VDD10_1025 METAL5_1731700_794400 METAL5_1731700_794800 0.0016
R_VDD10_1026 METAL5_1731700_794800 METAL5_1731700_800000 0.0208
R_VDD10_1027 METAL5_1731700_800000 METAL5_1731700_802400 0.0096
R_VDD10_1028 METAL5_1731700_802400 METAL5_1731700_803200 0.0032
R_VDD10_1029 METAL5_1731700_803200 METAL5_1731700_806400 0.0128
R_VDD10_1030 METAL5_1731700_806400 METAL6_1731700_806400 0.1
R_VDD10_1031 METAL6_1731700_806400 METAL6_1729800_806400 0.0038
R_VDD10_1032 METAL6_1729800_806400 METAL6_1727800_806400 0.004
R_VDD10_1033 METAL6_1727800_806400 METAL6_1719700_806400 0.0162
R_VDD10_1034 METAL6_1719700_806400 METAL6_1717800_806400 0.0038
R_VDD10_1035 METAL6_1717800_806400 METAL6_1710800_806400 0.014
R_VDD10_1036 METAL6_1710800_806400 METAL6_1707700_806400 0.0062
R_VDD10_1037 METAL6_1707700_806400 METAL6_1699000_806400 0.0174
R_VDD10_1038 METAL6_1699000_806400 METAL6_1692000_806400 0.014
R_VDD10_1039 METAL6_1692000_806400 METAL6_1680000_806400 0.024
R_VDD10_1040 METAL6_1680000_806400 METAL6_1668000_806400 0.024
R_VDD10_1041 METAL6_1668000_806400 METAL6_1658800_806400 0.0184
R_VDD10_1042 METAL6_1658800_806400 METAL6_1658800_808000 0.0032
R_VDD10_1043 METAL6_1658800_808000 METAL6_1658800_812000 0.008
R_VDD10_1044 METAL6_1658800_812000 METAL6_1658800_814400 0.0048
R_VDD10_1045 METAL6_1658800_814400 METAL6_1658800_818400 0.008
R_VDD10_1046 METAL6_1658800_818400 METAL6_1646800_818400 0.024
R_VDD10_1047 METAL6_1646800_818400 METAL6_1634800_818400 0.024
R_VDD10_1048 METAL6_1634800_818400 METAL6_1632800_818400 0.004
R_VDD10_1049 METAL6_1632800_818400 METAL6_1615800_818400 0.034
R_VDD10_1050 METAL6_1615800_818400 METAL6_1612000_818400 0.0076
R_VDD10_1051 METAL6_1612000_818400 METAL6_1607900_818400 0.0082
R_VDD10_1052 METAL6_1607900_818400 METAL6_1600700_818400 0.0144
R_VDD10_1053 METAL6_1600700_818400 METAL6_1600700_820000 0.0032
R_VDD10_1054 METAL6_1600700_820000 METAL6_1600700_832000 0.024
R_VDD10_1055 METAL6_1600700_832000 METAL6_1600700_839500 0.015
R_VDD10_1056 METAL6_1600700_839500 METAL6_1600700_840700 0.0024
R_VDD10_1057 METAL6_1600700_840700 METAL6_1600700_851500 0.0216
R_VDD10_1058 METAL6_1600700_851500 METAL6_1600700_858200 0.0134
R_VDD10_1059 METAL6_1600700_858200 METAL6_1600700_863500 0.0106
R_VDD10_1060 METAL6_1600700_863500 METAL6_1600700_887000 0.047
R_VDD10_1061 METAL6_1600700_887000 METAL6_1600700_888000 0.002
R_VDD10_1062 METAL6_1600700_888000 METAL6_1600700_900000 0.024
R_VDD10_1063 METAL6_1600700_900000 METAL6_1600700_900400 0.0008
R_VDD10_1064 METAL6_1600700_900400 METAL6_1600700_912000 0.0232
R_VDD10_1065 METAL6_1600700_912000 METAL6_1600700_927300 0.0306
R_VDD10_1066 METAL6_1600700_927300 METAL6_1600700_947000 0.0394
R_VDD10_1067 METAL6_1600700_947000 METAL6_1600700_959000 0.024
R_VDD10_1068 METAL6_1600700_959000 METAL6_1600700_971000 0.024
R_VDD10_1069 METAL6_1600700_971000 METAL6_1600700_976000 0.01
R_VDD10_1070 METAL6_1600700_976000 METAL6_1600700_988000 0.024
R_VDD10_1071 METAL6_1600700_988000 METAL6_1600700_995000 0.014
R_VDD10_1072 METAL6_1600700_995000 METAL6_1600700_1000000 0.01
R_VDD10_1073 METAL6_1600700_1000000 METAL6_1600700_1007000 0.014
R_VDD10_1074 METAL6_1600700_1007000 METAL6_1600700_1012000 0.01
R_VDD10_1075 METAL6_1600700_1012000 METAL6_1600700_1014000 0.004
R_VDD10_1076 METAL6_1600700_1014000 METAL6_1600700_1019000 0.01
R_VDD10_1077 METAL6_1600700_1019000 METAL6_1600700_1026000 0.014
R_VDD10_1078 METAL6_1600700_1026000 METAL6_1600700_1029800 0.0076
R_VDD10_1079 METAL6_1600700_1029800 METAL6_1600700_1031000 0.0024
R_VDD10_1080 METAL6_1600700_1031000 METAL6_1600700_1035700 0.0094
R_VDD10_1081 METAL6_1600700_1035700 METAL6_1600700_1038000 0.0046
R_VDD10_1082 METAL6_1600700_1038000 METAL6_1600700_1041800 0.0076
R_VDD10_1083 METAL6_1600700_1041800 METAL6_1600700_1042700 0.0018
R_VDD10_1084 METAL6_1600700_1042700 METAL6_1600700_1049400 0.0134
R_VDD10_1085 METAL6_1600700_1049400 METAL6_1600000_1049400 0.0014
R_VDD10_1086 METAL6_1600000_1049400 METAL6_1588700_1049400 0.0226
R_VDD10_1087 METAL6_1588700_1049400 METAL6_1588000_1049400 0.0014
R_VDD10_1088 METAL6_1588000_1049400 METAL6_1576700_1049400 0.0226
R_VDD10_1089 METAL6_1576700_1049400 METAL6_1576000_1049400 0.0014
R_VDD10_1090 METAL6_1576000_1049400 METAL6_1574700_1049400 0.0026
R_VDD10_1091 METAL6_1574700_1049400 METAL6_1557000_1049400 0.0354
R_VDD10_1092 METAL6_1557000_1049400 METAL6_1555400_1049400 0.0032
R_VDD10_1093 METAL6_1555400_1049400 METAL6_1551800_1049400 0.0072
R_VDD10_1094 METAL6_1551800_1049400 METAL6_1539800_1049400 0.024
R_VDD10_1095 METAL6_1539800_1049400 METAL6_1527800_1049400 0.024
R_VDD10_1096 METAL6_1527800_1049400 METAL6_1512000_1049400 0.0316
R_VDD10_1097 METAL6_1512000_1049400 METAL6_1510400_1049400 0.0032
R_VDD10_1098 METAL6_1510400_1049400 METAL6_1503400_1049400 0.014
R_VDD10_1099 METAL6_1503400_1049400 METAL6_1500000_1049400 0.0068
R_VDD10_1100 METAL6_1500000_1049400 METAL6_1498300_1049400 0.0034
R_VDD10_1101 METAL6_1498300_1049400 METAL6_1491400_1049400 0.0138
R_VDD10_1102 METAL6_1491400_1049400 METAL6_1488000_1049400 0.0068
R_VDD10_1103 METAL6_1488000_1049400 METAL6_1479400_1049400 0.0172
R_VDD10_1104 METAL6_1479400_1049400 METAL6_1443700_1049400 0.0714
R_VDD10_1105 METAL6_1443700_1049400 METAL6_1432800_1049400 0.0218
R_VDD10_1106 METAL6_1432800_1049400 METAL6_1431700_1049400 0.0022
R_VDD10_1107 METAL6_1431700_1049400 METAL6_1424000_1049400 0.0154
R_VDD10_1108 METAL6_1424000_1049400 METAL6_1419700_1049400 0.0086
R_VDD10_1109 METAL6_1419700_1049400 METAL6_1412000_1049400 0.0154
R_VDD10_1110 METAL6_1412000_1049400 METAL6_1400000_1049400 0.024
R_VDD10_1111 METAL6_1400000_1049400 METAL6_1388000_1049400 0.024
R_VDD10_1112 METAL6_1388000_1049400 METAL6_1337000_1049400 0.102
R_VDD10_1113 METAL6_1337000_1049400 METAL6_1325000_1049400 0.024
R_VDD10_1114 METAL6_1325000_1049400 METAL6_1324000_1049400 0.002
R_VDD10_1115 METAL6_1324000_1049400 METAL6_1313000_1049400 0.022
R_VDD10_1116 METAL6_1313000_1049400 METAL6_1312000_1049400 0.002
R_VDD10_1117 METAL6_1312000_1049400 METAL6_1312000_1049800 0.0008
R_VDD10_1118 METAL6_1312000_1049800 METAL6_1312000_1053800 0.008
R_VDD10_1119 METAL6_1312000_1053800 METAL6_1312000_1054700 0.0018
R_VDD10_1120 METAL6_1312000_1054700 METAL6_1312000_1061800 0.0142
R_VDD10_1121 METAL6_1312000_1061800 METAL6_1312000_1066700 0.0098
R_VDD10_1122 METAL6_1312000_1066700 METAL6_1312000_1073800 0.0142
R_VDD10_1123 METAL6_1312000_1073800 METAL6_1312000_1086000 0.0244
R_VDD10_1124 METAL6_1312000_1086000 METAL6_1312000_1088000 0.004
R_VDD10_1125 METAL6_1312000_1088000 METAL6_1312000_1098300 0.0206
R_VDD10_1126 METAL6_1312000_1098300 METAL6_1311800_1098300 0.0004
R_VDD10_1127 METAL6_1311800_1098300 METAL6_1301000_1098300 0.0216
R_VDD10_1128 METAL6_1301000_1098300 METAL6_1300000_1098300 0.002
R_VDD10_1129 METAL6_1300000_1098300 METAL6_1288000_1098300 0.024
R_VDD10_1130 METAL6_1288000_1098300 METAL6_1274700_1098300 0.0266
R_VDD10_1131 METAL6_1274700_1098300 METAL6_1266800_1098300 0.0158
R_VDD10_1132 METAL6_1266800_1098300 METAL6_1259800_1098300 0.014
R_VDD10_1133 METAL6_1259800_1098300 METAL6_1253300_1098300 0.013
R_VDD10_1134 METAL6_1253300_1098300 METAL6_1247800_1098300 0.011
R_VDD10_1135 METAL6_1247800_1098300 METAL6_1246300_1098300 0.003
R_VDD10_1136 METAL6_1246300_1098300 METAL6_1235800_1098300 0.021
R_VDD10_1137 METAL6_1235800_1098300 METAL6_1234300_1098300 0.003
R_VDD10_1138 METAL6_1234300_1098300 METAL6_1222300_1098300 0.024
R_VDD10_1139 METAL6_1222300_1098300 METAL6_1218700_1098300 0.0072
R_VDD10_1140 METAL6_1218700_1098300 METAL6_1218700_1098500 0.0004
R_VDD10_1141 METAL6_1218700_1098500 METAL6_1218700_1100000 0.003
R_VDD10_1142 METAL6_1218700_1100000 METAL6_1218700_1108800 0.0176
R_VDD10_1143 METAL6_1218700_1108800 METAL6_1218700_1110300 0.003
R_VDD10_1144 METAL6_1218700_1110300 METAL6_1218700_1112000 0.0034
R_VDD10_1145 METAL6_1218700_1112000 METAL6_1218700_1122300 0.0206
R_VDD10_1146 METAL6_1218700_1122300 METAL6_1218700_1129300 0.014
R_VDD10_1147 METAL6_1218700_1129300 METAL6_1218700_1134300 0.01
R_VDD10_1148 METAL6_1218700_1134300 METAL6_1218700_1141300 0.014
R_VDD10_1149 METAL6_1218700_1141300 METAL6_1218700_1153300 0.024
R_VDD10_1150 METAL6_1218700_1153300 METAL6_1218700_1160600 0.0146
R_VDD10_1151 METAL6_1218700_1160600 METAL6_1218700_1172600 0.024
R_VDD10_1152 METAL6_1218700_1172600 METAL6_1218700_1184600 0.024
R_VDD10_1153 METAL6_1218700_1184600 METAL6_1218700_1191600 0.014
R_VDD10_1154 METAL6_1218700_1191600 METAL6_1218700_1193800 0.0044
R_VDD10_1155 METAL6_1218700_1193800 METAL6_1218700_1217700 0.0478
R_VDD10_1156 METAL6_1218700_1217700 METAL6_1218700_1238000 0.0406
R_VDD10_1157 METAL6_1218700_1238000 METAL6_1218700_1247700 0.0194
R_VDD10_1158 METAL6_1218700_1247700 METAL6_1218700_1250000 0.0046
R_VDD10_1159 METAL6_1218700_1250000 METAL6_1218700_1259700 0.0194
R_VDD10_1160 METAL6_1218700_1259700 METAL6_1218700_1262000 0.0046
R_VDD10_1161 METAL6_1218700_1262000 METAL6_1218700_1271700 0.0194
R_VDD10_1162 METAL6_1218700_1271700 METAL6_1218700_1273000 0.0026
R_VDD10_1163 METAL6_1218700_1273000 METAL6_1218700_1326000 0.106
R_VDD10_1164 METAL6_1218700_1326000 METAL6_1218700_1338000 0.024
R_VDD10_1165 METAL6_1218700_1338000 METAL5_1218700_1338000 0.1
R_VDD10_1166 METAL5_1218700_1338000 METAL5_1218700_1350000 0.048
R_VDD10_1167 METAL5_1218700_1350000 METAL5_1218700_1362000 0.048
R_VDD10_1168 METAL5_1218700_1362000 METAL6_1218700_1362000 0.1
R_VDD10_1169 METAL6_1218700_1362000 METAL6_1218700_1374000 0.024
R_VDD10_1170 METAL6_1218700_1374000 METAL6_1218700_1381000 0.014
R_VDD10_1171 METAL6_1218700_1381000 METAL6_1212000_1381000 0.0134
R_VDD10_1172 METAL6_1212000_1381000 METAL6_1200000_1381000 0.024
R_VDD10_1173 METAL6_1200000_1381000 METAL6_1192400_1381000 0.0152
R_VDD10_1174 METAL6_1192400_1381000 METAL6_1192400_1386600 0.0112
R_VDD10_1175 METAL6_1192400_1386600 METAL6_1192400_1393000 0.0128
R_VDD10_1176 METAL6_1192400_1393000 METAL6_1192400_1405000 0.024
R_VDD10_1177 METAL6_1192400_1405000 METAL6_1192400_1437700 0.0654
R_VDD10_1178 METAL6_1192400_1437700 METAL6_1192400_1449700 0.024
R_VDD10_1179 METAL6_1192400_1449700 METAL6_1192400_1461700 0.024
R_VDD10_1180 METAL6_1192400_1461700 METAL6_1192400_1504300 0.0852
R_VDD10_1181 METAL6_1192400_1504300 METAL6_1192400_1516300 0.024
R_VDD10_1182 METAL6_1192400_1516300 METAL6_1192400_1528300 0.024
R_VDD10_1183 METAL6_1192400_1528300 METAL6_1192400_1540300 0.024
R_VDD10_1184 METAL6_1192400_1540300 METAL6_1192400_1552300 0.024
R_VDD10_1185 METAL6_1192400_1552300 METAL6_1188000_1552300 0.0088
R_VDD10_1186 METAL6_1188000_1552300 METAL6_1173700_1552300 0.0286
R_VDD10_1187 METAL6_1173700_1552300 METAL6_1166700_1552300 0.014
R_VDD10_1188 METAL6_1166700_1552300 METAL6_1154700_1552300 0.024
R_VDD10_1189 METAL6_1154700_1552300 METAL6_1142700_1552300 0.024
R_VDD10_1190 METAL6_1142700_1552300 METAL6_1137000_1552300 0.0114
R_VDD10_1191 METAL6_1137000_1552300 METAL6_1130700_1552300 0.0126
R_VDD10_1192 METAL6_1130700_1552300 METAL6_1125000_1552300 0.0114
R_VDD10_1193 METAL6_1125000_1552300 METAL6_1113000_1552300 0.024
R_VDD10_1194 METAL6_1113000_1552300 METAL6_1019000_1552300 0.188
R_VDD10_1195 METAL6_1019000_1552300 METAL6_1007000_1552300 0.024
R_VDD10_1196 METAL6_1007000_1552300 METAL6_995000_1552300 0.024
R_VDD10_1197 METAL6_995000_1552300 METAL6_988000_1552300 0.014
R_VDD10_1198 METAL6_988000_1552300 METAL6_947400_1552300 0.0812
R_VDD10_1199 METAL6_947400_1552300 METAL6_940400_1552300 0.014
R_VDD10_1200 METAL6_940400_1552300 METAL6_928400_1552300 0.024
R_VDD10_1201 METAL6_928400_1552300 METAL6_916400_1552300 0.024
R_VDD10_1202 METAL6_916400_1552300 METAL6_916400_1554500 0.0044
R_VDD10_1203 METAL6_916400_1554500 METAL6_916400_1564300 0.0196
R_VDD10_1204 METAL6_916400_1564300 METAL6_916400_1571300 0.014
R_VDD10_1205 METAL6_916400_1571300 METAL6_916400_1714500 0.2864
R_VDD10_1206 METAL6_916400_1714500 METAL6_916400_1720500 0.012
R_VDD10_1207 METAL6_916400_1720500 METAL6_916400_1726500 0.012
R_VDD10_1208 METAL6_916400_1726500 METAL6_916400_1731700 0.0104
R_VDD10_1209 METAL6_916400_1731700 METAL6_916400_1738500 0.0136
R_VDD10_1210 METAL6_916400_1738500 METAL6_916400_1750500 0.024
R_VDD10_1211 METAL6_916400_1750500 METAL6_916400_1762500 0.024
R_VDD10_1212 METAL6_916400_1762500 METAL6_916400_1774500 0.024
R_VDD10_1213 METAL6_916400_1774500 METAL6_916400_1814500 0.08
R_VDD10_1214 METAL6_916400_1814500 METAL6_928400_1814500 0.024
R_VDD10_1215 METAL6_928400_1814500 METAL6_928400_1826500 0.024
R_VDD10_1216 METAL6_940400_1826500 METAL6_928400_1826500 0.024
R_VDD10_1217 METAL6_1853400_2536000 METAL6_1865400_2536000 0.024
R_VDD10_1218 METAL6_1192400_1504300 METAL6_1200000_1504300 0.0152
R_VDD10_1219 METAL6_1200000_1504300 METAL6_1204400_1504300 0.0088
R_VDD10_1220 METAL6_1204400_1504300 METAL6_1204400_1516300 0.024
R_VDD10_1221 METAL6_1204400_1516300 METAL6_1204400_1528300 0.024
R_VDD10_1222 METAL6_1204400_1528300 METAL6_1204400_1540300 0.024
R_VDD10_1223 METAL6_1204400_1540300 METAL6_1204400_1552300 0.024
R_VDD10_1224 METAL6_1204400_1552300 METAL6_1206700_1552300 0.0046
R_VDD10_1225 METAL6_1206700_1552300 METAL6_1212000_1552300 0.0106
R_VDD10_1226 METAL6_1212000_1552300 METAL6_1218700_1552300 0.0134
R_VDD10_1227 METAL6_1218700_1552300 METAL6_1222300_1552300 0.0072
R_VDD10_1228 METAL6_1222300_1552300 METAL6_1230700_1552300 0.0168
R_VDD10_1229 METAL6_1230700_1552300 METAL6_1234300_1552300 0.0072
R_VDD10_1230 METAL6_1234300_1552300 METAL6_1234300_1554500 0.0044
R_VDD10_1231 METAL6_1234300_1554500 METAL6_1234300_1564300 0.0196
R_VDD10_1232 METAL6_1234300_1564300 METAL6_1234300_1571300 0.014
R_VDD10_1233 METAL6_1234300_1571300 METAL6_1234300_1714500 0.2864
R_VDD10_1234 METAL6_1234300_1714500 METAL6_1234300_1720500 0.012
R_VDD10_1235 METAL6_1234300_1720500 METAL6_1234300_1726500 0.012
R_VDD10_1236 METAL6_1234300_1726500 METAL6_1234300_1731700 0.0104
R_VDD10_1237 METAL6_1234300_1731700 METAL6_1234300_1738500 0.0136
R_VDD10_1238 METAL6_1234300_1738500 METAL6_1234300_1750500 0.024
R_VDD10_1239 METAL6_1234300_1750500 METAL6_1234300_1762500 0.024
R_VDD10_1240 METAL6_1234300_1762500 METAL6_1234300_1774500 0.024
R_VDD10_1241 METAL6_1234300_1774500 METAL6_1234300_1802500 0.056
R_VDD10_1242 METAL6_1234300_1802500 METAL6_1234300_1814500 0.024
R_VDD10_1243 METAL6_1234300_1814500 METAL6_1234300_1826500 0.024
R_VDD10_1244 METAL6_1234300_1826500 METAL6_1234300_1838500 0.024
R_VDD10_1245 METAL6_1234300_1838500 METAL6_1234300_1852300 0.0276
R_VDD10_1246 METAL6_1234300_1852300 METAL6_1234300_1866300 0.028
R_VDD10_1247 METAL6_1234300_1866300 METAL6_1234300_1914500 0.0964
R_VDD10_1248 METAL6_1234300_1914500 METAL6_1234300_1926500 0.024
R_VDD10_1249 METAL6_1234300_1926500 METAL6_1234300_1938500 0.024
R_VDD10_1250 METAL6_1234300_1938500 METAL6_1234300_1940500 0.004
R_VDD10_1251 METAL6_1234300_1940500 METAL6_1234300_1950500 0.02
R_VDD10_1252 METAL6_1234300_1950500 METAL6_1234300_1952500 0.004
R_VDD10_1253 METAL6_1234300_1952500 METAL6_1234300_1963000 0.021
R_VDD10_1254 METAL6_1234300_1963000 METAL6_1235800_1963000 0.003
R_VDD10_1255 METAL6_1235800_1963000 METAL6_1246300_1963000 0.021
R_VDD10_1256 METAL6_1246300_1963000 METAL6_1246300_1964500 0.003
R_VDD10_1257 METAL6_1246300_1964500 METAL6_1246300_1975000 0.021
R_VDD10_1258 METAL6_1246300_1975000 METAL6_1246300_1976500 0.003
R_VDD10_1259 METAL6_1246300_1976500 METAL6_1246300_1987000 0.021
R_VDD10_1260 METAL6_1246300_1987000 METAL6_1246300_2014500 0.055
R_VDD10_1261 METAL6_1246300_2014500 METAL6_1246300_2026500 0.024
R_VDD10_1262 METAL6_1246300_2026500 METAL6_1246300_2038500 0.024
R_VDD10_1263 METAL6_1246300_2038500 METAL6_1246300_2114500 0.152
R_VDD10_1264 METAL6_1246300_2114500 METAL6_1246300_2126500 0.024
R_VDD10_1265 METAL6_1246300_2126500 METAL6_1246300_2138500 0.024
R_VDD10_1266 METAL6_1246300_2138500 METAL6_1246300_2147300 0.0176
R_VDD10_1267 METAL6_1246300_2147300 METAL6_1246300_2154300 0.014
R_VDD10_1268 METAL6_1246300_2154300 METAL6_1246300_2163000 0.0174
R_VDD10_1269 METAL6_1246300_2163000 METAL6_1246300_2166300 0.0066
R_VDD10_1270 METAL6_1246300_2166300 METAL6_1246300_2175000 0.0174
R_VDD10_1271 METAL6_1246300_2175000 METAL6_1246300_2178300 0.0066
R_VDD10_1272 METAL6_1246300_2178300 METAL6_1246300_2187000 0.0174
R_VDD10_1273 METAL6_1246300_2187000 METAL6_1246300_2190300 0.0066
R_VDD10_1274 METAL6_1246300_2190300 METAL6_1246300_2222500 0.0644
R_VDD10_1275 METAL6_1246300_2222500 METAL6_1246300_2234500 0.024
R_VDD10_1276 METAL6_1246300_2234500 METAL6_1246300_2246500 0.024
R_VDD10_1277 METAL6_1246300_2246500 METAL6_1246300_2268500 0.044
R_VDD10_1278 METAL6_1246300_2268500 METAL6_1246300_2288000 0.039
R_VDD10_1279 METAL6_1246300_2288000 METAL6_1246300_2300000 0.024
R_VDD10_1280 METAL6_1246300_2300000 METAL6_1246300_2312000 0.024
R_VDD10_1281 METAL6_1246300_2312000 METAL6_1246300_2338000 0.052
R_VDD10_1282 METAL6_1246300_2338000 METAL6_1246300_2350000 0.024
R_VDD10_1283 METAL6_1246300_2350000 METAL6_1246300_2362000 0.024
R_VDD10_1284 METAL6_1246300_2362000 METAL6_1246300_2377000 0.03
R_VDD10_1285 METAL6_1246300_2377000 METAL6_1246300_2388000 0.022
R_VDD10_1286 METAL6_1246300_2388000 METAL6_1247800_2388000 0.003
R_VDD10_1287 METAL6_1247800_2388000 METAL6_1253300_2388000 0.011
R_VDD10_1288 METAL6_1253300_2388000 METAL6_1259800_2388000 0.013
R_VDD10_1289 METAL6_1259800_2388000 METAL6_1266800_2388000 0.014
R_VDD10_1290 METAL6_1266800_2388000 METAL6_1274700_2388000 0.0158
R_VDD10_1291 METAL6_1274700_2388000 METAL6_1288000_2388000 0.0266
R_VDD10_1292 METAL6_1288000_2388000 METAL6_1300000_2388000 0.024
R_VDD10_1293 METAL6_1300000_2388000 METAL6_1301000_2388000 0.002
R_VDD10_1294 METAL6_1301000_2388000 METAL6_1311800_2388000 0.0216
R_VDD10_1295 METAL6_1311800_2388000 METAL6_1311800_2389000 0.002
R_VDD10_1296 METAL6_1311800_2389000 METAL6_1312000_2389000 0.0004
R_VDD10_1297 METAL6_1312000_2389000 METAL6_1313000_2389000 0.002
R_VDD10_1298 METAL6_1313000_2389000 METAL6_1324000_2389000 0.022
R_VDD10_1299 METAL6_1324000_2389000 METAL6_1325000_2389000 0.002
R_VDD10_1300 METAL6_1325000_2389000 METAL6_1337000_2389000 0.024
R_VDD10_1301 METAL6_1337000_2389000 METAL6_1388000_2389000 0.102
R_VDD10_1302 METAL6_1388000_2389000 METAL6_1400000_2389000 0.024
R_VDD10_1303 METAL6_1400000_2389000 METAL6_1412000_2389000 0.024
R_VDD10_1304 METAL6_1412000_2389000 METAL6_1419700_2389000 0.0154
R_VDD10_1305 METAL6_1419700_2389000 METAL6_1424000_2389000 0.0086
R_VDD10_1306 METAL6_1424000_2389000 METAL6_1431700_2389000 0.0154
R_VDD10_1307 METAL6_1431700_2389000 METAL6_1432800_2389000 0.0022
R_VDD10_1308 METAL6_1432800_2389000 METAL6_1443700_2389000 0.0218
R_VDD10_1309 METAL6_1443700_2389000 METAL6_1479400_2389000 0.0714
R_VDD10_1310 METAL6_1479400_2389000 METAL6_1488000_2389000 0.0172
R_VDD10_1311 METAL6_1488000_2389000 METAL6_1491400_2389000 0.0068
R_VDD10_1312 METAL6_1491400_2389000 METAL6_1498300_2389000 0.0138
R_VDD10_1313 METAL6_1498300_2389000 METAL6_1500000_2389000 0.0034
R_VDD10_1314 METAL6_1500000_2389000 METAL6_1503400_2389000 0.0068
R_VDD10_1315 METAL6_1503400_2389000 METAL6_1510400_2389000 0.014
R_VDD10_1316 METAL6_1510400_2389000 METAL6_1512000_2389000 0.0032
R_VDD10_1317 METAL6_1512000_2389000 METAL6_1527800_2389000 0.0316
R_VDD10_1318 METAL6_1527800_2389000 METAL6_1539800_2389000 0.024
R_VDD10_1319 METAL6_1539800_2389000 METAL6_1551800_2389000 0.024
R_VDD10_1320 METAL6_1551800_2389000 METAL6_1555400_2389000 0.0072
R_VDD10_1321 METAL6_1555400_2389000 METAL6_1557000_2389000 0.0032
R_VDD10_1322 METAL6_1557000_2389000 METAL6_1574700_2389000 0.0354
R_VDD10_1323 METAL6_1574700_2389000 METAL6_1576000_2389000 0.0026
R_VDD10_1324 METAL6_1576000_2389000 METAL6_1576700_2389000 0.0014
R_VDD10_1325 METAL6_1576700_2389000 METAL6_1588000_2389000 0.0226
R_VDD10_1326 METAL6_1588000_2389000 METAL6_1588700_2389000 0.0014
R_VDD10_1327 METAL6_1588700_2389000 METAL6_1600000_2389000 0.0226
R_VDD10_1328 METAL6_1600000_2389000 METAL6_1600700_2389000 0.0014
R_VDD10_1329 METAL6_1600700_2389000 METAL6_1607900_2389000 0.0144
R_VDD10_1330 METAL6_1607900_2389000 METAL6_1612000_2389000 0.0082
R_VDD10_1331 METAL6_1612000_2389000 METAL6_1612700_2389000 0.0014
R_VDD10_1332 METAL6_1612700_2389000 METAL6_1615800_2389000 0.0062
R_VDD10_1333 METAL6_1615800_2389000 METAL6_1632800_2389000 0.034
R_VDD10_1334 METAL6_1632800_2389000 METAL6_1634800_2389000 0.004
R_VDD10_1335 METAL6_1634800_2389000 METAL6_1646800_2389000 0.024
R_VDD10_1336 METAL6_1646800_2389000 METAL6_1658800_2389000 0.024
R_VDD10_1337 METAL6_1658800_2389000 METAL6_1668000_2389000 0.0184
R_VDD10_1338 METAL6_1668000_2389000 METAL6_1670800_2389000 0.0056
R_VDD10_1339 METAL6_1670800_2389000 METAL6_1680000_2389000 0.0184
R_VDD10_1340 METAL6_1680000_2389000 METAL6_1692000_2389000 0.024
R_VDD10_1341 METAL6_1692000_2389000 METAL6_1699000_2389000 0.014
R_VDD10_1342 METAL6_1699000_2389000 METAL6_1707700_2389000 0.0174
R_VDD10_1343 METAL6_1707700_2389000 METAL6_1710800_2389000 0.0062
R_VDD10_1344 METAL6_1710800_2389000 METAL6_1717800_2389000 0.014
R_VDD10_1345 METAL6_1717800_2389000 METAL6_1719700_2389000 0.0038
R_VDD10_1346 METAL6_1719700_2389000 METAL6_1727800_2389000 0.0162
R_VDD10_1347 METAL6_1727800_2389000 METAL6_1729800_2389000 0.004
R_VDD10_1348 METAL6_1729800_2389000 METAL6_1731700_2389000 0.0038
R_VDD10_1349 METAL6_1731700_2389000 METAL6_1739800_2389000 0.0162
R_VDD10_1350 METAL6_1739800_2389000 METAL6_1741800_2389000 0.004
R_VDD10_1351 METAL6_1741800_2389000 METAL6_1743700_2389000 0.0038
R_VDD10_1352 METAL6_1743700_2389000 METAL6_1744000_2389000 0.0006
R_VDD10_1353 METAL6_1744000_2389000 METAL6_1751400_2389000 0.0148
R_VDD10_1354 METAL6_1751400_2389000 METAL6_1751800_2389000 0.0008
R_VDD10_1355 METAL6_1751800_2389000 METAL6_1755700_2389000 0.0078
R_VDD10_1356 METAL6_1755700_2389000 METAL6_1788000_2389000 0.0646
R_VDD10_1357 METAL6_1788000_2389000 METAL6_1800000_2389000 0.024
R_VDD10_1358 METAL6_1800000_2389000 METAL6_1812000_2389000 0.024
R_VDD10_1359 METAL6_1812000_2389000 METAL6_1820800_2389000 0.0176
R_VDD10_1360 METAL6_1820800_2389000 METAL6_1832800_2389000 0.024
R_VDD10_1361 METAL6_1832800_2389000 METAL6_1834400_2389000 0.0032
R_VDD10_1362 METAL6_1834400_2389000 METAL6_1834600_2389000 0.0004
R_VDD10_1363 METAL6_1834600_2389000 METAL6_1844800_2389000 0.0204
R_VDD10_1364 METAL6_1844800_2389000 METAL6_1846400_2389000 0.0032
R_VDD10_1365 METAL6_1846400_2389000 METAL6_1846600_2389000 0.0004
R_VDD10_1366 METAL6_1846600_2389000 METAL6_1846800_2389000 0.0004
R_VDD10_1367 METAL6_1846800_2389000 METAL6_1853400_2389000 0.0132
R_VDD10_1368 METAL6_1853400_2389000 METAL6_1858400_2389000 0.01
R_VDD10_1369 METAL6_1858400_2389000 METAL6_1858600_2389000 0.0004
R_VDD10_1370 METAL6_1858600_2389000 METAL6_1864700_2389000 0.0122
R_VDD10_1371 METAL6_1864700_2389000 METAL6_1865400_2389000 0.0014
R_VDD10_1372 METAL6_1865400_2389000 METAL6_1865400_2400000 0.022
R_VDD10_1373 METAL6_1865400_2400000 METAL6_1865400_2401000 0.002
R_VDD10_1374 METAL6_1865400_2401000 METAL6_1865400_2407000 0.012
R_VDD10_1375 METAL6_1865400_2407000 METAL6_1865400_2412000 0.01
R_VDD10_1376 METAL6_1865400_2412000 METAL6_1865400_2438000 0.052
R_VDD10_1377 METAL6_1865400_2438000 METAL6_1865400_2444000 0.012
R_VDD10_1378 METAL6_1865400_2444000 METAL6_1865400_2450000 0.012
R_VDD10_1379 METAL6_1865400_2450000 METAL6_1865400_2456000 0.012
R_VDD10_1380 METAL6_1865400_2456000 METAL6_1865400_2462000 0.012
R_VDD10_1381 METAL6_1865400_2462000 METAL6_1865400_2468000 0.012
R_VDD10_1382 METAL6_1865400_2468000 METAL6_1865400_2481000 0.026
R_VDD10_1383 METAL6_1865400_2481000 METAL6_1865400_2493000 0.024
R_VDD10_1384 METAL6_1865400_2493000 METAL6_1865400_2505000 0.024
R_VDD10_1385 METAL6_1865400_2505000 METAL6_1865400_2512000 0.014
R_VDD10_1386 METAL6_1865400_2512000 METAL6_1865400_2524000 0.024
R_VDD10_1387 METAL6_1865400_2524000 METAL6_1865400_2536000 0.024
R_VDD10_1388 METAL6_1919200_2456000 METAL6_1913600_2456000 0.0112
R_VDD10_1389 METAL6_1913600_2456000 METAL6_1907400_2456000 0.0124
R_VDD10_1390 METAL6_1907400_2456000 METAL6_1907200_2456000 0.0004
R_VDD10_1391 METAL6_2460600_52600 METAL6_2460600_40600 0.024
R_VDD10_1392 METAL6_2460600_40600 METAL6_2446600_40600 0.028
R_VDD10_1393 METAL6_2446600_40600 METAL6_2407100_40600 0.079
R_VDD10_1394 METAL6_2407100_40600 METAL6_2405600_40600 0.003
R_VDD10_1395 METAL6_2405600_40600 METAL6_2402100_40600 0.007
R_VDD10_1396 METAL6_2402100_40600 METAL6_2395100_40600 0.014
R_VDD10_1397 METAL6_2395100_40600 METAL6_2393600_40600 0.003
R_VDD10_1398 METAL6_2393600_40600 METAL6_2383100_40600 0.021
R_VDD10_1399 METAL6_2383100_40600 METAL6_2381600_40600 0.003
R_VDD10_1400 METAL6_2381600_40600 METAL6_2371100_40600 0.021
R_VDD10_1401 METAL6_2371100_40600 METAL6_2369600_40600 0.003
R_VDD10_1402 METAL6_2369600_40600 METAL6_2369600_52600 0.024
R_VDD10_1403 METAL6_2369600_52600 METAL6_2365900_52600 0.0074
R_VDD10_1404 METAL6_2365900_52600 METAL6_2351900_52600 0.028
R_VDD10_1405 METAL6_2351900_52600 METAL6_2343700_52600 0.0164
R_VDD10_1406 METAL6_2343700_52600 METAL6_2310900_52600 0.0656
R_VDD10_1407 METAL6_2310900_52600 METAL6_2298900_52600 0.024
R_VDD10_1408 METAL6_2298900_52600 METAL6_2286900_52600 0.024
R_VDD10_1409 METAL6_2286900_52600 METAL6_2272400_52600 0.029
R_VDD10_1410 METAL6_2272400_52600 METAL6_2260600_52600 0.0236
R_VDD10_1411 METAL6_2260600_52600 METAL6_2260400_52600 0.0004
R_VDD10_1412 METAL6_2260400_52600 METAL6_2258600_52600 0.0036
R_VDD10_1413 METAL6_2258600_52600 METAL6_2248700_52600 0.0198
R_VDD10_1414 METAL6_2248700_52600 METAL6_2248400_52600 0.0006
R_VDD10_1415 METAL6_2248400_52600 METAL6_2246600_52600 0.0036
R_VDD10_1416 METAL6_2246600_52600 METAL6_2236700_52600 0.0198
R_VDD10_1417 METAL6_2236700_52600 METAL6_2234600_52600 0.0042
R_VDD10_1418 METAL6_2234600_52600 METAL6_2224700_52600 0.0198
R_VDD10_1419 METAL6_2224700_52600 METAL6_2221900_52600 0.0056
R_VDD10_1420 METAL6_2221900_52600 METAL6_2212700_52600 0.0184
R_VDD10_1421 METAL6_2212700_52600 METAL6_2200700_52600 0.024
R_VDD10_1422 METAL6_2200700_52600 METAL6_2188700_52600 0.024
R_VDD10_1423 METAL6_2188700_52600 METAL6_2177900_52600 0.0216
R_VDD10_1424 METAL6_2177900_52600 METAL6_2176700_52600 0.0024
R_VDD10_1425 METAL6_2176700_52600 METAL6_2165900_52600 0.0216
R_VDD10_1426 METAL6_2165900_52600 METAL6_2165400_52600 0.001
R_VDD10_1427 METAL6_2165400_52600 METAL6_2153900_52600 0.023
R_VDD10_1428 METAL6_2153900_52600 METAL6_2153400_52600 0.001
R_VDD10_1429 METAL6_2153400_52600 METAL6_2151900_52600 0.003
R_VDD10_1430 METAL6_2151900_52600 METAL6_2141400_52600 0.021
R_VDD10_1431 METAL6_2141400_52600 METAL6_2129700_52600 0.0234
R_VDD10_1432 METAL6_2129700_52600 METAL6_2125600_52600 0.0082
R_VDD10_1433 METAL6_2125600_52600 METAL6_2121400_52600 0.0084
R_VDD10_1434 METAL6_2121400_52600 METAL6_2113600_52600 0.0156
R_VDD10_1435 METAL6_2113600_52600 METAL6_2101900_52600 0.0234
R_VDD10_1436 METAL6_2101900_52600 METAL6_2101600_52600 0.0006
R_VDD10_1437 METAL6_2101600_52600 METAL6_2089900_52600 0.0234
R_VDD10_1438 METAL6_2089900_52600 METAL6_2077900_52600 0.024
R_VDD10_1439 METAL6_2077900_52600 METAL6_2067700_52600 0.0204
R_VDD10_1440 METAL6_2067700_52600 METAL6_2060600_52600 0.0142
R_VDD10_1441 METAL6_2060600_52600 METAL6_2055700_52600 0.0098
R_VDD10_1442 METAL6_2055700_52600 METAL6_2046800_52600 0.0178
R_VDD10_1443 METAL6_2046800_52600 METAL6_2046600_52600 0.0004
R_VDD10_1444 METAL6_2046600_52600 METAL6_2046400_52600 0.0004
R_VDD10_1445 METAL6_2046400_52600 METAL6_2043700_52600 0.0054
R_VDD10_1446 METAL6_2043700_52600 METAL6_2031700_52600 0.024
R_VDD10_1447 METAL6_2031700_52600 METAL6_2030900_52600 0.0016
R_VDD10_1448 METAL6_2030900_52600 METAL6_2026400_52600 0.009
R_VDD10_1449 METAL6_2026400_52600 METAL6_2021200_52600 0.0104
R_VDD10_1450 METAL6_2021200_52600 METAL6_2019700_52600 0.003
R_VDD10_1451 METAL6_2019700_52600 METAL6_2018900_52600 0.0016
R_VDD10_1452 METAL6_2018900_52600 METAL6_2014400_52600 0.009
R_VDD10_1453 METAL6_2014400_52600 METAL6_2012000_52600 0.0048
R_VDD10_1454 METAL6_2012000_52600 METAL6_2006900_52600 0.0102
R_VDD10_1455 METAL6_2006900_52600 METAL6_2002400_52600 0.009
R_VDD10_1456 METAL6_2002400_52600 METAL6_2000000_52600 0.0048
R_VDD10_1457 METAL6_2000000_52600 METAL6_1988000_52600 0.024
R_VDD10_1458 METAL6_1988000_52600 METAL6_1951900_52600 0.0722
R_VDD10_1459 METAL6_1951900_52600 METAL6_1951800_52600 0.0002
R_VDD10_1460 METAL6_1951800_52600 METAL6_1939800_52600 0.024
R_VDD10_1461 METAL6_1939800_52600 METAL6_1927800_52600 0.024
R_VDD10_1462 METAL6_1927800_52600 METAL6_1926200_52600 0.0032
R_VDD10_1463 METAL6_1926200_52600 METAL6_1925600_52600 0.0012
R_VDD10_1464 METAL6_1925600_52600 METAL6_1919200_52600 0.0128
R_VDD10_1465 METAL6_1919200_52600 METAL6_1913600_52600 0.0112
R_VDD10_1466 METAL6_1913600_52600 METAL6_1907400_52600 0.0124
R_VDD10_1467 METAL6_1907400_52600 METAL6_1907200_52600 0.0004
R_VDD10_1468 METAL6_1907200_52600 METAL6_1901600_52600 0.0112
R_VDD10_1469 METAL6_1901600_52600 METAL6_1900700_52600 0.0018
R_VDD10_1470 METAL6_1900700_52600 METAL6_1895200_52600 0.011
R_VDD10_1471 METAL6_1895200_52600 METAL6_1888700_52600 0.013
R_VDD10_1472 METAL6_1888700_52600 METAL6_1877400_52600 0.0226
R_VDD10_1473 METAL6_1877400_52600 METAL6_1876700_52600 0.0014
R_VDD10_1474 METAL6_1876700_52600 METAL6_1874700_52600 0.004
R_VDD10_1475 METAL6_1874700_52600 METAL6_1865400_52600 0.0186
R_VDD10_1476 METAL6_1865400_52600 METAL6_1864700_52600 0.0014
R_VDD10_1477 METAL6_1864700_52600 METAL6_1858600_52600 0.0122
R_VDD10_1478 METAL6_1858600_52600 METAL6_1858400_52600 0.0004
R_VDD10_1479 METAL6_1858400_52600 METAL6_1853400_52600 0.01
R_VDD10_1480 METAL6_1853400_52600 METAL6_1846800_52600 0.0132
R_VDD10_1481 METAL6_1846800_52600 METAL6_1846600_52600 0.0004
R_VDD10_1482 METAL6_1846600_52600 METAL6_1846400_52600 0.0004
R_VDD10_1483 METAL6_1846400_52600 METAL6_1844800_52600 0.0032
R_VDD10_1484 METAL6_1844800_52600 METAL6_1834600_52600 0.0204
R_VDD10_1485 METAL6_1834600_52600 METAL6_1834600_64600 0.024
R_VDD10_1486 METAL6_1834600_64600 METAL6_1834600_76600 0.024
R_VDD10_1487 METAL6_1834600_76600 METAL6_1834600_83600 0.014
R_VDD10_1488 METAL6_1834600_83600 METAL6_1834600_88000 0.0088
R_VDD10_1489 METAL6_1834600_88000 METAL6_1834600_88600 0.0012
R_VDD10_1490 METAL6_1834600_88600 METAL6_1834600_100000 0.0228
R_VDD10_1491 METAL6_1834600_100000 METAL6_1834600_112000 0.024
R_VDD10_1492 METAL6_1834600_112000 METAL6_1834600_159600 0.0952
R_VDD10_1493 METAL6_1834600_159600 METAL6_1834600_166600 0.014
R_VDD10_1494 METAL6_1834600_166600 METAL6_1834600_178600 0.024
R_VDD10_1495 METAL6_1834600_178600 METAL5_1834600_178600 0.1
R_VDD10_1496 METAL5_1834600_178600 METAL5_1844800_178600 0.0408
R_VDD10_1497 METAL5_1844800_178600 METAL5_1846400_178600 0.0064
R_VDD10_1498 METAL5_1846400_178600 METAL5_1846600_178600 0.0008
R_VDD10_1499 METAL5_1846600_178600 METAL5_1846800_178600 0.0008
R_VDD10_1500 METAL5_1846800_178600 METAL5_1853400_178600 0.0264
R_VDD10_1501 METAL5_1853400_178600 METAL5_1858400_178600 0.02
R_VDD10_1502 METAL5_1858400_178600 METAL5_1858600_178600 0.0008
R_VDD10_1503 METAL5_1858600_178600 METAL6_1858600_178600 0.1
R_VDD10_1504 METAL6_1858600_178600 METAL6_1858600_188000 0.0188
R_VDD10_1505 METAL6_1858600_188000 METAL6_1864700_188000 0.0122
R_VDD10_1506 METAL6_1864700_188000 METAL6_1864700_190600 0.0052
R_VDD10_1507 METAL6_1864700_190600 METAL6_1864700_200000 0.0188
R_VDD10_1508 METAL6_1864700_200000 METAL6_1864700_212000 0.024
R_VDD10_1509 METAL6_1864700_212000 METAL6_1864700_248300 0.0726
R_VDD10_1510 METAL6_1864700_248300 METAL6_1864700_260300 0.024
R_VDD10_1511 METAL6_1864700_260300 METAL6_1864700_263000 0.0054
R_VDD10_1512 METAL6_1864700_263000 METAL6_1864700_272300 0.0186
R_VDD10_1513 METAL6_1864700_272300 METAL6_1864700_275000 0.0054
R_VDD10_1514 METAL6_1864700_275000 METAL6_1864700_279300 0.0086
R_VDD10_1515 METAL6_1864700_279300 METAL6_1864700_287000 0.0154
R_VDD10_1516 METAL6_1864700_287000 METAL6_1864700_288000 0.002
R_VDD10_1517 METAL6_1864700_288000 METAL6_1864700_299000 0.022
R_VDD10_1518 METAL6_1864700_299000 METAL6_1864700_300000 0.002
R_VDD10_1519 METAL6_1864700_300000 METAL6_1864700_312000 0.024
R_VDD10_1520 METAL6_1864700_312000 METAL6_1864700_355300 0.0866
R_VDD10_1521 METAL6_1864700_355300 METAL6_1864700_362300 0.014
R_VDD10_1522 METAL6_1864700_362300 METAL6_1864700_374300 0.024
R_VDD10_1523 METAL6_1864700_374300 METAL6_1864700_386300 0.024
R_VDD10_1524 METAL6_1864700_386300 METAL6_1864700_388000 0.0034
R_VDD10_1525 METAL6_1864700_388000 METAL6_1864700_400000 0.024
R_VDD10_1526 METAL6_1864700_400000 METAL6_1864700_402800 0.0056
R_VDD10_1527 METAL6_1864700_402800 METAL6_1864700_412000 0.0184
R_VDD10_1528 METAL6_1864700_412000 METAL6_1864700_449000 0.074
R_VDD10_1529 METAL6_1864700_449000 METAL6_1864700_453000 0.008
R_VDD10_1530 METAL6_1864700_453000 METAL6_1864700_465000 0.024
R_VDD10_1531 METAL6_1864700_465000 METAL6_1864700_477000 0.024
R_VDD10_1532 METAL6_1864700_477000 METAL6_1864700_480400 0.0068
R_VDD10_1533 METAL6_1864700_480400 METAL6_1864700_488000 0.0152
R_VDD10_1534 METAL6_1864700_488000 METAL6_1864700_500000 0.024
R_VDD10_1535 METAL6_1864700_500000 METAL6_1864700_504000 0.008
R_VDD10_1536 METAL6_1864700_504000 METAL6_1864700_507000 0.006
R_VDD10_1537 METAL6_1864700_507000 METAL6_1864700_507800 0.0016
R_VDD10_1538 METAL6_1864700_507800 METAL6_1864700_512000 0.0084
R_VDD10_1539 METAL6_1864700_512000 METAL6_1864700_516000 0.008
R_VDD10_1540 METAL6_1864700_516000 METAL6_1864700_528000 0.024
R_VDD10_1541 METAL6_1864700_528000 METAL6_1864700_535400 0.0148
R_VDD10_1542 METAL6_1864700_535400 METAL6_1864700_544200 0.0176
R_VDD10_1543 METAL6_1864700_544200 METAL6_1864700_547400 0.0064
R_VDD10_1544 METAL6_1864700_547400 METAL6_1864700_559400 0.024
R_VDD10_1545 METAL6_1864700_559400 METAL6_1864700_573000 0.0272
R_VDD10_1546 METAL6_1864700_573000 METAL6_1864700_579800 0.0136
R_VDD10_1547 METAL6_1864700_579800 METAL6_1864700_586400 0.0132
R_VDD10_1548 METAL6_1864700_586400 METAL6_1864700_588000 0.0032
R_VDD10_1549 METAL6_1864700_588000 METAL6_1864700_600000 0.024
R_VDD10_1550 METAL6_1864700_600000 METAL6_1864700_612000 0.024
R_VDD10_1551 METAL6_1864700_612000 METAL6_1864700_637800 0.0516
R_VDD10_1552 METAL6_1864700_637800 METAL6_1864700_641400 0.0072
R_VDD10_1553 METAL6_1864700_641400 METAL6_1864700_649800 0.0168
R_VDD10_1554 METAL6_1864700_649800 METAL6_1864700_653400 0.0072
R_VDD10_1555 METAL6_1864700_653400 METAL6_1864700_661800 0.0168
R_VDD10_1556 METAL6_1864700_661800 METAL6_1864700_665400 0.0072
R_VDD10_1557 METAL6_1864700_665400 METAL6_1864700_688000 0.0452
R_VDD10_1558 METAL6_1864700_688000 METAL6_1864700_700000 0.024
R_VDD10_1559 METAL6_1864700_700000 METAL6_1864700_702800 0.0056
R_VDD10_1560 METAL6_1864700_702800 METAL6_1864700_709800 0.014
R_VDD10_1561 METAL6_1864700_709800 METAL6_1864700_712000 0.0044
R_VDD10_1562 METAL6_1864700_712000 METAL6_1864700_716800 0.0096
R_VDD10_1563 METAL6_1864700_716800 METAL6_1864700_721800 0.01
R_VDD10_1564 METAL6_1864700_721800 METAL6_1864700_733800 0.024
R_VDD10_1565 METAL6_1864700_733800 METAL6_1864700_735400 0.0032
R_VDD10_1566 METAL6_1864700_735400 METAL6_1864700_758400 0.046
R_VDD10_1567 METAL6_1864700_758400 METAL6_1864700_763000 0.0092
R_VDD10_1568 METAL6_1864700_763000 METAL6_1864700_770400 0.0148
R_VDD10_1569 METAL6_1864700_770400 METAL6_1864700_772000 0.0032
R_VDD10_1570 METAL6_1864700_772000 METAL6_1864700_778400 0.0128
R_VDD10_1571 METAL6_1864700_778400 METAL6_1864700_779200 0.0016
R_VDD10_1572 METAL6_1864700_779200 METAL6_1864700_782400 0.0064
R_VDD10_1573 METAL6_1864700_782400 METAL6_1864700_784500 0.0042
R_VDD10_1574 METAL6_1864700_784500 METAL6_1864700_788000 0.007
R_VDD10_1575 METAL6_1864700_788000 METAL6_1864700_790400 0.0048
R_VDD10_1576 METAL6_1864700_790400 METAL6_1864700_791200 0.0016
R_VDD10_1577 METAL6_1864700_791200 METAL6_1864700_794400 0.0064
R_VDD10_1578 METAL6_1864700_794400 METAL6_1865400_794400 0.0014
R_VDD10_1579 METAL6_1865400_794400 METAL6_1874700_794400 0.0186
R_VDD10_1580 METAL6_1874700_794400 METAL6_1876700_794400 0.004
R_VDD10_1581 METAL6_1876700_794400 METAL6_1877400_794400 0.0014
R_VDD10_1582 METAL6_1877400_794400 METAL6_1888700_794400 0.0226
R_VDD10_1583 METAL6_1888700_794400 METAL6_1895200_794400 0.013
R_VDD10_1584 METAL6_1895200_794400 METAL6_1900700_794400 0.011
R_VDD10_1585 METAL6_1900700_794400 METAL6_1901600_794400 0.0018
R_VDD10_1586 METAL6_1901600_794400 METAL6_1907200_794400 0.0112
R_VDD10_1587 METAL6_1907200_794400 METAL6_1907200_794800 0.0008
R_VDD10_1588 METAL6_1907200_794800 METAL6_1907200_800000 0.0104
R_VDD10_1589 METAL6_1907200_800000 METAL6_1907200_802400 0.0048
R_VDD10_1590 METAL6_1907200_802400 METAL6_1907200_803200 0.0016
R_VDD10_1591 METAL6_1907200_803200 METAL6_1907200_806400 0.0064
R_VDD10_1592 METAL6_1907200_806400 METAL6_1907200_808000 0.0032
R_VDD10_1593 METAL6_1907200_808000 METAL6_1907200_812000 0.008
R_VDD10_1594 METAL6_1907200_812000 METAL6_1907200_814400 0.0048
R_VDD10_1595 METAL6_1907200_814400 METAL6_1907200_818400 0.008
R_VDD10_1596 METAL6_1907200_818400 METAL6_1907200_820000 0.0032
R_VDD10_1597 METAL6_1907200_820000 METAL6_1907200_830400 0.0208
R_VDD10_1598 METAL6_1907200_830400 METAL6_1907200_832000 0.0032
R_VDD10_1599 METAL6_1907200_832000 METAL6_1907200_839500 0.015
R_VDD10_1600 METAL6_1907200_839500 METAL6_1907200_840700 0.0024
R_VDD10_1601 METAL6_1907200_840700 METAL6_1907200_851500 0.0216
R_VDD10_1602 METAL6_1907200_851500 METAL6_1907200_858200 0.0134
R_VDD10_1603 METAL6_1907200_858200 METAL6_1907200_863500 0.0106
R_VDD10_1604 METAL6_1907200_863500 METAL6_1907200_887000 0.047
R_VDD10_1605 METAL6_1907200_887000 METAL6_1907200_888000 0.002
R_VDD10_1606 METAL6_1907200_888000 METAL6_1907200_900000 0.024
R_VDD10_1607 METAL6_1907200_900000 METAL6_1907200_900400 0.0008
R_VDD10_1608 METAL6_1907200_900400 METAL6_1907200_912000 0.0232
R_VDD10_1609 METAL6_1907200_912000 METAL6_1907200_927300 0.0306
R_VDD10_1610 METAL6_1907200_927300 METAL6_1907200_947000 0.0394
R_VDD10_1611 METAL6_1907200_947000 METAL6_1907200_959000 0.024
R_VDD10_1612 METAL6_1907200_959000 METAL6_1907200_971000 0.024
R_VDD10_1613 METAL6_1907200_971000 METAL6_1907200_976000 0.01
R_VDD10_1614 METAL6_1907200_976000 METAL6_1907200_988000 0.024
R_VDD10_1615 METAL6_1907200_988000 METAL6_1907200_995000 0.014
R_VDD10_1616 METAL6_1907200_995000 METAL6_1907200_1000000 0.01
R_VDD10_1617 METAL6_1907200_1000000 METAL6_1907200_1007000 0.014
R_VDD10_1618 METAL6_1907200_1007000 METAL6_1907200_1012000 0.01
R_VDD10_1619 METAL6_1907200_1012000 METAL6_1907200_1014000 0.004
R_VDD10_1620 METAL6_1907200_1014000 METAL6_1907200_1019000 0.01
R_VDD10_1621 METAL6_1907200_1019000 METAL6_1907200_1026000 0.014
R_VDD10_1622 METAL6_1907200_1026000 METAL6_1907200_1029800 0.0076
R_VDD10_1623 METAL6_1907200_1029800 METAL6_1907200_1031000 0.0024
R_VDD10_1624 METAL6_1907200_1031000 METAL6_1907200_1035700 0.0094
R_VDD10_1625 METAL6_1907200_1035700 METAL6_1907200_1037400 0.0034
R_VDD10_1626 METAL6_1907200_1037400 METAL6_1907200_1038000 0.0012
R_VDD10_1627 METAL6_1907200_1038000 METAL6_1907200_1041800 0.0076
R_VDD10_1628 METAL6_1907200_1041800 METAL6_1907200_1042700 0.0018
R_VDD10_1629 METAL6_1907200_1042700 METAL6_1907200_1049400 0.0134
R_VDD10_1630 METAL6_1907200_1049400 METAL6_1907200_1049800 0.0008
R_VDD10_1631 METAL6_1907200_1049800 METAL6_1907200_1053800 0.008
R_VDD10_1632 METAL6_1907200_1053800 METAL6_1907200_1054700 0.0018
R_VDD10_1633 METAL6_1907200_1054700 METAL6_1907200_1061400 0.0134
R_VDD10_1634 METAL6_1907200_1061400 METAL6_1907200_1061800 0.0008
R_VDD10_1635 METAL6_1907200_1061800 METAL6_1907200_1066700 0.0098
R_VDD10_1636 METAL6_1907200_1066700 METAL6_1907200_1073800 0.0142
R_VDD10_1637 METAL6_1907200_1073800 METAL6_1907200_1086000 0.0244
R_VDD10_1638 METAL6_1907200_1086000 METAL6_1907200_1086300 0.0006
R_VDD10_1639 METAL6_1907200_1086300 METAL6_1907200_1088000 0.0034
R_VDD10_1640 METAL6_1907200_1088000 METAL6_1907200_1098300 0.0206
R_VDD10_1641 METAL6_1907200_1098300 METAL6_1907200_1098500 0.0004
R_VDD10_1642 METAL6_1907200_1098500 METAL6_1907200_1100000 0.003
R_VDD10_1643 METAL6_1907200_1100000 METAL6_1907200_1108800 0.0176
R_VDD10_1644 METAL6_1907200_1108800 METAL6_1907200_1110300 0.003
R_VDD10_1645 METAL6_1907200_1110300 METAL6_1907200_1112000 0.0034
R_VDD10_1646 METAL6_1907200_1112000 METAL6_1907200_1122300 0.0206
R_VDD10_1647 METAL6_1907200_1122300 METAL6_1907200_1129300 0.014
R_VDD10_1648 METAL6_1907200_1129300 METAL6_1907200_1134300 0.01
R_VDD10_1649 METAL6_1907200_1134300 METAL6_1907200_1141300 0.014
R_VDD10_1650 METAL6_1907200_1141300 METAL6_1907200_1153300 0.024
R_VDD10_1651 METAL6_1907200_1153300 METAL6_1907200_1160600 0.0146
R_VDD10_1652 METAL6_1907200_1160600 METAL6_1907200_1172600 0.024
R_VDD10_1653 METAL6_1907200_1172600 METAL6_1907200_1184600 0.024
R_VDD10_1654 METAL6_1907200_1184600 METAL6_1907200_1191600 0.014
R_VDD10_1655 METAL6_1907200_1191600 METAL6_1907200_1193800 0.0044
R_VDD10_1656 METAL6_1907200_1193800 METAL6_1907200_1217700 0.0478
R_VDD10_1657 METAL6_1907200_1217700 METAL6_1907200_1238000 0.0406
R_VDD10_1658 METAL6_1907200_1238000 METAL6_1907200_1247700 0.0194
R_VDD10_1659 METAL6_1907200_1247700 METAL6_1907200_1250000 0.0046
R_VDD10_1660 METAL6_1907200_1250000 METAL6_1907200_1259700 0.0194
R_VDD10_1661 METAL6_1907200_1259700 METAL6_1907200_1262000 0.0046
R_VDD10_1662 METAL6_1907200_1262000 METAL6_1907200_1271700 0.0194
R_VDD10_1663 METAL6_1907200_1271700 METAL6_1907200_1273000 0.0026
R_VDD10_1664 METAL6_1907200_1273000 METAL6_1907200_1326000 0.106
R_VDD10_1665 METAL6_1907200_1326000 METAL6_1907200_1338000 0.024
R_VDD10_1666 METAL6_1907200_1338000 METAL6_1907200_1350000 0.024
R_VDD10_1667 METAL6_1907200_1350000 METAL6_1907200_1362000 0.024
R_VDD10_1668 METAL6_1907200_1362000 METAL6_1907200_1369000 0.014
R_VDD10_1669 METAL6_1907200_1369000 METAL6_1907200_1374000 0.01
R_VDD10_1670 METAL6_1907200_1374000 METAL6_1907200_1381000 0.014
R_VDD10_1671 METAL6_1907200_1381000 METAL6_1907200_1386600 0.0112
R_VDD10_1672 METAL6_1907200_1386600 METAL6_1907200_1393000 0.0128
R_VDD10_1673 METAL6_1907200_1393000 METAL6_1907200_1405000 0.024
R_VDD10_1674 METAL6_1907200_1405000 METAL6_1907200_1437700 0.0654
R_VDD10_1675 METAL6_1907200_1437700 METAL6_1907200_1449700 0.024
R_VDD10_1676 METAL6_1907200_1449700 METAL6_1907200_1461700 0.024
R_VDD10_1677 METAL6_1907200_1461700 METAL6_1907200_1492300 0.0612
R_VDD10_1678 METAL6_1907200_1492300 METAL6_1907200_1504300 0.024
R_VDD10_1679 METAL6_1907200_1504300 METAL6_1907400_1504300 0.0004
R_VDD10_1680 METAL6_1907400_1504300 METAL6_1913600_1504300 0.0124
R_VDD10_1681 METAL6_1913600_1504300 METAL6_1919200_1504300 0.0112
R_VDD10_1682 METAL6_1919200_1504300 METAL6_1925600_1504300 0.0128
R_VDD10_1683 METAL6_1925600_1504300 METAL6_1926200_1504300 0.0012
R_VDD10_1684 METAL6_1926200_1504300 METAL6_1927800_1504300 0.0032
R_VDD10_1685 METAL6_1927800_1504300 METAL6_1939800_1504300 0.024
R_VDD10_1686 METAL6_1939800_1504300 METAL6_1951800_1504300 0.024
R_VDD10_1687 METAL6_1951800_1504300 METAL6_1951900_1504300 0.0002
R_VDD10_1688 METAL6_1951900_1504300 METAL6_1988000_1504300 0.0722
R_VDD10_1689 METAL6_1988000_1504300 METAL6_2000000_1504300 0.024
R_VDD10_1690 METAL6_2000000_1504300 METAL6_2002400_1504300 0.0048
R_VDD10_1691 METAL6_2002400_1504300 METAL6_2006900_1504300 0.009
R_VDD10_1692 METAL6_2006900_1504300 METAL6_2012000_1504300 0.0102
R_VDD10_1693 METAL6_2012000_1504300 METAL6_2014400_1504300 0.0048
R_VDD10_1694 METAL6_2014400_1504300 METAL6_2018900_1504300 0.009
R_VDD10_1695 METAL6_2018900_1504300 METAL6_2019700_1504300 0.0016
R_VDD10_1696 METAL6_2019700_1504300 METAL6_2021200_1504300 0.003
R_VDD10_1697 METAL6_2021200_1504300 METAL6_2026400_1504300 0.0104
R_VDD10_1698 METAL6_2026400_1504300 METAL6_2030900_1504300 0.009
R_VDD10_1699 METAL6_2030900_1504300 METAL6_2031700_1504300 0.0016
R_VDD10_1700 METAL6_2031700_1504300 METAL6_2043700_1504300 0.024
R_VDD10_1701 METAL6_2043700_1504300 METAL6_2046400_1504300 0.0054
R_VDD10_1702 METAL6_2046400_1504300 METAL6_2046600_1504300 0.0004
R_VDD10_1703 METAL6_2046600_1504300 METAL6_2046800_1504300 0.0004
R_VDD10_1704 METAL6_2046800_1504300 METAL6_2055700_1504300 0.0178
R_VDD10_1705 METAL6_2055700_1504300 METAL6_2060600_1504300 0.0098
R_VDD10_1706 METAL6_2060600_1504300 METAL6_2067700_1504300 0.0142
R_VDD10_1707 METAL6_2067700_1504300 METAL6_2067700_1516300 0.024
R_VDD10_1708 METAL6_2067700_1516300 METAL6_2077900_1516300 0.0204
R_VDD10_1709 METAL6_2077900_1516300 METAL6_2089900_1516300 0.024
R_VDD10_1710 METAL6_2089900_1516300 METAL6_2101600_1516300 0.0234
R_VDD10_1711 METAL6_2101600_1516300 METAL6_2101900_1516300 0.0006
R_VDD10_1712 METAL6_2101900_1516300 METAL6_2113600_1516300 0.0234
R_VDD10_1713 METAL6_2113600_1516300 METAL6_2121400_1516300 0.0156
R_VDD10_1714 METAL6_2121400_1516300 METAL6_2125600_1516300 0.0084
R_VDD10_1715 METAL6_2125600_1516300 METAL6_2129700_1516300 0.0082
R_VDD10_1716 METAL6_2129700_1516300 METAL6_2141400_1516300 0.0234
R_VDD10_1717 METAL6_2141400_1516300 METAL6_2151900_1516300 0.021
R_VDD10_1718 METAL6_2151900_1516300 METAL6_2153400_1516300 0.003
R_VDD10_1719 METAL6_2153400_1516300 METAL6_2153900_1516300 0.001
R_VDD10_1720 METAL6_2153900_1516300 METAL6_2165400_1516300 0.023
R_VDD10_1721 METAL6_2165400_1516300 METAL6_2165900_1516300 0.001
R_VDD10_1722 METAL6_2165900_1516300 METAL6_2176700_1516300 0.0216
R_VDD10_1723 METAL6_2176700_1516300 METAL6_2177900_1516300 0.0024
R_VDD10_1724 METAL6_2177900_1516300 METAL6_2188700_1516300 0.0216
R_VDD10_1725 METAL6_2188700_1516300 METAL5_2188700_1516300 0.1
R_VDD10_1726 METAL5_2188700_1516300 METAL5_2188700_1528300 0.048
R_VDD10_1727 METAL5_2188700_1528300 METAL5_2188700_1540300 0.048
R_VDD10_1728 METAL5_2188700_1540300 METAL5_2188700_1552300 0.048
R_VDD10_1729 METAL5_2188700_1552300 METAL5_2188700_1554500 0.0088
R_VDD10_1730 METAL5_2188700_1554500 METAL5_2188700_1564300 0.0392
R_VDD10_1731 METAL5_2188700_1564300 METAL5_2200700_1564300 0.048
R_VDD10_1732 METAL5_2200700_1564300 METAL6_2200700_1564300 0.1
R_VDD10_1733 METAL6_2200700_1564300 METAL6_2200700_1571300 0.014
R_VDD10_1734 METAL6_2200700_1571300 METAL6_2200700_1714500 0.2864
R_VDD10_1735 METAL6_2200700_1714500 METAL6_2200700_1720500 0.012
R_VDD10_1736 METAL6_2200700_1720500 METAL6_2200700_1726500 0.012
R_VDD10_1737 METAL6_2200700_1726500 METAL6_2200700_1731700 0.0104
R_VDD10_1738 METAL6_2200700_1731700 METAL6_2200700_1738500 0.0136
R_VDD10_1739 METAL6_2200700_1738500 METAL6_2200700_1750500 0.024
R_VDD10_1740 METAL6_2200700_1750500 METAL6_2200700_1762500 0.024
R_VDD10_1741 METAL6_2200700_1762500 METAL6_2200700_1774500 0.024
R_VDD10_1742 METAL6_2200700_1774500 METAL6_2200700_1802500 0.056
R_VDD10_1743 METAL6_2200700_1802500 METAL6_2200700_1814500 0.024
R_VDD10_1744 METAL6_2200700_1814500 METAL6_2200700_1826500 0.024
R_VDD10_1745 METAL6_2200700_1826500 METAL6_2200700_1838500 0.024
R_VDD10_1746 METAL6_2200700_1838500 METAL6_2200700_1852300 0.0276
R_VDD10_1747 METAL6_2200700_1852300 METAL6_2200700_1866300 0.028
R_VDD10_1748 METAL6_2200700_1866300 METAL6_2200700_1914500 0.0964
R_VDD10_1749 METAL6_2200700_1914500 METAL6_2200700_1926500 0.024
R_VDD10_1750 METAL6_2200700_1926500 METAL6_2200700_1938500 0.024
R_VDD10_1751 METAL6_2200700_1938500 METAL6_2200700_1940500 0.004
R_VDD10_1752 METAL6_2200700_1940500 METAL6_2200700_1950500 0.02
R_VDD10_1753 METAL6_2200700_1950500 METAL6_2200700_1951000 0.001
R_VDD10_1754 METAL6_2200700_1951000 METAL6_2200700_1952500 0.003
R_VDD10_1755 METAL6_2200700_1952500 METAL6_2200700_1963000 0.021
R_VDD10_1756 METAL6_2200700_1963000 METAL6_2200700_1964500 0.003
R_VDD10_1757 METAL6_2200700_1964500 METAL6_2200700_1975000 0.021
R_VDD10_1758 METAL6_2200700_1975000 METAL6_2200700_1976500 0.003
R_VDD10_1759 METAL6_2200700_1976500 METAL6_2200700_1987000 0.021
R_VDD10_1760 METAL6_2200700_1987000 METAL6_2200700_2014500 0.055
R_VDD10_1761 METAL6_2200700_2014500 METAL6_2200700_2026500 0.024
R_VDD10_1762 METAL6_2200700_2026500 METAL6_2200700_2038500 0.024
R_VDD10_1763 METAL6_2200700_2038500 METAL6_2200700_2114500 0.152
R_VDD10_1764 METAL6_2200700_2114500 METAL6_2200700_2126500 0.024
R_VDD10_1765 METAL6_2200700_2126500 METAL6_2200700_2138500 0.024
R_VDD10_1766 METAL6_2200700_2138500 METAL6_2200700_2147300 0.0176
R_VDD10_1767 METAL6_2200700_2147300 METAL6_2200700_2154300 0.014
R_VDD10_1768 METAL6_2200700_2154300 METAL6_2200700_2163000 0.0174
R_VDD10_1769 METAL6_2200700_2163000 METAL6_2200700_2166300 0.0066
R_VDD10_1770 METAL6_2200700_2166300 METAL6_2200700_2175000 0.0174
R_VDD10_1771 METAL6_2200700_2175000 METAL6_2200700_2178300 0.0066
R_VDD10_1772 METAL6_2200700_2178300 METAL6_2188700_2178300 0.024
R_VDD10_1773 METAL6_2188700_2178300 METAL6_2177900_2178300 0.0216
R_VDD10_1774 METAL6_2177900_2178300 METAL5_2177900_2178300 0.1
R_VDD10_1775 METAL5_2177900_2178300 METAL5_2176700_2178300 0.0048
R_VDD10_1776 METAL5_2176700_2178300 METAL5_2165900_2178300 0.0432
R_VDD10_1777 METAL5_2165900_2178300 METAL5_2165400_2178300 0.002
R_VDD10_1778 METAL5_2165400_2178300 METAL5_2153900_2178300 0.046
R_VDD10_1779 METAL5_2153900_2178300 METAL6_2153900_2178300 0.1
R_VDD10_1780 METAL6_2153900_2178300 METAL6_2153900_2187000 0.0174
R_VDD10_1781 METAL6_2153900_2187000 METAL6_2153900_2190300 0.0066
R_VDD10_1782 METAL6_2153900_2190300 METAL6_2153900_2222500 0.0644
R_VDD10_1783 METAL6_2153900_2222500 METAL6_2153900_2234500 0.024
R_VDD10_1784 METAL6_2153900_2234500 METAL6_2153900_2246500 0.024
R_VDD10_1785 METAL6_2153900_2246500 METAL6_2153900_2268500 0.044
R_VDD10_1786 METAL6_2153900_2268500 METAL6_2153900_2288000 0.039
R_VDD10_1787 METAL6_2153900_2288000 METAL6_2153900_2300000 0.024
R_VDD10_1788 METAL6_2153900_2300000 METAL6_2153900_2312000 0.024
R_VDD10_1789 METAL6_2153900_2312000 METAL6_2153900_2338000 0.052
R_VDD10_1790 METAL6_2153900_2338000 METAL6_2153900_2350000 0.024
R_VDD10_1791 METAL6_2153900_2350000 METAL6_2153900_2362000 0.024
R_VDD10_1792 METAL6_2153900_2362000 METAL6_2153900_2376000 0.028
R_VDD10_1793 METAL6_2153900_2376000 METAL6_2153900_2377000 0.002
R_VDD10_1794 METAL6_2153900_2377000 METAL6_2153900_2388000 0.022
R_VDD10_1795 METAL6_2153900_2388000 METAL6_2153900_2389000 0.002
R_VDD10_1796 METAL6_2153900_2389000 METAL6_2153400_2389000 0.001
R_VDD10_1797 METAL6_2153400_2389000 METAL6_2151900_2389000 0.003
R_VDD10_1798 METAL6_2151900_2389000 METAL6_2141400_2389000 0.021
R_VDD10_1799 METAL6_2141400_2389000 METAL6_2129700_2389000 0.0234
R_VDD10_1800 METAL6_2129700_2389000 METAL6_2125600_2389000 0.0082
R_VDD10_1801 METAL6_2125600_2389000 METAL6_2121400_2389000 0.0084
R_VDD10_1802 METAL6_2121400_2389000 METAL6_2113600_2389000 0.0156
R_VDD10_1803 METAL6_2113600_2389000 METAL6_2101900_2389000 0.0234
R_VDD10_1804 METAL6_2101900_2389000 METAL6_2101600_2389000 0.0006
R_VDD10_1805 METAL6_2101600_2389000 METAL6_2089900_2389000 0.0234
R_VDD10_1806 METAL6_2089900_2389000 METAL6_2077900_2389000 0.024
R_VDD10_1807 METAL6_2077900_2389000 METAL6_2067700_2389000 0.0204
R_VDD10_1808 METAL6_2067700_2389000 METAL6_2060600_2389000 0.0142
R_VDD10_1809 METAL6_2060600_2389000 METAL6_2055700_2389000 0.0098
R_VDD10_1810 METAL6_2055700_2389000 METAL6_2046800_2389000 0.0178
R_VDD10_1811 METAL6_2046800_2389000 METAL6_2046600_2389000 0.0004
R_VDD10_1812 METAL6_2046600_2389000 METAL6_2046400_2389000 0.0004
R_VDD10_1813 METAL6_2046400_2389000 METAL6_2043700_2389000 0.0054
R_VDD10_1814 METAL6_2043700_2389000 METAL6_2031700_2389000 0.024
R_VDD10_1815 METAL6_2031700_2389000 METAL6_2030900_2389000 0.0016
R_VDD10_1816 METAL6_2030900_2389000 METAL6_2026400_2389000 0.009
R_VDD10_1817 METAL6_2026400_2389000 METAL6_2021200_2389000 0.0104
R_VDD10_1818 METAL6_2021200_2389000 METAL6_2019700_2389000 0.003
R_VDD10_1819 METAL6_2019700_2389000 METAL6_2018900_2389000 0.0016
R_VDD10_1820 METAL6_2018900_2389000 METAL6_2014400_2389000 0.009
R_VDD10_1821 METAL6_2014400_2389000 METAL6_2012000_2389000 0.0048
R_VDD10_1822 METAL6_2012000_2389000 METAL6_2006900_2389000 0.0102
R_VDD10_1823 METAL6_2006900_2389000 METAL6_2002400_2389000 0.009
R_VDD10_1824 METAL6_2002400_2389000 METAL6_2000000_2389000 0.0048
R_VDD10_1825 METAL6_2000000_2389000 METAL6_1988000_2389000 0.024
R_VDD10_1826 METAL6_1988000_2389000 METAL6_1951900_2389000 0.0722
R_VDD10_1827 METAL6_1951900_2389000 METAL6_1951800_2389000 0.0002
R_VDD10_1828 METAL6_1951800_2389000 METAL6_1939800_2389000 0.024
R_VDD10_1829 METAL6_1939800_2389000 METAL6_1927800_2389000 0.024
R_VDD10_1830 METAL6_1927800_2389000 METAL6_1926200_2389000 0.0032
R_VDD10_1831 METAL6_1926200_2389000 METAL6_1925600_2389000 0.0012
R_VDD10_1832 METAL6_1925600_2389000 METAL6_1919200_2389000 0.0128
R_VDD10_1833 METAL6_1919200_2389000 METAL6_1913600_2389000 0.0112
R_VDD10_1834 METAL6_1913600_2389000 METAL6_1907400_2389000 0.0124
R_VDD10_1835 METAL6_1907400_2389000 METAL6_1907200_2389000 0.0004
R_VDD10_1836 METAL6_1907200_2389000 METAL6_1907200_2400000 0.022
R_VDD10_1837 METAL6_1907200_2400000 METAL6_1907200_2401000 0.002
R_VDD10_1838 METAL6_1907200_2401000 METAL6_1907200_2407000 0.012
R_VDD10_1839 METAL6_1907200_2407000 METAL6_1907200_2412000 0.01
R_VDD10_1840 METAL6_1907200_2412000 METAL6_1907200_2438000 0.052
R_VDD10_1841 METAL6_1907200_2438000 METAL6_1907200_2444000 0.012
R_VDD10_1842 METAL6_1907200_2444000 METAL6_1907200_2450000 0.012
R_VDD10_1843 METAL6_1907200_2450000 METAL6_1907200_2456000 0.012
I_VDD10_3 METAL6_940400_1826500 gnd 0.0016
I_VDD10_4 METAL6_1853400_2536000 gnd 0.003
I_VDD10_5 METAL6_1919200_2456000 gnd 0.003

V_VDD11_3 METAL6_3100000_0 gnd 1
R_VDD11_1844 METAL6_3100000_0 METAL6_3100000_9500 0.019
R_VDD11_1845 METAL6_3100000_9500 METAL6_3099200_9500 0.0016
R_VDD11_1846 METAL6_3099200_9500 METAL6_3098900_9500 0.0006
R_VDD11_1847 METAL6_3098900_9500 METAL6_3088000_9500 0.0218
R_VDD11_1848 METAL6_3088000_9500 METAL6_3088000_16000 0.013
R_VDD11_1849 METAL6_3088000_16000 METAL6_3087200_16000 0.0016
R_VDD11_1850 METAL6_3087200_16000 METAL6_3087200_16600 0.0012
R_VDD11_1851 METAL6_3087200_16600 METAL6_3087200_21500 0.0098
R_VDD11_1852 METAL6_3087200_21500 METAL6_3087200_28000 0.013
R_VDD11_1853 METAL6_3087200_28000 METAL6_3087200_28600 0.0012
R_VDD11_1854 METAL6_3087200_28600 METAL6_3086900_28600 0.0006
R_VDD11_1855 METAL6_3086900_28600 METAL6_3076000_28600 0.0218
R_VDD11_1856 METAL6_3076000_28600 METAL6_3075200_28600 0.0016
R_VDD11_1857 METAL6_3075200_28600 METAL5_3075200_28600 0.1
R_VDD11_1858 METAL5_3075200_28600 METAL5_3075200_33500 0.0196
R_VDD11_1859 METAL5_3075200_33500 METAL5_3075200_40000 0.026
R_VDD11_1860 METAL5_3075200_40000 METAL5_3075200_40600 0.0024
R_VDD11_1861 METAL5_3075200_40600 METAL5_3075200_52000 0.0456
R_VDD11_1862 METAL5_3075200_52000 METAL5_3075200_52600 0.0024
R_VDD11_1863 METAL5_3075200_52600 METAL5_3075200_64000 0.0456
R_VDD11_1864 METAL5_3075200_64000 METAL5_3075200_64600 0.0024
R_VDD11_1865 METAL5_3075200_64600 METAL5_3075200_71600 0.028
R_VDD11_1866 METAL5_3075200_71600 METAL5_3075200_76000 0.0176
R_VDD11_1867 METAL5_3075200_76000 METAL5_3075200_76600 0.0024
R_VDD11_1868 METAL5_3075200_76600 METAL6_3075200_76600 0.1
R_VDD11_1869 METAL6_3075200_76600 METAL6_3075200_83600 0.014
R_VDD11_1870 METAL6_3075200_83600 METAL6_3075200_88000 0.0088
R_VDD11_1871 METAL6_3075200_88000 METAL6_3072600_88000 0.0052
R_VDD11_1872 METAL6_3072600_88000 METAL6_3072600_88600 0.0012
R_VDD11_1873 METAL6_3072600_88600 METAL6_3072600_95600 0.014
R_VDD11_1874 METAL6_3072600_95600 METAL6_3072600_100000 0.0088
R_VDD11_1875 METAL6_3072600_100000 METAL6_3072600_100600 0.0012
R_VDD11_1876 METAL6_3072600_100600 METAL6_3072600_112000 0.0228
R_VDD11_1877 METAL6_3072600_112000 METAL6_3072600_147600 0.0712
R_VDD11_1878 METAL6_3072600_147600 METAL6_3072600_159600 0.024
R_VDD11_1879 METAL6_3072600_159600 METAL6_3072600_164000 0.0088
R_VDD11_1880 METAL6_3072600_164000 METAL6_3072600_166600 0.0052
R_VDD11_1881 METAL6_3072600_166600 METAL6_3072600_171600 0.01
R_VDD11_1882 METAL6_3072600_171600 METAL6_3072600_176000 0.0088
R_VDD11_1883 METAL6_3072600_176000 METAL6_3072600_178600 0.0052
R_VDD11_1884 METAL6_3072600_178600 METAL5_3072600_178600 0.1
R_VDD11_1885 METAL5_3072600_178600 METAL5_3072600_188000 0.0376
R_VDD11_1886 METAL5_3072600_188000 METAL5_3072600_190600 0.0104
R_VDD11_1887 METAL5_3072600_190600 METAL5_3072600_200000 0.0376
R_VDD11_1888 METAL5_3072600_200000 METAL5_3072600_202600 0.0104
R_VDD11_1889 METAL5_3072600_202600 METAL5_3072600_212000 0.0376
R_VDD11_1890 METAL5_3072600_212000 METAL5_3072600_214600 0.0104
R_VDD11_1891 METAL5_3072600_214600 METAL5_3072600_224300 0.0388
R_VDD11_1892 METAL5_3072600_224300 METAL5_3072600_226600 0.0092
R_VDD11_1893 METAL5_3072600_226600 METAL5_3068200_226600 0.0176
R_VDD11_1894 METAL5_3068200_226600 METAL5_3064000_226600 0.0168
R_VDD11_1895 METAL5_3064000_226600 METAL5_3063200_226600 0.0032
R_VDD11_1896 METAL5_3063200_226600 METAL5_3060600_226600 0.0104
R_VDD11_1897 METAL5_3060600_226600 METAL5_3052000_226600 0.0344
R_VDD11_1898 METAL5_3052000_226600 METAL5_3048600_226600 0.0136
R_VDD11_1899 METAL5_3048600_226600 METAL5_3048600_224300 0.0092
R_VDD11_1900 METAL5_3048600_224300 METAL6_3048600_224300 0.1
R_VDD11_1901 METAL6_3048600_224300 METAL6_3036000_224300 0.0252
R_VDD11_1902 METAL6_3036000_224300 METAL6_3036000_214600 0.0194
R_VDD11_1903 METAL6_3036000_214600 METAL6_3035200_214600 0.0016
R_VDD11_1904 METAL6_3035200_214600 METAL6_3024000_214600 0.0224
R_VDD11_1905 METAL6_3024000_214600 METAL6_3023200_214600 0.0016
R_VDD11_1906 METAL6_3023200_214600 METAL6_3018200_214600 0.01
R_VDD11_1907 METAL6_3018200_214600 METAL6_3012000_214600 0.0124
R_VDD11_1908 METAL6_3012000_214600 METAL6_3011200_214600 0.0016
R_VDD11_1909 METAL6_3011200_214600 METAL6_3006200_214600 0.01
R_VDD11_1910 METAL6_3006200_214600 METAL6_3000000_214600 0.0124
R_VDD11_1911 METAL6_3000000_214600 METAL6_2994200_214600 0.0116
R_VDD11_1912 METAL6_2994200_214600 METAL6_2993000_214600 0.0024
R_VDD11_1913 METAL6_2993000_214600 METAL6_2988000_214600 0.01
R_VDD11_1914 METAL6_2988000_214600 METAL6_2987200_214600 0.0016
R_VDD11_1915 METAL6_2987200_214600 METAL6_2982200_214600 0.01
R_VDD11_1916 METAL6_2982200_214600 METAL6_2976000_214600 0.0124
R_VDD11_1917 METAL6_2976000_214600 METAL6_2975200_214600 0.0016
R_VDD11_1918 METAL6_2975200_214600 METAL6_2970200_214600 0.01
R_VDD11_1919 METAL6_2970200_214600 METAL6_2965900_214600 0.0086
R_VDD11_1920 METAL6_2965900_214600 METAL6_2963200_214600 0.0054
R_VDD11_1921 METAL6_2963200_214600 METAL6_2958200_214600 0.01
R_VDD11_1922 METAL6_2958200_214600 METAL6_2951900_214600 0.0126
R_VDD11_1923 METAL6_2951900_214600 METAL6_2942200_214600 0.0194
R_VDD11_1924 METAL6_2942200_214600 METAL6_2930200_214600 0.024
R_VDD11_1925 METAL6_2930200_214600 METAL6_2925600_214600 0.0092
R_VDD11_1926 METAL6_2925600_214600 METAL6_2918200_214600 0.0148
R_VDD11_1927 METAL6_2918200_214600 METAL6_2913600_214600 0.0092
R_VDD11_1928 METAL6_2913600_214600 METAL6_2910900_214600 0.0054
R_VDD11_1929 METAL6_2910900_214600 METAL6_2901600_214600 0.0186
R_VDD11_1930 METAL6_2901600_214600 METAL5_2901600_214600 0.1
R_VDD11_1931 METAL5_2901600_214600 METAL5_2901600_212000 0.0104
R_VDD11_1932 METAL5_2901600_212000 METAL5_2901600_202600 0.0376
R_VDD11_1933 METAL5_2901600_202600 METAL5_2901600_200000 0.0104
R_VDD11_1934 METAL5_2901600_200000 METAL5_2901600_190600 0.0376
R_VDD11_1935 METAL5_2901600_190600 METAL5_2901600_188000 0.0104
R_VDD11_1936 METAL5_2901600_188000 METAL5_2901600_178600 0.0376
R_VDD11_1937 METAL5_2901600_178600 METAL6_2901600_178600 0.1
R_VDD11_1938 METAL6_2901600_178600 METAL6_2898900_178600 0.0054
R_VDD11_1939 METAL6_2898900_178600 METAL6_2897100_178600 0.0036
R_VDD11_1940 METAL6_2897100_178600 METAL6_2886900_178600 0.0204
R_VDD11_1941 METAL6_2886900_178600 METAL6_2886800_178600 0.0002
R_VDD11_1942 METAL6_2886800_178600 METAL6_2874900_178600 0.0238
R_VDD11_1943 METAL6_2874900_178600 METAL6_2874800_178600 0.0002
R_VDD11_1944 METAL6_2874800_178600 METAL6_2862800_178600 0.024
R_VDD11_1945 METAL6_2862800_178600 METAL6_2860600_178600 0.0044
R_VDD11_1946 METAL6_2860600_178600 METAL6_2850800_178600 0.0196
R_VDD11_1947 METAL6_2850800_178600 METAL6_2846600_178600 0.0084
R_VDD11_1948 METAL6_2846600_178600 METAL6_2843800_178600 0.0056
R_VDD11_1949 METAL6_2843800_178600 METAL6_2824000_178600 0.0396
R_VDD11_1950 METAL6_2824000_178600 METAL6_2817600_178600 0.0128
R_VDD11_1951 METAL6_2817600_178600 METAL6_2812000_178600 0.0112
R_VDD11_1952 METAL6_2812000_178600 METAL6_2810800_178600 0.0024
R_VDD11_1953 METAL6_2810800_178600 METAL6_2805600_178600 0.0104
R_VDD11_1954 METAL6_2805600_178600 METAL6_2800000_178600 0.0112
R_VDD11_1955 METAL6_2800000_178600 METAL6_2798800_178600 0.0024
R_VDD11_1956 METAL6_2798800_178600 METAL6_2793600_178600 0.0104
R_VDD11_1957 METAL6_2793600_178600 METAL6_2788000_178600 0.0112
R_VDD11_1958 METAL6_2788000_178600 METAL6_2786800_178600 0.0024
R_VDD11_1959 METAL6_2786800_178600 METAL6_2781600_178600 0.0104
R_VDD11_1960 METAL6_2781600_178600 METAL6_2769600_178600 0.024
R_VDD11_1961 METAL6_2769600_178600 METAL6_2765900_178600 0.0074
R_VDD11_1962 METAL6_2765900_178600 METAL6_2751900_178600 0.028
R_VDD11_1963 METAL6_2751900_178600 METAL6_2728200_178600 0.0474
R_VDD11_1964 METAL6_2728200_178600 METAL6_2710900_178600 0.0346
R_VDD11_1965 METAL6_2710900_178600 METAL6_2698900_178600 0.024
R_VDD11_1966 METAL6_2698900_178600 METAL6_2686900_178600 0.024
R_VDD11_1967 METAL6_2686900_178600 METAL6_2683200_178600 0.0074
R_VDD11_1968 METAL6_2683200_178600 METAL6_2676200_178600 0.014
R_VDD11_1969 METAL6_2676200_178600 METAL6_2664200_178600 0.024
R_VDD11_1970 METAL6_2664200_178600 METAL6_2660600_178600 0.0072
R_VDD11_1971 METAL6_2660600_178600 METAL6_2652200_178600 0.0168
R_VDD11_1972 METAL6_2652200_178600 METAL6_2646600_178600 0.0112
R_VDD11_1973 METAL6_2646600_178600 METAL6_2640200_178600 0.0128
R_VDD11_1974 METAL6_2640200_178600 METAL6_2604400_178600 0.0716
R_VDD11_1975 METAL6_2604400_178600 METAL6_2592400_178600 0.024
R_VDD11_1976 METAL6_2592400_178600 METAL6_2580400_178600 0.024
R_VDD11_1977 METAL6_2580400_178600 METAL6_2568400_178600 0.024
R_VDD11_1978 METAL6_2568400_178600 METAL6_2565900_178600 0.005
R_VDD11_1979 METAL6_2565900_178600 METAL6_2556400_178600 0.019
R_VDD11_1980 METAL6_2556400_178600 METAL6_2551900_178600 0.009
R_VDD11_1981 METAL6_2551900_178600 METAL6_2549600_178600 0.0046
R_VDD11_1982 METAL6_2549600_178600 METAL6_2548000_178600 0.0032
R_VDD11_1983 METAL6_2548000_178600 METAL6_2537600_178600 0.0208
R_VDD11_1984 METAL6_2537600_178600 METAL6_2536000_178600 0.0032
R_VDD11_1985 METAL6_2536000_178600 METAL6_2535400_178600 0.0012
R_VDD11_1986 METAL6_2535400_178600 METAL6_2529000_178600 0.0128
R_VDD11_1987 METAL6_2529000_178600 METAL6_2528400_178600 0.0012
R_VDD11_1988 METAL6_2528400_178600 METAL6_2525600_178600 0.0056
R_VDD11_1989 METAL6_2525600_178600 METAL6_2524000_178600 0.0032
R_VDD11_1990 METAL6_2524000_178600 METAL6_2517000_178600 0.014
R_VDD11_1991 METAL6_2517000_178600 METAL6_2516400_178600 0.0012
R_VDD11_1992 METAL6_2516400_178600 METAL6_2513600_178600 0.0056
R_VDD11_1993 METAL6_2513600_166600 METAL6_2513600_178600 0.024
R_VDD11_1994 METAL6_2698900_272300 METAL6_2698900_260300 0.024
R_VDD11_1995 METAL6_2698900_178600 METAL5_2698900_178600 0.1
R_VDD11_1996 METAL5_2698900_178600 METAL5_2698900_188000 0.0376
R_VDD11_1997 METAL5_2698900_188000 METAL5_2698900_190600 0.0104
R_VDD11_1998 METAL5_2698900_190600 METAL5_2698900_200000 0.0376
R_VDD11_1999 METAL5_2698900_200000 METAL5_2698900_202600 0.0104
R_VDD11_2000 METAL5_2698900_202600 METAL5_2698900_212000 0.0376
R_VDD11_2001 METAL5_2698900_212000 METAL5_2698900_212300 0.0012
R_VDD11_2002 METAL5_2698900_212300 METAL5_2698900_214600 0.0092
R_VDD11_2003 METAL5_2698900_214600 METAL5_2698900_224300 0.0388
R_VDD11_2004 METAL5_2698900_224300 METAL5_2698900_226600 0.0092
R_VDD11_2005 METAL5_2698900_226600 METAL5_2698900_236300 0.0388
R_VDD11_2006 METAL5_2698900_236300 METAL5_2698900_238600 0.0092
R_VDD11_2007 METAL5_2698900_238600 METAL5_2698900_248300 0.0388
R_VDD11_2008 METAL5_2698900_248300 METAL5_2698900_251000 0.0108
R_VDD11_2009 METAL5_2698900_251000 METAL5_2698900_260300 0.0372
R_VDD11_2010 METAL5_2698900_260300 METAL6_2698900_260300 0.1
R_VDD11_2011 METAL6_2898900_272300 METAL6_2898900_260300 0.024
R_VDD11_2012 METAL5_2901600_188000 METAL5_2898900_188000 0.0108
R_VDD11_2013 METAL5_2898900_188000 METAL5_2897100_188000 0.0072
R_VDD11_2014 METAL5_2897100_188000 METAL5_2889600_188000 0.03
R_VDD11_2015 METAL5_2889600_188000 METAL5_2886900_188000 0.0108
R_VDD11_2016 METAL5_2886900_188000 METAL5_2886900_190600 0.0104
R_VDD11_2017 METAL5_2886900_190600 METAL5_2886900_200000 0.0376
R_VDD11_2018 METAL5_2886900_200000 METAL5_2886900_202600 0.0104
R_VDD11_2019 METAL5_2886900_202600 METAL5_2886900_212000 0.0376
R_VDD11_2020 METAL5_2886900_212000 METAL5_2886900_212300 0.0012
R_VDD11_2021 METAL5_2886900_212300 METAL5_2886900_214600 0.0092
R_VDD11_2022 METAL5_2886900_214600 METAL5_2886900_224300 0.0388
R_VDD11_2023 METAL5_2886900_224300 METAL5_2886900_226600 0.0092
R_VDD11_2024 METAL5_2886900_226600 METAL5_2886900_236300 0.0388
R_VDD11_2025 METAL5_2886900_236300 METAL5_2886900_238600 0.0092
R_VDD11_2026 METAL5_2886900_238600 METAL5_2886900_248300 0.0388
R_VDD11_2027 METAL5_2886900_248300 METAL5_2886900_251000 0.0108
R_VDD11_2028 METAL5_2886900_251000 METAL5_2886900_260300 0.0372
R_VDD11_2029 METAL5_2886900_260300 METAL6_2886900_260300 0.1
R_VDD11_2030 METAL6_2886900_260300 METAL6_2889600_260300 0.0054
R_VDD11_2031 METAL6_2889600_260300 METAL6_2897100_260300 0.015
R_VDD11_2032 METAL6_2897100_260300 METAL6_2898900_260300 0.0036
R_VDD11_2033 METAL6_2913600_166600 METAL6_2913600_178600 0.024
R_VDD11_2034 METAL5_2886900_226600 METAL5_2889600_226600 0.0108
R_VDD11_2035 METAL5_2889600_226600 METAL5_2897100_226600 0.03
R_VDD11_2036 METAL5_2897100_226600 METAL5_2898900_226600 0.0072
R_VDD11_2037 METAL5_2898900_226600 METAL5_2901600_226600 0.0108
R_VDD11_2038 METAL5_2901600_226600 METAL5_2910900_226600 0.0372
R_VDD11_2039 METAL5_2910900_226600 METAL5_2913600_226600 0.0108
R_VDD11_2040 METAL5_2913600_226600 METAL5_2913600_224300 0.0092
R_VDD11_2041 METAL5_2913600_224300 METAL5_2913600_214600 0.0388
R_VDD11_2042 METAL5_2913600_214600 METAL5_2913600_212300 0.0092
R_VDD11_2043 METAL5_2913600_212300 METAL5_2913600_212000 0.0012
R_VDD11_2044 METAL5_2913600_212000 METAL5_2913600_202600 0.0376
R_VDD11_2045 METAL5_2913600_202600 METAL5_2913600_200000 0.0104
R_VDD11_2046 METAL5_2913600_200000 METAL5_2913600_190600 0.0376
R_VDD11_2047 METAL5_2913600_190600 METAL5_2913600_188000 0.0104
R_VDD11_2048 METAL5_2913600_188000 METAL5_2913600_178600 0.0376
R_VDD11_2049 METAL5_2913600_178600 METAL6_2913600_178600 0.1
I_VDD11_6 METAL6_2513600_166600 gnd 0.003
I_VDD11_7 METAL6_2698900_272300 gnd 0.003
I_VDD11_8 METAL6_2898900_272300 gnd 0.003
I_VDD11_9 METAL6_2913600_166600 gnd 0.003

V_VDD12_4 METAL6_3200000_0 gnd 1
R_VDD12_2050 METAL6_3200000_0 METAL6_3200000_9500 0.019
R_VDD12_2051 METAL6_3200000_9500 METAL6_3188000_9500 0.024
R_VDD12_2052 METAL6_3188000_9500 METAL6_3179500_9500 0.017
R_VDD12_2053 METAL6_3179500_9500 METAL6_3167500_9500 0.024
R_VDD12_2054 METAL6_3167500_9500 METAL6_3167500_16600 0.0142
R_VDD12_2055 METAL6_3167500_16600 METAL6_3167500_21500 0.0098
R_VDD12_2056 METAL6_3167500_21500 METAL6_3167500_28000 0.013
R_VDD12_2057 METAL6_3167500_28000 METAL6_3165900_28000 0.0032
R_VDD12_2058 METAL6_3165900_28000 METAL6_3155500_28000 0.0208
R_VDD12_2059 METAL6_3155500_28000 METAL6_3124000_28000 0.063
R_VDD12_2060 METAL6_3124000_28000 METAL6_3112000_28000 0.024
R_VDD12_2061 METAL6_3112000_28000 METAL6_3111200_28000 0.0016
R_VDD12_2062 METAL6_3111200_28000 METAL6_3111200_28600 0.0012
R_VDD12_2063 METAL6_3111200_28600 METAL6_3111200_33500 0.0098
R_VDD12_2064 METAL6_3111200_33500 METAL6_3111200_40000 0.013
R_VDD12_2065 METAL6_3111200_40000 METAL6_3111200_40600 0.0012
R_VDD12_2066 METAL6_3111200_40600 METAL6_3111200_52000 0.0228
R_VDD12_2067 METAL6_3111200_52000 METAL6_3111200_52600 0.0012
R_VDD12_2068 METAL6_3111200_52600 METAL6_3111200_64000 0.0228
R_VDD12_2069 METAL6_3111200_64000 METAL6_3111200_64600 0.0012
R_VDD12_2070 METAL6_3111200_64600 METAL6_3111200_71600 0.014
R_VDD12_2071 METAL6_3111200_71600 METAL6_3111200_76000 0.0088
R_VDD12_2072 METAL6_3111200_76000 METAL6_3111200_76600 0.0012
R_VDD12_2073 METAL6_3111200_76600 METAL6_3111200_83600 0.014
R_VDD12_2074 METAL6_3111200_83600 METAL6_3111200_88000 0.0088
R_VDD12_2075 METAL6_3111200_88000 METAL6_3111200_88600 0.0012
R_VDD12_2076 METAL6_3111200_88600 METAL6_3111200_95600 0.014
R_VDD12_2077 METAL6_3111200_95600 METAL6_3111200_100000 0.0088
R_VDD12_2078 METAL6_3111200_100000 METAL6_3111200_100600 0.0012
R_VDD12_2079 METAL6_3111200_100600 METAL6_3111200_112000 0.0228
R_VDD12_2080 METAL6_3111200_112000 METAL6_3111200_147600 0.0712
R_VDD12_2081 METAL6_3111200_147600 METAL6_3111200_159600 0.024
R_VDD12_2082 METAL6_3111200_159600 METAL6_3111200_164000 0.0088
R_VDD12_2083 METAL6_3111200_164000 METAL6_3111200_166600 0.0052
R_VDD12_2084 METAL6_3111200_166600 METAL6_3111200_171600 0.01
R_VDD12_2085 METAL6_3111200_171600 METAL6_3111200_176000 0.0088
R_VDD12_2086 METAL6_3111200_176000 METAL6_3111200_178600 0.0052
R_VDD12_2087 METAL6_3111200_178600 METAL5_3111200_178600 0.1
R_VDD12_2088 METAL5_3111200_178600 METAL5_3111200_188000 0.0376
R_VDD12_2089 METAL5_3111200_188000 METAL5_3111200_190600 0.0104
R_VDD12_2090 METAL5_3111200_190600 METAL5_3111200_200000 0.0376
R_VDD12_2091 METAL5_3111200_200000 METAL5_3111200_202600 0.0104
R_VDD12_2092 METAL5_3111200_202600 METAL6_3111200_202600 0.1
R_VDD12_2093 METAL6_3111200_202600 METAL6_3110900_202600 0.0006
R_VDD12_2094 METAL6_3110900_202600 METAL6_3100000_202600 0.0218
R_VDD12_2095 METAL6_3100000_202600 METAL6_3099200_202600 0.0016
R_VDD12_2096 METAL6_3099200_202600 METAL6_3098900_202600 0.0006
R_VDD12_2097 METAL6_3098900_202600 METAL6_3088000_202600 0.0218
R_VDD12_2098 METAL6_3088000_202600 METAL6_3087200_202600 0.0016
R_VDD12_2099 METAL6_3087200_202600 METAL6_3086900_202600 0.0006
R_VDD12_2100 METAL6_3086900_202600 METAL6_3076000_202600 0.0218
R_VDD12_2101 METAL6_3076000_202600 METAL6_3075200_202600 0.0016
R_VDD12_2102 METAL6_3075200_202600 METAL6_3068200_202600 0.014
R_VDD12_2103 METAL6_3068200_202600 METAL6_3064000_202600 0.0084
R_VDD12_2104 METAL6_3064000_202600 METAL6_3063200_202600 0.0016
R_VDD12_2105 METAL6_3063200_202600 METAL6_3060600_202600 0.0052
R_VDD12_2106 METAL6_3060600_202600 METAL6_3052000_202600 0.0172
R_VDD12_2107 METAL6_3052000_202600 METAL6_3035200_202600 0.0336
R_VDD12_2108 METAL6_3035200_202600 METAL6_3024000_202600 0.0224
R_VDD12_2109 METAL6_3024000_202600 METAL6_3023200_202600 0.0016
R_VDD12_2110 METAL6_3023200_202600 METAL6_3018200_202600 0.01
R_VDD12_2111 METAL6_3018200_202600 METAL6_3012000_202600 0.0124
R_VDD12_2112 METAL6_3012000_202600 METAL6_3011200_202600 0.0016
R_VDD12_2113 METAL6_3011200_202600 METAL6_3006200_202600 0.01
R_VDD12_2114 METAL6_3006200_202600 METAL6_3000000_202600 0.0124
R_VDD12_2115 METAL6_3000000_202600 METAL6_2994200_202600 0.0116
R_VDD12_2116 METAL6_2994200_202600 METAL6_2993000_202600 0.0024
R_VDD12_2117 METAL6_2993000_202600 METAL6_2988000_202600 0.01
R_VDD12_2118 METAL6_2988000_202600 METAL6_2987200_202600 0.0016
R_VDD12_2119 METAL6_2987200_202600 METAL6_2982200_202600 0.01
R_VDD12_2120 METAL6_2982200_202600 METAL6_2975200_202600 0.014
R_VDD12_2121 METAL6_2975200_202600 METAL6_2970200_202600 0.01
R_VDD12_2122 METAL6_2970200_202600 METAL6_2965900_202600 0.0086
R_VDD12_2123 METAL6_2965900_202600 METAL6_2963200_202600 0.0054
R_VDD12_2124 METAL6_2963200_202600 METAL6_2958200_202600 0.01
R_VDD12_2125 METAL6_2958200_202600 METAL6_2951900_202600 0.0126
R_VDD12_2126 METAL6_2951900_202600 METAL6_2942200_202600 0.0194
R_VDD12_2127 METAL6_2942200_202600 METAL6_2930200_202600 0.024
R_VDD12_2128 METAL6_2930200_202600 METAL6_2925600_202600 0.0092
R_VDD12_2129 METAL6_2925600_202600 METAL6_2918200_202600 0.0148
R_VDD12_2130 METAL6_2918200_202600 METAL6_2913600_202600 0.0092
R_VDD12_2131 METAL6_2913600_202600 METAL6_2910900_202600 0.0054
R_VDD12_2132 METAL6_2910900_202600 METAL6_2901600_202600 0.0186
R_VDD12_2133 METAL6_2901600_202600 METAL6_2898900_202600 0.0054
R_VDD12_2134 METAL6_2898900_202600 METAL6_2897100_202600 0.0036
R_VDD12_2135 METAL6_2897100_202600 METAL6_2886900_202600 0.0204
R_VDD12_2136 METAL6_2886900_202600 METAL6_2874900_202600 0.024
R_VDD12_2137 METAL6_2874900_202600 METAL6_2874800_202600 0.0002
R_VDD12_2138 METAL6_2874800_202600 METAL6_2862800_202600 0.024
R_VDD12_2139 METAL6_2862800_202600 METAL6_2860600_202600 0.0044
R_VDD12_2140 METAL6_2860600_202600 METAL6_2850800_202600 0.0196
R_VDD12_2141 METAL6_2850800_202600 METAL6_2846600_202600 0.0084
R_VDD12_2142 METAL6_2846600_202600 METAL6_2843800_202600 0.0056
R_VDD12_2143 METAL6_2843800_202600 METAL6_2824000_202600 0.0396
R_VDD12_2144 METAL6_2824000_202600 METAL6_2817600_202600 0.0128
R_VDD12_2145 METAL6_2817600_202600 METAL6_2812000_202600 0.0112
R_VDD12_2146 METAL6_2812000_202600 METAL6_2810800_202600 0.0024
R_VDD12_2147 METAL6_2810800_202600 METAL6_2805600_202600 0.0104
R_VDD12_2148 METAL6_2805600_202600 METAL6_2800000_202600 0.0112
R_VDD12_2149 METAL6_2800000_202600 METAL6_2798800_202600 0.0024
R_VDD12_2150 METAL6_2798800_202600 METAL6_2793600_202600 0.0104
R_VDD12_2151 METAL6_2793600_202600 METAL6_2788000_202600 0.0112
R_VDD12_2152 METAL6_2788000_202600 METAL6_2786800_202600 0.0024
R_VDD12_2153 METAL6_2786800_202600 METAL6_2781600_202600 0.0104
R_VDD12_2154 METAL6_2781600_202600 METAL6_2769600_202600 0.024
R_VDD12_2155 METAL6_2769600_202600 METAL6_2765900_202600 0.0074
R_VDD12_2156 METAL6_2765900_202600 METAL6_2751900_202600 0.028
R_VDD12_2157 METAL6_2751900_202600 METAL6_2728200_202600 0.0474
R_VDD12_2158 METAL6_2728200_202600 METAL6_2710900_202600 0.0346
R_VDD12_2159 METAL6_2710900_202600 METAL6_2698900_202600 0.024
R_VDD12_2160 METAL6_2698900_202600 METAL6_2686900_202600 0.024
R_VDD12_2161 METAL6_2686900_202600 METAL6_2683200_202600 0.0074
R_VDD12_2162 METAL6_2683200_202600 METAL6_2676200_202600 0.014
R_VDD12_2163 METAL6_2676200_202600 METAL6_2664200_202600 0.024
R_VDD12_2164 METAL6_2664200_202600 METAL6_2660600_202600 0.0072
R_VDD12_2165 METAL6_2660600_202600 METAL6_2652200_202600 0.0168
R_VDD12_2166 METAL6_2652200_202600 METAL6_2646600_202600 0.0112
R_VDD12_2167 METAL6_2646600_202600 METAL6_2604400_202600 0.0844
R_VDD12_2168 METAL6_2604400_202600 METAL6_2592400_202600 0.024
R_VDD12_2169 METAL6_2592400_202600 METAL6_2580400_202600 0.024
R_VDD12_2170 METAL6_2580400_202600 METAL6_2568400_202600 0.024
R_VDD12_2171 METAL6_2568400_202600 METAL6_2565900_202600 0.005
R_VDD12_2172 METAL6_2565900_202600 METAL6_2556400_202600 0.019
R_VDD12_2173 METAL6_2556400_202600 METAL6_2551900_202600 0.009
R_VDD12_2174 METAL6_2551900_202600 METAL6_2548000_202600 0.0078
R_VDD12_2175 METAL6_2548000_202600 METAL6_2537600_202600 0.0208
R_VDD12_2176 METAL6_2537600_202600 METAL6_2536000_202600 0.0032
R_VDD12_2177 METAL6_2536000_202600 METAL6_2535400_202600 0.0012
R_VDD12_2178 METAL6_2535400_202600 METAL6_2529000_202600 0.0128
R_VDD12_2179 METAL6_2529000_202600 METAL6_2528400_202600 0.0012
R_VDD12_2180 METAL6_2528400_202600 METAL6_2525600_202600 0.0056
R_VDD12_2181 METAL6_2525600_202600 METAL6_2524000_202600 0.0032
R_VDD12_2182 METAL6_2524000_202600 METAL6_2517000_202600 0.014
R_VDD12_2183 METAL6_2517000_202600 METAL6_2516400_202600 0.0012
R_VDD12_2184 METAL6_2516400_202600 METAL6_2513600_202600 0.0056
R_VDD12_2185 METAL6_2513600_202600 METAL6_2512000_202600 0.0032
R_VDD12_2186 METAL6_2512000_202600 METAL6_2510900_202600 0.0022
R_VDD12_2187 METAL6_2510900_202600 METAL6_2505000_202600 0.0118
R_VDD12_2188 METAL6_2505000_202600 METAL6_2504400_202600 0.0012
R_VDD12_2189 METAL6_2504400_202600 METAL6_2501600_202600 0.0056
R_VDD12_2190 METAL6_2501600_202600 METAL5_2501600_202600 0.1
R_VDD12_2191 METAL5_2501600_202600 METAL5_2501600_200000 0.0104
R_VDD12_2192 METAL5_2501600_200000 METAL5_2501600_190600 0.0376
R_VDD12_2193 METAL5_2501600_190600 METAL5_2501600_188000 0.0104
R_VDD12_2194 METAL5_2501600_188000 METAL5_2501600_178600 0.0376
R_VDD12_2195 METAL5_2501600_178600 METAL6_2501600_178600 0.1
R_VDD12_2196 METAL6_2501600_178600 METAL6_2500000_178600 0.0032
R_VDD12_2197 METAL6_2500000_178600 METAL6_2498900_178600 0.0022
R_VDD12_2198 METAL6_2498900_178600 METAL6_2496600_178600 0.0046
R_VDD12_2199 METAL6_2496600_178600 METAL6_2493000_178600 0.0072
R_VDD12_2200 METAL6_2493000_178600 METAL6_2492400_178600 0.0012
R_VDD12_2201 METAL6_2492400_178600 METAL6_2489600_178600 0.0056
R_VDD12_2202 METAL6_2489600_178600 METAL6_2488000_178600 0.0032
R_VDD12_2203 METAL6_2488000_178600 METAL6_2486900_178600 0.0022
R_VDD12_2204 METAL6_2486900_178600 METAL6_2484600_178600 0.0046
R_VDD12_2205 METAL6_2484600_178600 METAL6_2482600_178600 0.004
R_VDD12_2206 METAL6_2482600_178600 METAL6_2481000_178600 0.0032
R_VDD12_2207 METAL6_2481000_178600 METAL6_2480400_178600 0.0012
R_VDD12_2208 METAL6_2480400_178600 METAL6_2477600_178600 0.0056
R_VDD12_2209 METAL6_2477600_178600 METAL6_2476000_178600 0.0032
R_VDD12_2210 METAL6_2476000_178600 METAL6_2472600_178600 0.0068
R_VDD12_2211 METAL6_2472600_178600 METAL6_2470600_178600 0.004
R_VDD12_2212 METAL6_2470600_178600 METAL6_2469000_178600 0.0032
R_VDD12_2213 METAL6_2469000_178600 METAL6_2468400_178600 0.0012
R_VDD12_2214 METAL6_2468400_178600 METAL6_2465600_178600 0.0056
R_VDD12_2215 METAL6_2465600_178600 METAL6_2464000_178600 0.0032
R_VDD12_2216 METAL6_2464000_178600 METAL6_2460600_178600 0.0068
R_VDD12_2217 METAL6_2460600_178600 METAL6_2458600_178600 0.004
R_VDD12_2218 METAL6_2458600_178600 METAL6_2457000_178600 0.0032
R_VDD12_2219 METAL6_2457000_178600 METAL6_2452000_178600 0.01
R_VDD12_2220 METAL6_2452000_178600 METAL6_2448600_178600 0.0068
R_VDD12_2221 METAL6_2448600_178600 METAL6_2446600_178600 0.004
R_VDD12_2222 METAL6_2446600_178600 METAL6_2440000_178600 0.0132
R_VDD12_2223 METAL6_2440000_178600 METAL6_2436600_178600 0.0068
R_VDD12_2224 METAL6_2436600_178600 METAL6_2434600_178600 0.004
R_VDD12_2225 METAL6_2434600_178600 METAL6_2424600_178600 0.02
R_VDD12_2226 METAL6_2424600_178600 METAL6_2422600_178600 0.004
R_VDD12_2227 METAL6_2422600_178600 METAL6_2419100_178600 0.007
R_VDD12_2228 METAL6_2419100_178600 METAL6_2407100_178600 0.024
R_VDD12_2229 METAL6_2407100_178600 METAL6_2405600_178600 0.003
R_VDD12_2230 METAL6_2405600_178600 METAL6_2402100_178600 0.007
R_VDD12_2231 METAL6_2402100_178600 METAL6_2395100_178600 0.014
R_VDD12_2232 METAL6_2395100_178600 METAL6_2393600_178600 0.003
R_VDD12_2233 METAL6_2393600_178600 METAL6_2383100_178600 0.021
R_VDD12_2234 METAL6_2383100_178600 METAL6_2381600_178600 0.003
R_VDD12_2235 METAL6_2381600_178600 METAL6_2371100_178600 0.021
R_VDD12_2236 METAL6_2371100_178600 METAL6_2369600_178600 0.003
R_VDD12_2237 METAL6_2369600_178600 METAL6_2365900_178600 0.0074
R_VDD12_2238 METAL6_2365900_178600 METAL6_2357600_178600 0.0166
R_VDD12_2239 METAL6_2357600_178600 METAL6_2351900_178600 0.0114
R_VDD12_2240 METAL6_2351900_178600 METAL6_2343700_178600 0.0164
R_VDD12_2241 METAL6_2343700_178600 METAL6_2332600_178600 0.0222
R_VDD12_2242 METAL6_2332600_178600 METAL6_2322900_178600 0.0194
R_VDD12_2243 METAL6_2322900_178600 METAL6_2320600_178600 0.0046
R_VDD12_2244 METAL6_2320600_178600 METAL6_2310900_178600 0.0194
R_VDD12_2245 METAL6_2310900_178600 METAL6_2308600_178600 0.0046
R_VDD12_2246 METAL6_2308600_178600 METAL6_2298900_178600 0.0194
R_VDD12_2247 METAL6_2298900_178600 METAL6_2296600_178600 0.0046
R_VDD12_2248 METAL6_2296600_178600 METAL6_2286900_178600 0.0194
R_VDD12_2249 METAL6_2286900_178600 METAL6_2284600_178600 0.0046
R_VDD12_2250 METAL6_2284600_178600 METAL6_2284400_178600 0.0004
R_VDD12_2251 METAL6_2284400_178600 METAL6_2274900_178600 0.019
R_VDD12_2252 METAL6_2274900_178600 METAL6_2272600_178600 0.0046
R_VDD12_2253 METAL6_2272600_178600 METAL6_2272400_178600 0.0004
R_VDD12_2254 METAL6_2272400_178600 METAL6_2260600_178600 0.0236
R_VDD12_2255 METAL6_2260600_178600 METAL6_2260400_178600 0.0004
R_VDD12_2256 METAL6_2260400_178600 METAL6_2258600_178600 0.0036
R_VDD12_2257 METAL6_2258600_178600 METAL6_2248700_178600 0.0198
R_VDD12_2258 METAL6_2248700_178600 METAL6_2248600_178600 0.0002
R_VDD12_2259 METAL6_2248600_178600 METAL6_2248400_178600 0.0004
R_VDD12_2260 METAL6_2248400_178600 METAL6_2246600_178600 0.0036
R_VDD12_2261 METAL6_2246600_178600 METAL6_2245900_178600 0.0014
R_VDD12_2262 METAL6_2245900_178600 METAL6_2236700_178600 0.0184
R_VDD12_2263 METAL6_2236700_178600 METAL6_2236600_178600 0.0002
R_VDD12_2264 METAL6_2236600_178600 METAL6_2234600_178600 0.004
R_VDD12_2265 METAL6_2234600_178600 METAL6_2233900_178600 0.0014
R_VDD12_2266 METAL6_2233900_178600 METAL6_2224700_178600 0.0184
R_VDD12_2267 METAL6_2224700_178600 METAL6_2224600_178600 0.0002
R_VDD12_2268 METAL6_2224600_178600 METAL6_2222600_178600 0.004
R_VDD12_2269 METAL6_2222600_178600 METAL6_2221900_178600 0.0014
R_VDD12_2270 METAL6_2221900_178600 METAL6_2212700_178600 0.0184
R_VDD12_2271 METAL6_2212700_178600 METAL6_2212600_178600 0.0002
R_VDD12_2272 METAL6_2212600_178600 METAL6_2210600_178600 0.004
R_VDD12_2273 METAL6_2210600_178600 METAL6_2209900_178600 0.0014
R_VDD12_2274 METAL6_2209900_178600 METAL6_2200700_178600 0.0184
R_VDD12_2275 METAL6_2200700_178600 METAL6_2189900_178600 0.0216
R_VDD12_2276 METAL6_2189900_178600 METAL6_2188700_178600 0.0024
R_VDD12_2277 METAL6_2188700_178600 METAL6_2177900_178600 0.0216
R_VDD12_2278 METAL6_2177900_178600 METAL6_2176700_178600 0.0024
R_VDD12_2279 METAL6_2176700_178600 METAL6_2165900_178600 0.0216
R_VDD12_2280 METAL6_2165900_178600 METAL6_2165400_178600 0.001
R_VDD12_2281 METAL6_2165400_178600 METAL6_2153900_178600 0.023
R_VDD12_2282 METAL6_2153900_178600 METAL6_2153400_178600 0.001
R_VDD12_2283 METAL6_2153400_178600 METAL6_2151900_178600 0.003
R_VDD12_2284 METAL6_2151900_178600 METAL6_2141900_178600 0.02
R_VDD12_2285 METAL6_2141900_178600 METAL6_2141400_178600 0.001
R_VDD12_2286 METAL6_2141400_178600 METAL6_2129900_178600 0.023
R_VDD12_2287 METAL6_2129900_178600 METAL6_2129700_178600 0.0004
R_VDD12_2288 METAL6_2129700_178600 METAL6_2125600_178600 0.0082
R_VDD12_2289 METAL6_2125600_178600 METAL6_2121400_178600 0.0084
R_VDD12_2290 METAL6_2121400_178600 METAL6_2117900_178600 0.007
R_VDD12_2291 METAL6_2117900_178600 METAL6_2113900_178600 0.008
R_VDD12_2292 METAL6_2113900_178600 METAL6_2113600_178600 0.0006
R_VDD12_2293 METAL6_2113600_166600 METAL6_2113600_178600 0.024
R_VDD12_2294 METAL6_2793600_76600 METAL6_2793600_64600 0.024
R_VDD12_2295 METAL6_3111200_40600 METAL6_3110900_40600 0.0006
R_VDD12_2296 METAL6_3110900_40600 METAL6_3100000_40600 0.0218
R_VDD12_2297 METAL6_3100000_40600 METAL6_3099200_40600 0.0016
R_VDD12_2298 METAL6_3099200_40600 METAL6_3098900_40600 0.0006
R_VDD12_2299 METAL6_3098900_40600 METAL6_3088000_40600 0.0218
R_VDD12_2300 METAL6_3088000_40600 METAL6_3087200_40600 0.0016
R_VDD12_2301 METAL6_3087200_40600 METAL6_3086900_40600 0.0006
R_VDD12_2302 METAL6_3086900_40600 METAL6_3076000_40600 0.0218
R_VDD12_2303 METAL6_3076000_40600 METAL6_3075200_40600 0.0016
R_VDD12_2304 METAL6_3075200_40600 METAL6_3068200_40600 0.014
R_VDD12_2305 METAL6_3068200_40600 METAL6_3064000_40600 0.0084
R_VDD12_2306 METAL6_3064000_40600 METAL6_3063200_40600 0.0016
R_VDD12_2307 METAL6_3063200_40600 METAL6_3060600_40600 0.0052
R_VDD12_2308 METAL6_3060600_40600 METAL6_3052000_40600 0.0172
R_VDD12_2309 METAL6_3052000_40600 METAL6_3035200_40600 0.0336
R_VDD12_2310 METAL6_3035200_40600 METAL6_3024000_40600 0.0224
R_VDD12_2311 METAL6_3024000_40600 METAL6_3023200_40600 0.0016
R_VDD12_2312 METAL6_3023200_40600 METAL6_3018200_40600 0.01
R_VDD12_2313 METAL6_3018200_40600 METAL6_3012000_40600 0.0124
R_VDD12_2314 METAL6_3012000_40600 METAL5_3012000_40600 0.1
R_VDD12_2315 METAL5_3012000_40600 METAL5_3011200_40600 0.0032
R_VDD12_2316 METAL5_3011200_40600 METAL5_3006200_40600 0.02
R_VDD12_2317 METAL5_3006200_40600 METAL5_3000000_40600 0.0248
R_VDD12_2318 METAL5_3000000_40600 METAL5_2994200_40600 0.0232
R_VDD12_2319 METAL5_2994200_40600 METAL5_2993000_40600 0.0048
R_VDD12_2320 METAL5_2993000_40600 METAL5_2988000_40600 0.02
R_VDD12_2321 METAL5_2988000_40600 METAL6_2988000_40600 0.1
R_VDD12_2322 METAL6_2988000_40600 METAL6_2987200_40600 0.0016
R_VDD12_2323 METAL6_2987200_40600 METAL6_2982200_40600 0.01
R_VDD12_2324 METAL6_2982200_40600 METAL6_2975200_40600 0.014
R_VDD12_2325 METAL6_2975200_40600 METAL6_2970200_40600 0.01
R_VDD12_2326 METAL6_2970200_40600 METAL6_2965900_40600 0.0086
R_VDD12_2327 METAL6_2965900_40600 METAL6_2963200_40600 0.0054
R_VDD12_2328 METAL6_2963200_40600 METAL6_2958200_40600 0.01
R_VDD12_2329 METAL6_2958200_40600 METAL6_2951900_40600 0.0126
R_VDD12_2330 METAL6_2951900_40600 METAL6_2942200_40600 0.0194
R_VDD12_2331 METAL6_2942200_40600 METAL6_2930200_40600 0.024
R_VDD12_2332 METAL6_2930200_40600 METAL6_2925600_40600 0.0092
R_VDD12_2333 METAL6_2925600_40600 METAL6_2918200_40600 0.0148
R_VDD12_2334 METAL6_2918200_40600 METAL6_2913600_40600 0.0092
R_VDD12_2335 METAL6_2913600_40600 METAL6_2910900_40600 0.0054
R_VDD12_2336 METAL6_2910900_40600 METAL6_2901600_40600 0.0186
R_VDD12_2337 METAL6_2901600_40600 METAL6_2898900_40600 0.0054
R_VDD12_2338 METAL6_2898900_40600 METAL6_2897100_40600 0.0036
R_VDD12_2339 METAL6_2897100_40600 METAL6_2886900_40600 0.0204
R_VDD12_2340 METAL6_2886900_40600 METAL6_2874900_40600 0.024
R_VDD12_2341 METAL6_2874900_40600 METAL6_2874800_40600 0.0002
R_VDD12_2342 METAL6_2874800_40600 METAL6_2862800_40600 0.024
R_VDD12_2343 METAL6_2862800_40600 METAL6_2860600_40600 0.0044
R_VDD12_2344 METAL6_2860600_40600 METAL6_2850800_40600 0.0196
R_VDD12_2345 METAL6_2850800_40600 METAL6_2846600_40600 0.0084
R_VDD12_2346 METAL6_2846600_40600 METAL6_2843800_40600 0.0056
R_VDD12_2347 METAL6_2843800_40600 METAL6_2824000_40600 0.0396
R_VDD12_2348 METAL6_2824000_40600 METAL6_2817600_40600 0.0128
R_VDD12_2349 METAL6_2817600_40600 METAL6_2812000_40600 0.0112
R_VDD12_2350 METAL6_2812000_40600 METAL6_2810800_40600 0.0024
R_VDD12_2351 METAL6_2810800_40600 METAL6_2805600_40600 0.0104
R_VDD12_2352 METAL6_2805600_40600 METAL6_2800000_40600 0.0112
R_VDD12_2353 METAL6_2800000_40600 METAL6_2798800_40600 0.0024
R_VDD12_2354 METAL6_2798800_40600 METAL6_2793600_40600 0.0104
R_VDD12_2355 METAL6_2793600_40600 METAL5_2793600_40600 0.1
R_VDD12_2356 METAL5_2793600_40600 METAL4_2793600_40600 0.1
R_VDD12_2357 METAL4_2793600_40600 METAL4_2793600_52000 0.0912
R_VDD12_2358 METAL4_2793600_52000 METAL4_2793600_52600 0.0048
R_VDD12_2359 METAL4_2793600_52600 METAL4_2793600_64000 0.0912
R_VDD12_2360 METAL4_2793600_64000 METAL4_2793600_64600 0.0048
R_VDD12_2361 METAL4_2793600_64600 METAL5_2793600_64600 0.1
R_VDD12_2362 METAL5_2793600_64600 METAL6_2793600_64600 0.1
I_VDD12_10 METAL6_2113600_166600 gnd 0.003
I_VDD12_11 METAL6_2793600_76600 gnd 0.003

V_VDD13_5 METAL6_3300000_0 gnd 1
R_VDD13_2363 METAL6_3300000_0 METAL6_3300000_9500 0.019
R_VDD13_2364 METAL6_3300000_9500 METAL6_3300000_16600 0.0142
R_VDD13_2365 METAL6_3300000_16600 METAL6_3300000_21500 0.0098
R_VDD13_2366 METAL6_3300000_21500 METAL6_3300000_28600 0.0142
R_VDD13_2367 METAL6_3300000_28600 METAL6_3300000_33500 0.0098
R_VDD13_2368 METAL6_3300000_33500 METAL6_3300000_40600 0.0142
R_VDD13_2369 METAL6_3300000_40600 METAL6_3300000_52000 0.0228
R_VDD13_2370 METAL6_3300000_52000 METAL6_3299000_52000 0.002
R_VDD13_2371 METAL6_3299000_52000 METAL6_3288400_52000 0.0212
R_VDD13_2372 METAL6_3288400_52000 METAL6_3288400_52600 0.0012
R_VDD13_2373 METAL6_3288400_52600 METAL6_3288400_64000 0.0228
R_VDD13_2374 METAL6_3288400_64000 METAL6_3288400_64600 0.0012
R_VDD13_2375 METAL6_3288400_64600 METAL6_3288400_71600 0.014
R_VDD13_2376 METAL6_3288400_71600 METAL6_3288400_76000 0.0088
R_VDD13_2377 METAL6_3288400_76000 METAL6_3288400_76600 0.0012
R_VDD13_2378 METAL6_3288400_76600 METAL6_3288400_83600 0.014
R_VDD13_2379 METAL6_3288400_83600 METAL6_3288400_88000 0.0088
R_VDD13_2380 METAL6_3288400_88000 METAL6_3288400_88600 0.0012
R_VDD13_2381 METAL6_3288400_88600 METAL6_3288400_95600 0.014
R_VDD13_2382 METAL6_3288400_95600 METAL6_3288400_100000 0.0088
R_VDD13_2383 METAL6_3288400_100000 METAL6_3288400_112000 0.024
R_VDD13_2384 METAL6_3288400_112000 METAL6_3288400_147600 0.0712
R_VDD13_2385 METAL6_3288400_147600 METAL6_3288400_159600 0.024
R_VDD13_2386 METAL6_3288400_159600 METAL6_3288400_164000 0.0088
R_VDD13_2387 METAL6_3288400_164000 METAL6_3288400_166600 0.0052
R_VDD13_2388 METAL6_3288400_166600 METAL6_3288400_171600 0.01
R_VDD13_2389 METAL6_3288400_171600 METAL6_3288400_176000 0.0088
R_VDD13_2390 METAL6_3288400_176000 METAL6_3288400_178600 0.0052
R_VDD13_2391 METAL6_3288400_178600 METAL6_3288400_188000 0.0188
R_VDD13_2392 METAL6_3288400_188000 METAL6_3288400_190600 0.0052
R_VDD13_2393 METAL6_3288400_190600 METAL6_3288000_190600 0.0008
R_VDD13_2394 METAL6_3288000_190600 METAL6_3287000_190600 0.002
R_VDD13_2395 METAL6_3287000_190600 METAL6_3276400_190600 0.0212
R_VDD13_2396 METAL6_3276400_190600 METAL6_3275000_190600 0.0028
R_VDD13_2397 METAL6_3275000_190600 METAL6_3263000_190600 0.024
R_VDD13_2398 METAL6_3263000_190600 METAL6_3260400_190600 0.0052
R_VDD13_2399 METAL6_3260400_190600 METAL6_3243500_190600 0.0338
R_VDD13_2400 METAL6_3243500_190600 METAL6_3231500_190600 0.024
R_VDD13_2401 METAL6_3231500_190600 METAL6_3224500_190600 0.014
R_VDD13_2402 METAL6_3224500_190600 METAL6_3219500_190600 0.01
R_VDD13_2403 METAL6_3219500_190600 METAL6_3212500_190600 0.014
R_VDD13_2404 METAL6_3212500_190600 METAL6_3212000_190600 0.001
R_VDD13_2405 METAL6_3212000_190600 METAL6_3207500_190600 0.009
R_VDD13_2406 METAL6_3207500_190600 METAL6_3200500_190600 0.014
R_VDD13_2407 METAL6_3200500_190600 METAL6_3200000_190600 0.001
R_VDD13_2408 METAL6_3200000_190600 METAL6_3188000_190600 0.024
R_VDD13_2409 METAL6_3188000_190600 METAL6_3179500_190600 0.017
R_VDD13_2410 METAL6_3179500_190600 METAL6_3167500_190600 0.024
R_VDD13_2411 METAL6_3167500_190600 METAL6_3165900_190600 0.0032
R_VDD13_2412 METAL6_3165900_190600 METAL6_3155500_190600 0.0208
R_VDD13_2413 METAL6_3155500_190600 METAL6_3124000_190600 0.063
R_VDD13_2414 METAL6_3124000_190600 METAL6_3112000_190600 0.024
R_VDD13_2415 METAL6_3112000_190600 METAL6_3111200_190600 0.0016
R_VDD13_2416 METAL6_3111200_190600 METAL6_3110900_190600 0.0006
R_VDD13_2417 METAL6_3110900_190600 METAL6_3100000_190600 0.0218
R_VDD13_2418 METAL6_3100000_190600 METAL6_3099200_190600 0.0016
R_VDD13_2419 METAL6_3099200_190600 METAL6_3098900_190600 0.0006
R_VDD13_2420 METAL6_3098900_190600 METAL6_3088000_190600 0.0218
R_VDD13_2421 METAL6_3088000_190600 METAL6_3087200_190600 0.0016
R_VDD13_2422 METAL6_3087200_190600 METAL6_3086900_190600 0.0006
R_VDD13_2423 METAL6_3086900_190600 METAL6_3076000_190600 0.0218
R_VDD13_2424 METAL6_3076000_190600 METAL6_3075200_190600 0.0016
R_VDD13_2425 METAL6_3075200_190600 METAL6_3068200_190600 0.014
R_VDD13_2426 METAL6_3068200_190600 METAL6_3064000_190600 0.0084
R_VDD13_2427 METAL6_3064000_190600 METAL6_3063200_190600 0.0016
R_VDD13_2428 METAL6_3063200_190600 METAL6_3060600_190600 0.0052
R_VDD13_2429 METAL6_3060600_190600 METAL6_3052000_190600 0.0172
R_VDD13_2430 METAL6_3052000_190600 METAL6_3035200_190600 0.0336
R_VDD13_2431 METAL6_3035200_190600 METAL6_3024000_190600 0.0224
R_VDD13_2432 METAL6_3024000_190600 METAL6_3023200_190600 0.0016
R_VDD13_2433 METAL6_3023200_190600 METAL6_3018200_190600 0.01
R_VDD13_2434 METAL6_3018200_190600 METAL6_3012000_190600 0.0124
R_VDD13_2435 METAL6_3012000_190600 METAL6_3011200_190600 0.0016
R_VDD13_2436 METAL6_3011200_190600 METAL6_3006200_190600 0.01
R_VDD13_2437 METAL6_3006200_190600 METAL6_3000000_190600 0.0124
R_VDD13_2438 METAL6_3000000_190600 METAL6_2994200_190600 0.0116
R_VDD13_2439 METAL6_2994200_190600 METAL6_2993000_190600 0.0024
R_VDD13_2440 METAL6_2993000_190600 METAL6_2988000_190600 0.01
R_VDD13_2441 METAL6_2988000_190600 METAL6_2982200_190600 0.0116
R_VDD13_2442 METAL6_2982200_190600 METAL6_2975200_190600 0.014
R_VDD13_2443 METAL6_2975200_190600 METAL6_2970200_190600 0.01
R_VDD13_2444 METAL6_2970200_190600 METAL6_2965900_190600 0.0086
R_VDD13_2445 METAL6_2965900_190600 METAL6_2951900_190600 0.028
R_VDD13_2446 METAL6_2951900_190600 METAL6_2942200_190600 0.0194
R_VDD13_2447 METAL6_2942200_190600 METAL6_2930200_190600 0.024
R_VDD13_2448 METAL6_2930200_190600 METAL6_2925600_190600 0.0092
R_VDD13_2449 METAL6_2925600_190600 METAL6_2918200_190600 0.0148
R_VDD13_2450 METAL6_2918200_190600 METAL6_2913600_190600 0.0092
R_VDD13_2451 METAL6_2913600_190600 METAL6_2910900_190600 0.0054
R_VDD13_2452 METAL6_2910900_190600 METAL6_2901600_190600 0.0186
R_VDD13_2453 METAL6_2901600_190600 METAL6_2898900_190600 0.0054
R_VDD13_2454 METAL6_2898900_190600 METAL6_2897100_190600 0.0036
R_VDD13_2455 METAL6_2897100_190600 METAL6_2886900_190600 0.0204
R_VDD13_2456 METAL6_2886900_190600 METAL6_2874800_190600 0.0242
R_VDD13_2457 METAL6_2874800_190600 METAL6_2862800_190600 0.024
R_VDD13_2458 METAL6_2862800_190600 METAL6_2860600_190600 0.0044
R_VDD13_2459 METAL6_2860600_190600 METAL6_2850800_190600 0.0196
R_VDD13_2460 METAL6_2850800_190600 METAL6_2846600_190600 0.0084
R_VDD13_2461 METAL6_2846600_190600 METAL6_2843800_190600 0.0056
R_VDD13_2462 METAL6_2843800_190600 METAL6_2812000_190600 0.0636
R_VDD13_2463 METAL6_2812000_190600 METAL6_2810800_190600 0.0024
R_VDD13_2464 METAL6_2810800_190600 METAL6_2805600_190600 0.0104
R_VDD13_2465 METAL6_2805600_190600 METAL6_2800000_190600 0.0112
R_VDD13_2466 METAL6_2800000_190600 METAL6_2798800_190600 0.0024
R_VDD13_2467 METAL6_2798800_190600 METAL6_2793600_190600 0.0104
R_VDD13_2468 METAL6_2793600_190600 METAL6_2788000_190600 0.0112
R_VDD13_2469 METAL6_2788000_190600 METAL6_2786800_190600 0.0024
R_VDD13_2470 METAL6_2786800_190600 METAL6_2781600_190600 0.0104
R_VDD13_2471 METAL6_2781600_190600 METAL6_2765900_190600 0.0314
R_VDD13_2472 METAL6_2765900_190600 METAL6_2751900_190600 0.028
R_VDD13_2473 METAL6_2751900_190600 METAL6_2728200_190600 0.0474
R_VDD13_2474 METAL6_2728200_190600 METAL6_2710900_190600 0.0346
R_VDD13_2475 METAL6_2710900_190600 METAL6_2698900_190600 0.024
R_VDD13_2476 METAL6_2698900_190600 METAL6_2686900_190600 0.024
R_VDD13_2477 METAL6_2686900_190600 METAL6_2683200_190600 0.0074
R_VDD13_2478 METAL6_2683200_190600 METAL6_2676200_190600 0.014
R_VDD13_2479 METAL6_2676200_190600 METAL6_2664200_190600 0.024
R_VDD13_2480 METAL6_2664200_190600 METAL6_2660600_190600 0.0072
R_VDD13_2481 METAL6_2660600_190600 METAL6_2652200_190600 0.0168
R_VDD13_2482 METAL6_2652200_190600 METAL6_2646600_190600 0.0112
R_VDD13_2483 METAL6_2646600_190600 METAL6_2604400_190600 0.0844
R_VDD13_2484 METAL6_2604400_190600 METAL6_2592400_190600 0.024
R_VDD13_2485 METAL6_2592400_190600 METAL6_2580400_190600 0.024
R_VDD13_2486 METAL6_2580400_190600 METAL6_2568400_190600 0.024
R_VDD13_2487 METAL6_2568400_190600 METAL6_2565900_190600 0.005
R_VDD13_2488 METAL6_2565900_190600 METAL6_2556400_190600 0.019
R_VDD13_2489 METAL6_2556400_190600 METAL6_2551900_190600 0.009
R_VDD13_2490 METAL6_2551900_190600 METAL6_2548000_190600 0.0078
R_VDD13_2491 METAL6_2548000_190600 METAL6_2537600_190600 0.0208
R_VDD13_2492 METAL6_2537600_190600 METAL6_2536000_190600 0.0032
R_VDD13_2493 METAL6_2536000_190600 METAL6_2535400_190600 0.0012
R_VDD13_2494 METAL6_2535400_190600 METAL6_2529000_190600 0.0128
R_VDD13_2495 METAL6_2529000_190600 METAL6_2528400_190600 0.0012
R_VDD13_2496 METAL6_2528400_190600 METAL6_2525600_190600 0.0056
R_VDD13_2497 METAL6_2525600_190600 METAL6_2524000_190600 0.0032
R_VDD13_2498 METAL6_2524000_190600 METAL6_2517000_190600 0.014
R_VDD13_2499 METAL6_2517000_190600 METAL6_2516400_190600 0.0012
R_VDD13_2500 METAL6_2516400_190600 METAL6_2513600_190600 0.0056
R_VDD13_2501 METAL6_2513600_190600 METAL6_2512000_190600 0.0032
R_VDD13_2502 METAL6_2512000_190600 METAL6_2510900_190600 0.0022
R_VDD13_2503 METAL6_2510900_190600 METAL6_2505000_190600 0.0118
R_VDD13_2504 METAL6_2505000_190600 METAL6_2504400_190600 0.0012
R_VDD13_2505 METAL6_2504400_190600 METAL6_2501600_190600 0.0056
R_VDD13_2506 METAL6_2501600_190600 METAL6_2500000_190600 0.0032
R_VDD13_2507 METAL6_2500000_190600 METAL6_2498900_190600 0.0022
R_VDD13_2508 METAL6_2498900_190600 METAL6_2496600_190600 0.0046
R_VDD13_2509 METAL6_2496600_190600 METAL6_2493000_190600 0.0072
R_VDD13_2510 METAL6_2493000_190600 METAL6_2492400_190600 0.0012
R_VDD13_2511 METAL6_2492400_190600 METAL6_2489600_190600 0.0056
R_VDD13_2512 METAL6_2489600_190600 METAL6_2488000_190600 0.0032
R_VDD13_2513 METAL6_2488000_190600 METAL6_2486900_190600 0.0022
R_VDD13_2514 METAL6_2486900_190600 METAL6_2484600_190600 0.0046
R_VDD13_2515 METAL6_2484600_190600 METAL6_2481000_190600 0.0072
R_VDD13_2516 METAL6_2481000_190600 METAL6_2480400_190600 0.0012
R_VDD13_2517 METAL6_2480400_190600 METAL6_2477600_190600 0.0056
R_VDD13_2518 METAL6_2477600_190600 METAL6_2476000_190600 0.0032
R_VDD13_2519 METAL6_2476000_190600 METAL6_2472600_190600 0.0068
R_VDD13_2520 METAL6_2472600_190600 METAL6_2470600_190600 0.004
R_VDD13_2521 METAL6_2470600_190600 METAL6_2469000_190600 0.0032
R_VDD13_2522 METAL6_2469000_190600 METAL6_2468400_190600 0.0012
R_VDD13_2523 METAL6_2468400_190600 METAL6_2465600_190600 0.0056
R_VDD13_2524 METAL6_2465600_190600 METAL6_2464000_190600 0.0032
R_VDD13_2525 METAL6_2464000_190600 METAL6_2460600_190600 0.0068
R_VDD13_2526 METAL6_2460600_190600 METAL6_2458600_190600 0.004
R_VDD13_2527 METAL6_2458600_190600 METAL6_2457000_190600 0.0032
R_VDD13_2528 METAL6_2457000_190600 METAL6_2448600_190600 0.0168
R_VDD13_2529 METAL6_2448600_190600 METAL6_2446600_190600 0.004
R_VDD13_2530 METAL6_2446600_190600 METAL6_2436600_190600 0.02
R_VDD13_2531 METAL6_2436600_190600 METAL6_2434600_190600 0.004
R_VDD13_2532 METAL6_2434600_190600 METAL6_2424600_190600 0.02
R_VDD13_2533 METAL6_2424600_190600 METAL6_2422600_190600 0.004
R_VDD13_2534 METAL6_2422600_190600 METAL6_2419100_190600 0.007
R_VDD13_2535 METAL6_2419100_190600 METAL6_2407100_190600 0.024
R_VDD13_2536 METAL6_2407100_190600 METAL6_2405600_190600 0.003
R_VDD13_2537 METAL6_2405600_190600 METAL6_2402100_190600 0.007
R_VDD13_2538 METAL6_2402100_190600 METAL6_2395100_190600 0.014
R_VDD13_2539 METAL6_2395100_190600 METAL6_2393600_190600 0.003
R_VDD13_2540 METAL6_2393600_190600 METAL6_2383100_190600 0.021
R_VDD13_2541 METAL6_2383100_190600 METAL6_2381600_190600 0.003
R_VDD13_2542 METAL6_2381600_190600 METAL6_2371100_190600 0.021
R_VDD13_2543 METAL6_2371100_190600 METAL6_2369600_190600 0.003
R_VDD13_2544 METAL6_2369600_190600 METAL6_2365900_190600 0.0074
R_VDD13_2545 METAL6_2365900_190600 METAL6_2357600_190600 0.0166
R_VDD13_2546 METAL6_2357600_190600 METAL6_2351900_190600 0.0114
R_VDD13_2547 METAL6_2351900_190600 METAL6_2343700_190600 0.0164
R_VDD13_2548 METAL6_2343700_190600 METAL6_2322900_190600 0.0416
R_VDD13_2549 METAL6_2322900_190600 METAL6_2320600_190600 0.0046
R_VDD13_2550 METAL6_2320600_190600 METAL6_2310900_190600 0.0194
R_VDD13_2551 METAL6_2310900_190600 METAL6_2308600_190600 0.0046
R_VDD13_2552 METAL6_2308600_190600 METAL6_2298900_190600 0.0194
R_VDD13_2553 METAL6_2298900_190600 METAL6_2296600_190600 0.0046
R_VDD13_2554 METAL6_2296600_190600 METAL6_2286900_190600 0.0194
R_VDD13_2555 METAL6_2286900_190600 METAL6_2284600_190600 0.0046
R_VDD13_2556 METAL6_2284600_190600 METAL6_2284400_190600 0.0004
R_VDD13_2557 METAL6_2284400_190600 METAL6_2274900_190600 0.019
R_VDD13_2558 METAL6_2274900_190600 METAL6_2272600_190600 0.0046
R_VDD13_2559 METAL6_2272600_190600 METAL6_2272400_190600 0.0004
R_VDD13_2560 METAL6_2272400_190600 METAL6_2260600_190600 0.0236
R_VDD13_2561 METAL6_2260600_190600 METAL6_2260400_190600 0.0004
R_VDD13_2562 METAL6_2260400_190600 METAL6_2258600_190600 0.0036
R_VDD13_2563 METAL6_2258600_190600 METAL6_2248700_190600 0.0198
R_VDD13_2564 METAL6_2248700_190600 METAL6_2248600_190600 0.0002
R_VDD13_2565 METAL6_2248600_190600 METAL6_2248400_190600 0.0004
R_VDD13_2566 METAL6_2248400_190600 METAL6_2246600_190600 0.0036
R_VDD13_2567 METAL6_2246600_190600 METAL6_2236700_190600 0.0198
R_VDD13_2568 METAL6_2236700_190600 METAL6_2236600_190600 0.0002
R_VDD13_2569 METAL6_2236600_190600 METAL6_2234600_190600 0.004
R_VDD13_2570 METAL6_2234600_190600 METAL6_2233900_190600 0.0014
R_VDD13_2571 METAL6_2233900_190600 METAL6_2224700_190600 0.0184
R_VDD13_2572 METAL6_2224700_190600 METAL6_2224600_190600 0.0002
R_VDD13_2573 METAL6_2224600_190600 METAL6_2222600_190600 0.004
R_VDD13_2574 METAL6_2222600_190600 METAL6_2221900_190600 0.0014
R_VDD13_2575 METAL6_2221900_190600 METAL6_2212700_190600 0.0184
R_VDD13_2576 METAL6_2212700_190600 METAL6_2210600_190600 0.0042
R_VDD13_2577 METAL6_2210600_190600 METAL6_2209900_190600 0.0014
R_VDD13_2578 METAL6_2209900_190600 METAL6_2200700_190600 0.0184
R_VDD13_2579 METAL6_2200700_190600 METAL6_2189900_190600 0.0216
R_VDD13_2580 METAL6_2189900_190600 METAL6_2188700_190600 0.0024
R_VDD13_2581 METAL6_2188700_190600 METAL6_2177900_190600 0.0216
R_VDD13_2582 METAL6_2177900_190600 METAL6_2176700_190600 0.0024
R_VDD13_2583 METAL6_2176700_190600 METAL6_2165900_190600 0.0216
R_VDD13_2584 METAL6_2165900_190600 METAL6_2165400_190600 0.001
R_VDD13_2585 METAL6_2165400_190600 METAL6_2153900_190600 0.023
R_VDD13_2586 METAL6_2153900_190600 METAL6_2153400_190600 0.001
R_VDD13_2587 METAL6_2153400_190600 METAL6_2151900_190600 0.003
R_VDD13_2588 METAL6_2151900_190600 METAL6_2141900_190600 0.02
R_VDD13_2589 METAL6_2141900_190600 METAL6_2141400_190600 0.001
R_VDD13_2590 METAL6_2141400_190600 METAL6_2129900_190600 0.023
R_VDD13_2591 METAL6_2129900_190600 METAL6_2129700_190600 0.0004
R_VDD13_2592 METAL6_2129700_190600 METAL6_2125600_190600 0.0082
R_VDD13_2593 METAL6_2125600_190600 METAL6_2121400_190600 0.0084
R_VDD13_2594 METAL6_2121400_190600 METAL6_2117900_190600 0.007
R_VDD13_2595 METAL6_2117900_190600 METAL6_2113900_190600 0.008
R_VDD13_2596 METAL6_2113900_190600 METAL6_2113600_190600 0.0006
R_VDD13_2597 METAL6_2113600_190600 METAL6_2105900_190600 0.0154
R_VDD13_2598 METAL6_2105900_190600 METAL6_2101900_190600 0.008
R_VDD13_2599 METAL6_2101900_190600 METAL6_2101600_190600 0.0006
R_VDD13_2600 METAL6_2101600_190600 METAL6_2089900_190600 0.0234
R_VDD13_2601 METAL6_2089900_190600 METAL6_2079700_190600 0.0204
R_VDD13_2602 METAL6_2079700_190600 METAL6_2079700_188000 0.0052
R_VDD13_2603 METAL6_2079700_188000 METAL6_2079700_178600 0.0188
R_VDD13_2604 METAL6_2079700_178600 METAL6_2077900_178600 0.0036
R_VDD13_2605 METAL6_2077900_178600 METAL6_2067700_178600 0.0204
R_VDD13_2606 METAL6_2067700_178600 METAL6_2060600_178600 0.0142
R_VDD13_2607 METAL6_2060600_178600 METAL6_2058800_178600 0.0036
R_VDD13_2608 METAL6_2058800_178600 METAL6_2055700_178600 0.0062
R_VDD13_2609 METAL6_2055700_178600 METAL6_2046800_178600 0.0178
R_VDD13_2610 METAL6_2046800_178600 METAL6_2046600_178600 0.0004
R_VDD13_2611 METAL6_2046600_178600 METAL6_2046400_178600 0.0004
R_VDD13_2612 METAL6_2046400_178600 METAL6_2043700_178600 0.0054
R_VDD13_2613 METAL6_2043700_178600 METAL6_2034800_178600 0.0178
R_VDD13_2614 METAL6_2034800_178600 METAL6_2031700_178600 0.0062
R_VDD13_2615 METAL6_2031700_178600 METAL6_2030900_178600 0.0016
R_VDD13_2616 METAL6_2030900_178600 METAL6_2026400_178600 0.009
R_VDD13_2617 METAL6_2026400_178600 METAL6_2021200_178600 0.0104
R_VDD13_2618 METAL6_2021200_178600 METAL6_2019700_178600 0.003
R_VDD13_2619 METAL6_2019700_178600 METAL6_2018900_178600 0.0016
R_VDD13_2620 METAL6_2018900_178600 METAL6_2014400_178600 0.009
R_VDD13_2621 METAL6_2014400_178600 METAL6_2012000_178600 0.0048
R_VDD13_2622 METAL6_2012000_178600 METAL6_2007700_178600 0.0086
R_VDD13_2623 METAL6_2007700_178600 METAL6_2006900_178600 0.0016
R_VDD13_2624 METAL6_2006900_178600 METAL6_2002400_178600 0.009
R_VDD13_2625 METAL6_2002400_178600 METAL6_2000000_178600 0.0048
R_VDD13_2626 METAL6_2000000_178600 METAL6_1988000_178600 0.024
R_VDD13_2627 METAL6_1988000_178600 METAL6_1963900_178600 0.0482
R_VDD13_2628 METAL6_1963900_178600 METAL6_1963800_178600 0.0002
R_VDD13_2629 METAL6_1963800_178600 METAL6_1951900_178600 0.0238
R_VDD13_2630 METAL6_1951900_178600 METAL6_1951800_178600 0.0002
R_VDD13_2631 METAL6_1951800_178600 METAL6_1939900_178600 0.0238
R_VDD13_2632 METAL6_1939900_178600 METAL6_1939800_178600 0.0002
R_VDD13_2633 METAL6_1939800_178600 METAL6_1937600_178600 0.0044
R_VDD13_2634 METAL6_1937600_178600 METAL6_1931200_178600 0.0128
R_VDD13_2635 METAL6_1931200_178600 METAL6_1927800_178600 0.0068
R_VDD13_2636 METAL6_1927800_178600 METAL6_1926200_178600 0.0032
R_VDD13_2637 METAL6_1926200_178600 METAL6_1925600_178600 0.0012
R_VDD13_2638 METAL6_1925600_178600 METAL6_1919200_178600 0.0128
R_VDD13_2639 METAL6_1919200_178600 METAL6_1913600_178600 0.0112
R_VDD13_2640 METAL6_1913600_166600 METAL6_1913600_178600 0.024
R_VDD13_2641 METAL6_2393600_76600 METAL6_2393600_64600 0.024
R_VDD13_2642 METAL6_3088000_190600 METAL6_3088000_188000 0.0052
R_VDD13_2643 METAL6_3088000_188000 METAL6_3088000_178600 0.0188
R_VDD13_2644 METAL6_3088000_178600 METAL6_3088000_176000 0.0052
R_VDD13_2645 METAL6_3088000_176000 METAL6_3088000_171600 0.0088
R_VDD13_2646 METAL6_3088000_171600 METAL6_3088000_166600 0.01
R_VDD13_2647 METAL6_3088000_166600 METAL6_3088000_164000 0.0052
R_VDD13_2648 METAL6_3088000_164000 METAL6_3088000_159600 0.0088
R_VDD13_2649 METAL6_3088000_159600 METAL6_3088000_147600 0.024
R_VDD13_2650 METAL6_3088000_147600 METAL6_3088000_112000 0.0712
R_VDD13_2651 METAL6_3088000_112000 METAL6_3088000_100000 0.024
R_VDD13_2652 METAL6_3088000_100000 METAL6_3088000_95600 0.0088
R_VDD13_2653 METAL6_3088000_95600 METAL6_3088000_88600 0.014
R_VDD13_2654 METAL6_3088000_88600 METAL6_3087200_88600 0.0016
R_VDD13_2655 METAL6_3087200_88600 METAL6_3087200_88000 0.0012
R_VDD13_2656 METAL6_3087200_88000 METAL6_3087200_83600 0.0088
R_VDD13_2657 METAL6_3087200_83600 METAL6_3087200_76600 0.014
R_VDD13_2658 METAL6_3087200_76600 METAL6_3087200_76000 0.0012
R_VDD13_2659 METAL6_3087200_76000 METAL6_3087200_71600 0.0088
R_VDD13_2660 METAL6_3087200_71600 METAL6_3087200_64600 0.014
R_VDD13_2661 METAL6_3087200_64600 METAL6_3086900_64600 0.0006
R_VDD13_2662 METAL6_3086900_64600 METAL6_3076000_64600 0.0218
R_VDD13_2663 METAL6_3076000_64600 METAL6_3075200_64600 0.0016
R_VDD13_2664 METAL6_3075200_64600 METAL6_3068200_64600 0.014
R_VDD13_2665 METAL6_3068200_64600 METAL6_3064000_64600 0.0084
R_VDD13_2666 METAL6_3064000_64600 METAL6_3063200_64600 0.0016
R_VDD13_2667 METAL6_3063200_64600 METAL6_3060600_64600 0.0052
R_VDD13_2668 METAL6_3060600_64600 METAL6_3052000_64600 0.0172
R_VDD13_2669 METAL6_3052000_64600 METAL6_3035200_64600 0.0336
R_VDD13_2670 METAL6_3035200_64600 METAL6_3024000_64600 0.0224
R_VDD13_2671 METAL6_3024000_64600 METAL6_3023200_64600 0.0016
R_VDD13_2672 METAL6_3023200_64600 METAL6_3018200_64600 0.01
R_VDD13_2673 METAL6_3018200_64600 METAL6_3012000_64600 0.0124
R_VDD13_2674 METAL6_3012000_64600 METAL6_3011200_64600 0.0016
R_VDD13_2675 METAL6_3011200_64600 METAL6_3006200_64600 0.01
R_VDD13_2676 METAL6_3006200_64600 METAL6_3000000_64600 0.0124
R_VDD13_2677 METAL6_3000000_64600 METAL6_2994200_64600 0.0116
R_VDD13_2678 METAL6_2994200_64600 METAL6_2993000_64600 0.0024
R_VDD13_2679 METAL6_2993000_64600 METAL6_2988000_64600 0.01
R_VDD13_2680 METAL6_2988000_64600 METAL6_2982200_64600 0.0116
R_VDD13_2681 METAL6_2982200_64600 METAL6_2975200_64600 0.014
R_VDD13_2682 METAL6_2975200_64600 METAL6_2970200_64600 0.01
R_VDD13_2683 METAL6_2970200_64600 METAL6_2965900_64600 0.0086
R_VDD13_2684 METAL6_2965900_64600 METAL6_2951900_64600 0.028
R_VDD13_2685 METAL6_2951900_64600 METAL6_2942200_64600 0.0194
R_VDD13_2686 METAL6_2942200_64600 METAL6_2930200_64600 0.024
R_VDD13_2687 METAL6_2930200_64600 METAL6_2925600_64600 0.0092
R_VDD13_2688 METAL6_2925600_64600 METAL6_2918200_64600 0.0148
R_VDD13_2689 METAL6_2918200_64600 METAL6_2913600_64600 0.0092
R_VDD13_2690 METAL6_2913600_64600 METAL6_2910900_64600 0.0054
R_VDD13_2691 METAL6_2910900_64600 METAL6_2901600_64600 0.0186
R_VDD13_2692 METAL6_2901600_64600 METAL6_2898900_64600 0.0054
R_VDD13_2693 METAL6_2898900_64600 METAL6_2897100_64600 0.0036
R_VDD13_2694 METAL6_2897100_64600 METAL6_2886900_64600 0.0204
R_VDD13_2695 METAL6_2886900_64600 METAL6_2874800_64600 0.0242
R_VDD13_2696 METAL6_2874800_64600 METAL6_2862800_64600 0.024
R_VDD13_2697 METAL6_2862800_64600 METAL6_2860600_64600 0.0044
R_VDD13_2698 METAL6_2860600_64600 METAL6_2850800_64600 0.0196
R_VDD13_2699 METAL6_2850800_64600 METAL6_2846600_64600 0.0084
R_VDD13_2700 METAL6_2846600_64600 METAL6_2843800_64600 0.0056
R_VDD13_2701 METAL6_2843800_64600 METAL6_2812000_64600 0.0636
R_VDD13_2702 METAL6_2812000_64600 METAL6_2810800_64600 0.0024
R_VDD13_2703 METAL6_2810800_64600 METAL6_2805600_64600 0.0104
R_VDD13_2704 METAL6_2805600_64600 METAL5_2805600_64600 0.1
R_VDD13_2705 METAL5_2805600_64600 METAL5_2805600_64000 0.0024
R_VDD13_2706 METAL5_2805600_64000 METAL5_2805600_52600 0.0456
R_VDD13_2707 METAL5_2805600_52600 METAL5_2800000_52600 0.0224
R_VDD13_2708 METAL5_2800000_52600 METAL5_2798800_52600 0.0048
R_VDD13_2709 METAL5_2798800_52600 METAL5_2793600_52600 0.0208
R_VDD13_2710 METAL5_2793600_52600 METAL5_2788000_52600 0.0224
R_VDD13_2711 METAL5_2788000_52600 METAL5_2786800_52600 0.0048
R_VDD13_2712 METAL5_2786800_52600 METAL5_2781600_52600 0.0208
R_VDD13_2713 METAL5_2781600_52600 METAL5_2781600_64000 0.0456
R_VDD13_2714 METAL5_2781600_64000 METAL5_2781600_64600 0.0024
R_VDD13_2715 METAL5_2781600_64600 METAL6_2781600_64600 0.1
R_VDD13_2716 METAL6_2781600_64600 METAL6_2765900_64600 0.0314
R_VDD13_2717 METAL6_2765900_64600 METAL6_2751900_64600 0.028
R_VDD13_2718 METAL6_2751900_64600 METAL6_2728200_64600 0.0474
R_VDD13_2719 METAL6_2728200_64600 METAL6_2710900_64600 0.0346
R_VDD13_2720 METAL6_2710900_64600 METAL6_2698900_64600 0.024
R_VDD13_2721 METAL6_2698900_64600 METAL6_2686900_64600 0.024
R_VDD13_2722 METAL6_2686900_64600 METAL6_2683200_64600 0.0074
R_VDD13_2723 METAL6_2683200_64600 METAL6_2676200_64600 0.014
R_VDD13_2724 METAL6_2676200_64600 METAL6_2664200_64600 0.024
R_VDD13_2725 METAL6_2664200_64600 METAL6_2660600_64600 0.0072
R_VDD13_2726 METAL6_2660600_64600 METAL6_2652200_64600 0.0168
R_VDD13_2727 METAL6_2652200_64600 METAL6_2646600_64600 0.0112
R_VDD13_2728 METAL6_2646600_64600 METAL6_2604400_64600 0.0844
R_VDD13_2729 METAL6_2604400_64600 METAL6_2592400_64600 0.024
R_VDD13_2730 METAL6_2592400_64600 METAL6_2580400_64600 0.024
R_VDD13_2731 METAL6_2580400_64600 METAL6_2568400_64600 0.024
R_VDD13_2732 METAL6_2568400_64600 METAL6_2565900_64600 0.005
R_VDD13_2733 METAL6_2565900_64600 METAL6_2556400_64600 0.019
R_VDD13_2734 METAL6_2556400_64600 METAL6_2551900_64600 0.009
R_VDD13_2735 METAL6_2551900_64600 METAL6_2548000_64600 0.0078
R_VDD13_2736 METAL6_2548000_64600 METAL6_2537600_64600 0.0208
R_VDD13_2737 METAL6_2537600_64600 METAL6_2536000_64600 0.0032
R_VDD13_2738 METAL6_2536000_64600 METAL6_2535400_64600 0.0012
R_VDD13_2739 METAL6_2535400_64600 METAL6_2529000_64600 0.0128
R_VDD13_2740 METAL6_2529000_64600 METAL6_2528400_64600 0.0012
R_VDD13_2741 METAL6_2528400_64600 METAL6_2525600_64600 0.0056
R_VDD13_2742 METAL6_2525600_64600 METAL6_2524000_64600 0.0032
R_VDD13_2743 METAL6_2524000_64600 METAL6_2517000_64600 0.014
R_VDD13_2744 METAL6_2517000_64600 METAL6_2516400_64600 0.0012
R_VDD13_2745 METAL6_2516400_64600 METAL6_2513600_64600 0.0056
R_VDD13_2746 METAL6_2513600_64600 METAL6_2512000_64600 0.0032
R_VDD13_2747 METAL6_2512000_64600 METAL6_2510900_64600 0.0022
R_VDD13_2748 METAL6_2510900_64600 METAL6_2505000_64600 0.0118
R_VDD13_2749 METAL6_2505000_64600 METAL6_2504400_64600 0.0012
R_VDD13_2750 METAL6_2504400_64600 METAL6_2501600_64600 0.0056
R_VDD13_2751 METAL6_2501600_64600 METAL6_2500000_64600 0.0032
R_VDD13_2752 METAL6_2500000_64600 METAL6_2498900_64600 0.0022
R_VDD13_2753 METAL6_2498900_64600 METAL6_2496600_64600 0.0046
R_VDD13_2754 METAL6_2496600_64600 METAL6_2493000_64600 0.0072
R_VDD13_2755 METAL6_2493000_64600 METAL6_2492400_64600 0.0012
R_VDD13_2756 METAL6_2492400_64600 METAL6_2489600_64600 0.0056
R_VDD13_2757 METAL6_2489600_64600 METAL6_2488000_64600 0.0032
R_VDD13_2758 METAL6_2488000_64600 METAL6_2486900_64600 0.0022
R_VDD13_2759 METAL6_2486900_64600 METAL6_2484600_64600 0.0046
R_VDD13_2760 METAL6_2484600_64600 METAL6_2481000_64600 0.0072
R_VDD13_2761 METAL6_2481000_64600 METAL6_2480400_64600 0.0012
R_VDD13_2762 METAL6_2480400_64600 METAL6_2477600_64600 0.0056
R_VDD13_2763 METAL6_2477600_64600 METAL6_2476000_64600 0.0032
R_VDD13_2764 METAL6_2476000_64600 METAL6_2472600_64600 0.0068
R_VDD13_2765 METAL6_2472600_64600 METAL6_2470600_64600 0.004
R_VDD13_2766 METAL6_2470600_64600 METAL6_2469000_64600 0.0032
R_VDD13_2767 METAL6_2469000_64600 METAL6_2468400_64600 0.0012
R_VDD13_2768 METAL6_2468400_64600 METAL6_2465600_64600 0.0056
R_VDD13_2769 METAL6_2465600_64600 METAL6_2464000_64600 0.0032
R_VDD13_2770 METAL6_2464000_64600 METAL6_2460600_64600 0.0068
R_VDD13_2771 METAL6_2460600_64600 METAL6_2458600_64600 0.004
R_VDD13_2772 METAL6_2458600_64600 METAL6_2457000_64600 0.0032
R_VDD13_2773 METAL6_2457000_64600 METAL6_2448600_64600 0.0168
R_VDD13_2774 METAL6_2448600_64600 METAL6_2446600_64600 0.004
R_VDD13_2775 METAL6_2446600_64600 METAL6_2436600_64600 0.02
R_VDD13_2776 METAL6_2436600_64600 METAL6_2434600_64600 0.004
R_VDD13_2777 METAL6_2434600_64600 METAL6_2424600_64600 0.02
R_VDD13_2778 METAL6_2424600_64600 METAL6_2422600_64600 0.004
R_VDD13_2779 METAL6_2422600_64600 METAL6_2419100_64600 0.007
R_VDD13_2780 METAL6_2419100_64600 METAL6_2407100_64600 0.024
R_VDD13_2781 METAL6_2407100_64600 METAL6_2405600_64600 0.003
R_VDD13_2782 METAL6_2405600_64600 METAL6_2402100_64600 0.007
R_VDD13_2783 METAL6_2402100_64600 METAL6_2395100_64600 0.014
R_VDD13_2784 METAL6_2395100_64600 METAL6_2393600_64600 0.003
I_VDD13_12 METAL6_1913600_166600 gnd 0.003
I_VDD13_13 METAL6_2393600_76600 gnd 0.003

V_VDD14_6 METAL5_3500000_100000 gnd 1.1
R_VDD14_2785 METAL5_3500000_100000 METAL5_3490500_100000 0.038
R_VDD14_2786 METAL5_3490500_100000 METAL6_3490500_100000 0.1
R_VDD14_2787 METAL6_3490500_100000 METAL6_3490500_112000 0.024
R_VDD14_2788 METAL6_3490500_112000 METAL6_3490500_159600 0.0952
R_VDD14_2789 METAL6_3490500_159600 METAL6_3478500_159600 0.024
R_VDD14_2790 METAL6_3478500_159600 METAL6_3478500_166600 0.014
R_VDD14_2791 METAL6_3478500_166600 METAL6_3478500_176000 0.0188
R_VDD14_2792 METAL6_3478500_176000 METAL6_3477000_176000 0.003
R_VDD14_2793 METAL6_3477000_176000 METAL6_3466500_176000 0.021
R_VDD14_2794 METAL6_3466500_176000 METAL6_3465000_176000 0.003
R_VDD14_2795 METAL6_3465000_176000 METAL6_3454500_176000 0.021
R_VDD14_2796 METAL6_3454500_176000 METAL6_3454500_178600 0.0052
R_VDD14_2797 METAL6_3454500_178600 METAL6_3454500_188000 0.0188
R_VDD14_2798 METAL6_3454500_188000 METAL6_3453000_188000 0.003
R_VDD14_2799 METAL6_3453000_188000 METAL6_3442500_188000 0.021
R_VDD14_2800 METAL6_3442500_188000 METAL6_3360400_188000 0.1642
R_VDD14_2801 METAL6_3360400_188000 METAL6_3348400_188000 0.024
R_VDD14_2802 METAL6_3348400_188000 METAL6_3336400_188000 0.024
R_VDD14_2803 METAL6_3336400_188000 METAL6_3324400_188000 0.024
R_VDD14_2804 METAL6_3324400_188000 METAL6_3312400_188000 0.024
R_VDD14_2805 METAL6_3312400_188000 METAL6_3312400_190600 0.0052
R_VDD14_2806 METAL6_3312400_190600 METAL6_3312400_200000 0.0188
R_VDD14_2807 METAL6_3312400_200000 METAL6_3312400_212000 0.024
R_VDD14_2808 METAL6_3312400_212000 METAL6_3312400_236300 0.0486
R_VDD14_2809 METAL6_3312400_236300 METAL6_3312400_248300 0.024
R_VDD14_2810 METAL6_3312400_248300 METAL6_3312000_248300 0.0008
R_VDD14_2811 METAL6_3312000_248300 METAL6_3305400_248300 0.0132
R_VDD14_2812 METAL6_3305400_248300 METAL6_3300400_248300 0.01
R_VDD14_2813 METAL6_3300400_248300 METAL6_3300000_248300 0.0008
R_VDD14_2814 METAL6_3300000_248300 METAL6_3299000_248300 0.002
R_VDD14_2815 METAL6_3299000_248300 METAL6_3288400_248300 0.0212
R_VDD14_2816 METAL6_3288400_248300 METAL6_3288000_248300 0.0008
R_VDD14_2817 METAL6_3288000_248300 METAL6_3287000_248300 0.002
R_VDD14_2818 METAL6_3287000_248300 METAL6_3276400_248300 0.0212
R_VDD14_2819 METAL6_3276400_248300 METAL6_3275000_248300 0.0028
R_VDD14_2820 METAL6_3275000_248300 METAL6_3263000_248300 0.024
R_VDD14_2821 METAL6_3263000_248300 METAL6_3260400_248300 0.0052
R_VDD14_2822 METAL6_3260400_248300 METAL6_3243500_248300 0.0338
R_VDD14_2823 METAL6_3243500_248300 METAL6_3231500_248300 0.024
R_VDD14_2824 METAL6_3231500_248300 METAL6_3224500_248300 0.014
R_VDD14_2825 METAL6_3224500_248300 METAL6_3219500_248300 0.01
R_VDD14_2826 METAL6_3219500_248300 METAL6_3212500_248300 0.014
R_VDD14_2827 METAL6_3212500_248300 METAL6_3212000_248300 0.001
R_VDD14_2828 METAL6_3212000_248300 METAL6_3207500_248300 0.009
R_VDD14_2829 METAL6_3207500_248300 METAL6_3200500_248300 0.014
R_VDD14_2830 METAL6_3200500_248300 METAL6_3200000_248300 0.001
R_VDD14_2831 METAL6_3200000_248300 METAL6_3188000_248300 0.024
R_VDD14_2832 METAL6_3188000_248300 METAL6_3179500_248300 0.017
R_VDD14_2833 METAL6_3179500_248300 METAL6_3167500_248300 0.024
R_VDD14_2834 METAL6_3167500_248300 METAL6_3165900_248300 0.0032
R_VDD14_2835 METAL6_3165900_248300 METAL6_3155500_248300 0.0208
R_VDD14_2836 METAL6_3155500_248300 METAL6_3124000_248300 0.063
R_VDD14_2837 METAL6_3124000_248300 METAL6_3112000_248300 0.024
R_VDD14_2838 METAL6_3112000_248300 METAL6_3111200_248300 0.0016
R_VDD14_2839 METAL6_3111200_248300 METAL6_3110900_248300 0.0006
R_VDD14_2840 METAL6_3110900_248300 METAL6_3100000_248300 0.0218
R_VDD14_2841 METAL6_3100000_248300 METAL6_3099200_248300 0.0016
R_VDD14_2842 METAL6_3099200_248300 METAL6_3098900_248300 0.0006
R_VDD14_2843 METAL6_3098900_248300 METAL6_3088000_248300 0.0218
R_VDD14_2844 METAL6_3088000_248300 METAL6_3087200_248300 0.0016
R_VDD14_2845 METAL6_3087200_248300 METAL6_3086900_248300 0.0006
R_VDD14_2846 METAL6_3086900_248300 METAL6_3076000_248300 0.0218
R_VDD14_2847 METAL6_3076000_248300 METAL6_3075200_248300 0.0016
R_VDD14_2848 METAL6_3075200_248300 METAL6_3068200_248300 0.014
R_VDD14_2849 METAL6_3068200_248300 METAL6_3064000_248300 0.0084
R_VDD14_2850 METAL6_3064000_248300 METAL6_3063200_248300 0.0016
R_VDD14_2851 METAL6_3063200_248300 METAL6_3060600_248300 0.0052
R_VDD14_2852 METAL6_3060600_248300 METAL6_3052000_248300 0.0172
R_VDD14_2853 METAL6_3052000_248300 METAL6_3035200_248300 0.0336
R_VDD14_2854 METAL6_3035200_248300 METAL6_3024000_248300 0.0224
R_VDD14_2855 METAL6_3024000_248300 METAL6_3023200_248300 0.0016
R_VDD14_2856 METAL6_3023200_248300 METAL6_3018200_248300 0.01
R_VDD14_2857 METAL6_3018200_248300 METAL6_3012000_248300 0.0124
R_VDD14_2858 METAL6_3012000_248300 METAL6_3011200_248300 0.0016
R_VDD14_2859 METAL6_3011200_248300 METAL6_3006200_248300 0.01
R_VDD14_2860 METAL6_3006200_248300 METAL6_3000000_248300 0.0124
R_VDD14_2861 METAL6_3000000_248300 METAL6_2994200_248300 0.0116
R_VDD14_2862 METAL6_2994200_248300 METAL6_2993000_248300 0.0024
R_VDD14_2863 METAL6_2993000_248300 METAL6_2988000_248300 0.01
R_VDD14_2864 METAL6_2988000_248300 METAL6_2982200_248300 0.0116
R_VDD14_2865 METAL6_2982200_248300 METAL6_2975200_248300 0.014
R_VDD14_2866 METAL6_2975200_248300 METAL6_2970200_248300 0.01
R_VDD14_2867 METAL6_2970200_248300 METAL6_2965900_248300 0.0086
R_VDD14_2868 METAL6_2965900_248300 METAL6_2951900_248300 0.028
R_VDD14_2869 METAL6_2951900_248300 METAL6_2942200_248300 0.0194
R_VDD14_2870 METAL6_2942200_248300 METAL6_2930200_248300 0.024
R_VDD14_2871 METAL6_2930200_248300 METAL6_2925600_248300 0.0092
R_VDD14_2872 METAL6_2925600_248300 METAL6_2918200_248300 0.0148
R_VDD14_2873 METAL6_2918200_248300 METAL6_2913600_248300 0.0092
R_VDD14_2874 METAL6_2913600_248300 METAL6_2910900_248300 0.0054
R_VDD14_2875 METAL6_2910900_248300 METAL6_2901600_248300 0.0186
R_VDD14_2876 METAL6_2901600_248300 METAL6_2898900_248300 0.0054
R_VDD14_2877 METAL6_2898900_248300 METAL6_2897100_248300 0.0036
R_VDD14_2878 METAL6_2897100_248300 METAL6_2886900_248300 0.0204
R_VDD14_2879 METAL6_2886900_248300 METAL6_2874800_248300 0.0242
R_VDD14_2880 METAL6_2874800_248300 METAL6_2862800_248300 0.024
R_VDD14_2881 METAL6_2862800_248300 METAL6_2860600_248300 0.0044
R_VDD14_2882 METAL6_2860600_248300 METAL6_2850800_248300 0.0196
R_VDD14_2883 METAL6_2850800_248300 METAL6_2846600_248300 0.0084
R_VDD14_2884 METAL6_2846600_248300 METAL6_2843800_248300 0.0056
R_VDD14_2885 METAL6_2843800_248300 METAL6_2812000_248300 0.0636
R_VDD14_2886 METAL6_2812000_248300 METAL6_2810800_248300 0.0024
R_VDD14_2887 METAL6_2810800_248300 METAL6_2805600_248300 0.0104
R_VDD14_2888 METAL6_2805600_248300 METAL6_2800000_248300 0.0112
R_VDD14_2889 METAL6_2800000_248300 METAL6_2798800_248300 0.0024
R_VDD14_2890 METAL6_2798800_248300 METAL6_2793600_248300 0.0104
R_VDD14_2891 METAL6_2793600_248300 METAL6_2788000_248300 0.0112
R_VDD14_2892 METAL6_2788000_248300 METAL6_2786800_248300 0.0024
R_VDD14_2893 METAL6_2786800_248300 METAL6_2781600_248300 0.0104
R_VDD14_2894 METAL6_2781600_248300 METAL6_2765900_248300 0.0314
R_VDD14_2895 METAL6_2765900_248300 METAL6_2751900_248300 0.028
R_VDD14_2896 METAL6_2751900_248300 METAL6_2728200_248300 0.0474
R_VDD14_2897 METAL6_2728200_248300 METAL6_2710900_248300 0.0346
R_VDD14_2898 METAL6_2710900_248300 METAL6_2698900_248300 0.024
R_VDD14_2899 METAL6_2698900_248300 METAL6_2686900_248300 0.024
R_VDD14_2900 METAL6_2686900_248300 METAL6_2683200_248300 0.0074
R_VDD14_2901 METAL6_2683200_248300 METAL6_2676200_248300 0.014
R_VDD14_2902 METAL6_2676200_248300 METAL6_2664200_248300 0.024
R_VDD14_2903 METAL6_2664200_248300 METAL6_2660600_248300 0.0072
R_VDD14_2904 METAL6_2660600_248300 METAL6_2652200_248300 0.0168
R_VDD14_2905 METAL6_2652200_248300 METAL6_2646600_248300 0.0112
R_VDD14_2906 METAL6_2646600_248300 METAL6_2604400_248300 0.0844
R_VDD14_2907 METAL6_2604400_248300 METAL6_2592400_248300 0.024
R_VDD14_2908 METAL6_2592400_248300 METAL6_2580400_248300 0.024
R_VDD14_2909 METAL6_2580400_248300 METAL6_2568400_248300 0.024
R_VDD14_2910 METAL6_2568400_248300 METAL6_2565900_248300 0.005
R_VDD14_2911 METAL6_2565900_248300 METAL6_2556400_248300 0.019
R_VDD14_2912 METAL6_2556400_248300 METAL6_2551900_248300 0.009
R_VDD14_2913 METAL6_2551900_248300 METAL6_2548000_248300 0.0078
R_VDD14_2914 METAL6_2548000_248300 METAL6_2537600_248300 0.0208
R_VDD14_2915 METAL6_2537600_248300 METAL6_2536000_248300 0.0032
R_VDD14_2916 METAL6_2536000_248300 METAL6_2535400_248300 0.0012
R_VDD14_2917 METAL6_2535400_248300 METAL6_2529000_248300 0.0128
R_VDD14_2918 METAL6_2529000_248300 METAL6_2528400_248300 0.0012
R_VDD14_2919 METAL6_2528400_248300 METAL6_2525600_248300 0.0056
R_VDD14_2920 METAL6_2525600_248300 METAL6_2524000_248300 0.0032
R_VDD14_2921 METAL6_2524000_248300 METAL6_2517000_248300 0.014
R_VDD14_2922 METAL6_2517000_248300 METAL6_2516400_248300 0.0012
R_VDD14_2923 METAL6_2516400_248300 METAL6_2513600_248300 0.0056
R_VDD14_2924 METAL6_2513600_248300 METAL6_2512000_248300 0.0032
R_VDD14_2925 METAL6_2512000_248300 METAL6_2510900_248300 0.0022
R_VDD14_2926 METAL6_2510900_248300 METAL6_2505000_248300 0.0118
R_VDD14_2927 METAL6_2505000_248300 METAL6_2504400_248300 0.0012
R_VDD14_2928 METAL6_2504400_248300 METAL6_2501600_248300 0.0056
R_VDD14_2929 METAL6_2501600_248300 METAL6_2500000_248300 0.0032
R_VDD14_2930 METAL6_2500000_248300 METAL6_2498900_248300 0.0022
R_VDD14_2931 METAL6_2498900_248300 METAL6_2496600_248300 0.0046
R_VDD14_2932 METAL6_2496600_248300 METAL6_2493000_248300 0.0072
R_VDD14_2933 METAL6_2493000_248300 METAL6_2492400_248300 0.0012
R_VDD14_2934 METAL6_2492400_248300 METAL6_2489600_248300 0.0056
R_VDD14_2935 METAL6_2489600_248300 METAL6_2488000_248300 0.0032
R_VDD14_2936 METAL6_2488000_248300 METAL6_2486900_248300 0.0022
R_VDD14_2937 METAL6_2486900_248300 METAL6_2484600_248300 0.0046
R_VDD14_2938 METAL6_2484600_248300 METAL6_2481000_248300 0.0072
R_VDD14_2939 METAL6_2481000_248300 METAL6_2480400_248300 0.0012
R_VDD14_2940 METAL6_2480400_248300 METAL6_2477600_248300 0.0056
R_VDD14_2941 METAL6_2477600_248300 METAL6_2476000_248300 0.0032
R_VDD14_2942 METAL6_2476000_248300 METAL6_2472600_248300 0.0068
R_VDD14_2943 METAL6_2472600_248300 METAL6_2470600_248300 0.004
R_VDD14_2944 METAL6_2470600_248300 METAL6_2469000_248300 0.0032
R_VDD14_2945 METAL6_2469000_248300 METAL6_2468400_248300 0.0012
R_VDD14_2946 METAL6_2468400_248300 METAL6_2465600_248300 0.0056
R_VDD14_2947 METAL6_2465600_248300 METAL6_2464000_248300 0.0032
R_VDD14_2948 METAL6_2464000_248300 METAL6_2460600_248300 0.0068
R_VDD14_2949 METAL6_2460600_248300 METAL6_2458600_248300 0.004
R_VDD14_2950 METAL6_2458600_248300 METAL6_2457000_248300 0.0032
R_VDD14_2951 METAL6_2457000_248300 METAL6_2448600_248300 0.0168
R_VDD14_2952 METAL6_2448600_248300 METAL6_2446600_248300 0.004
R_VDD14_2953 METAL6_2446600_248300 METAL6_2436600_248300 0.02
R_VDD14_2954 METAL6_2436600_248300 METAL6_2434600_248300 0.004
R_VDD14_2955 METAL6_2434600_248300 METAL6_2424600_248300 0.02
R_VDD14_2956 METAL6_2424600_248300 METAL6_2422600_248300 0.004
R_VDD14_2957 METAL6_2422600_248300 METAL6_2419100_248300 0.007
R_VDD14_2958 METAL6_2419100_248300 METAL6_2407100_248300 0.024
R_VDD14_2959 METAL6_2407100_248300 METAL6_2405600_248300 0.003
R_VDD14_2960 METAL6_2405600_248300 METAL6_2402100_248300 0.007
R_VDD14_2961 METAL6_2402100_248300 METAL6_2395100_248300 0.014
R_VDD14_2962 METAL6_2395100_248300 METAL6_2393600_248300 0.003
R_VDD14_2963 METAL6_2393600_248300 METAL6_2383100_248300 0.021
R_VDD14_2964 METAL6_2383100_248300 METAL6_2381600_248300 0.003
R_VDD14_2965 METAL6_2381600_248300 METAL6_2371100_248300 0.021
R_VDD14_2966 METAL6_2371100_248300 METAL6_2369600_248300 0.003
R_VDD14_2967 METAL6_2369600_248300 METAL6_2365900_248300 0.0074
R_VDD14_2968 METAL6_2365900_248300 METAL6_2357600_248300 0.0166
R_VDD14_2969 METAL6_2357600_248300 METAL6_2351900_248300 0.0114
R_VDD14_2970 METAL6_2351900_248300 METAL6_2343700_248300 0.0164
R_VDD14_2971 METAL6_2343700_248300 METAL6_2322900_248300 0.0416
R_VDD14_2972 METAL6_2322900_248300 METAL6_2320600_248300 0.0046
R_VDD14_2973 METAL6_2320600_248300 METAL6_2310900_248300 0.0194
R_VDD14_2974 METAL6_2310900_248300 METAL6_2308600_248300 0.0046
R_VDD14_2975 METAL6_2308600_248300 METAL6_2298900_248300 0.0194
R_VDD14_2976 METAL6_2298900_248300 METAL6_2296600_248300 0.0046
R_VDD14_2977 METAL6_2296600_248300 METAL6_2286900_248300 0.0194
R_VDD14_2978 METAL6_2286900_248300 METAL6_2286900_251000 0.0054
R_VDD14_2979 METAL6_2286900_251000 METAL6_2286900_260300 0.0186
R_VDD14_2980 METAL6_2286900_260300 METAL6_2284600_260300 0.0046
R_VDD14_2981 METAL6_2284600_260300 METAL6_2284400_260300 0.0004
R_VDD14_2982 METAL6_2284400_260300 METAL6_2274900_260300 0.019
R_VDD14_2983 METAL6_2274900_260300 METAL6_2272600_260300 0.0046
R_VDD14_2984 METAL6_2272600_260300 METAL6_2272400_260300 0.0004
R_VDD14_2985 METAL6_2272400_260300 METAL6_2260600_260300 0.0236
R_VDD14_2986 METAL6_2260600_260300 METAL6_2260400_260300 0.0004
R_VDD14_2987 METAL6_2260400_260300 METAL6_2258600_260300 0.0036
R_VDD14_2988 METAL6_2258600_260300 METAL6_2248700_260300 0.0198
R_VDD14_2989 METAL6_2248700_260300 METAL6_2248600_260300 0.0002
R_VDD14_2990 METAL6_2248600_260300 METAL6_2248400_260300 0.0004
R_VDD14_2991 METAL6_2248400_260300 METAL6_2246600_260300 0.0036
R_VDD14_2992 METAL6_2246600_260300 METAL6_2236700_260300 0.0198
R_VDD14_2993 METAL6_2236700_260300 METAL6_2236600_260300 0.0002
R_VDD14_2994 METAL6_2236600_260300 METAL6_2234600_260300 0.004
R_VDD14_2995 METAL6_2234600_260300 METAL6_2233900_260300 0.0014
R_VDD14_2996 METAL6_2233900_260300 METAL6_2224700_260300 0.0184
R_VDD14_2997 METAL6_2224700_260300 METAL6_2224600_260300 0.0002
R_VDD14_2998 METAL6_2224600_260300 METAL6_2222600_260300 0.004
R_VDD14_2999 METAL6_2222600_260300 METAL6_2221900_260300 0.0014
R_VDD14_3000 METAL6_2221900_260300 METAL6_2212700_260300 0.0184
R_VDD14_3001 METAL6_2212700_260300 METAL6_2210600_260300 0.0042
R_VDD14_3002 METAL6_2210600_260300 METAL6_2209900_260300 0.0014
R_VDD14_3003 METAL6_2209900_260300 METAL6_2200700_260300 0.0184
R_VDD14_3004 METAL6_2200700_260300 METAL6_2189900_260300 0.0216
R_VDD14_3005 METAL6_2189900_260300 METAL6_2188700_260300 0.0024
R_VDD14_3006 METAL6_2188700_260300 METAL6_2177900_260300 0.0216
R_VDD14_3007 METAL6_2177900_260300 METAL6_2176700_260300 0.0024
R_VDD14_3008 METAL6_2176700_260300 METAL6_2165900_260300 0.0216
R_VDD14_3009 METAL6_2165900_260300 METAL6_2165400_260300 0.001
R_VDD14_3010 METAL6_2165400_260300 METAL6_2153900_260300 0.023
R_VDD14_3011 METAL6_2153900_260300 METAL6_2153400_260300 0.001
R_VDD14_3012 METAL6_2153400_260300 METAL6_2151900_260300 0.003
R_VDD14_3013 METAL6_2151900_260300 METAL6_2141900_260300 0.02
R_VDD14_3014 METAL6_2141900_260300 METAL6_2141400_260300 0.001
R_VDD14_3015 METAL6_2141400_260300 METAL6_2129900_260300 0.023
R_VDD14_3016 METAL6_2129900_260300 METAL6_2129700_260300 0.0004
R_VDD14_3017 METAL6_2129700_260300 METAL6_2125600_260300 0.0082
R_VDD14_3018 METAL6_2125600_260300 METAL6_2121400_260300 0.0084
R_VDD14_3019 METAL6_2121400_260300 METAL6_2117900_260300 0.007
R_VDD14_3020 METAL6_2117900_260300 METAL6_2113900_260300 0.008
R_VDD14_3021 METAL6_2113900_260300 METAL6_2113600_260300 0.0006
R_VDD14_3022 METAL6_2113600_260300 METAL6_2105900_260300 0.0154
R_VDD14_3023 METAL6_2105900_260300 METAL6_2101900_260300 0.008
R_VDD14_3024 METAL6_2101900_260300 METAL6_2101600_260300 0.0006
R_VDD14_3025 METAL6_2101600_260300 METAL6_2089900_260300 0.0234
R_VDD14_3026 METAL6_2089900_260300 METAL6_2079700_260300 0.0204
R_VDD14_3027 METAL6_2079700_260300 METAL6_2077900_260300 0.0036
R_VDD14_3028 METAL6_2077900_260300 METAL6_2067700_260300 0.0204
R_VDD14_3029 METAL6_2067700_260300 METAL6_2060600_260300 0.0142
R_VDD14_3030 METAL6_2060600_260300 METAL6_2058800_260300 0.0036
R_VDD14_3031 METAL6_2058800_260300 METAL6_2055700_260300 0.0062
R_VDD14_3032 METAL6_2055700_260300 METAL6_2046800_260300 0.0178
R_VDD14_3033 METAL6_2046800_260300 METAL6_2046600_260300 0.0004
R_VDD14_3034 METAL6_2046600_260300 METAL6_2046400_260300 0.0004
R_VDD14_3035 METAL6_2046400_260300 METAL6_2043700_260300 0.0054
R_VDD14_3036 METAL6_2043700_260300 METAL6_2034800_260300 0.0178
R_VDD14_3037 METAL6_2034800_260300 METAL6_2031700_260300 0.0062
R_VDD14_3038 METAL6_2031700_260300 METAL6_2030900_260300 0.0016
R_VDD14_3039 METAL6_2030900_260300 METAL6_2026400_260300 0.009
R_VDD14_3040 METAL6_2026400_260300 METAL6_2021200_260300 0.0104
R_VDD14_3041 METAL6_2021200_260300 METAL6_2019700_260300 0.003
R_VDD14_3042 METAL6_2019700_260300 METAL6_2018900_260300 0.0016
R_VDD14_3043 METAL6_2018900_260300 METAL6_2014400_260300 0.009
R_VDD14_3044 METAL6_2014400_260300 METAL6_2012000_260300 0.0048
R_VDD14_3045 METAL6_2012000_260300 METAL6_2007700_260300 0.0086
R_VDD14_3046 METAL6_2007700_260300 METAL6_2006900_260300 0.0016
R_VDD14_3047 METAL6_2006900_260300 METAL6_2002400_260300 0.009
R_VDD14_3048 METAL6_2002400_260300 METAL6_2000000_260300 0.0048
R_VDD14_3049 METAL6_2000000_260300 METAL6_1988000_260300 0.024
R_VDD14_3050 METAL6_1988000_260300 METAL6_1963900_260300 0.0482
R_VDD14_3051 METAL6_1963900_260300 METAL6_1963800_260300 0.0002
R_VDD14_3052 METAL6_1963800_260300 METAL6_1951900_260300 0.0238
R_VDD14_3053 METAL6_1951900_260300 METAL6_1951900_263000 0.0054
R_VDD14_3054 METAL6_1951900_263000 METAL6_1951900_272300 0.0186
R_VDD14_3055 METAL6_1951900_272300 METAL6_1951900_275000 0.0054
R_VDD14_3056 METAL6_1951900_275000 METAL6_1951900_279300 0.0086
R_VDD14_3057 METAL6_1951900_279300 METAL6_1951900_287000 0.0154
R_VDD14_3058 METAL6_1951900_287000 METAL6_1951900_288000 0.002
R_VDD14_3059 METAL6_1951900_288000 METAL6_1951900_299000 0.022
R_VDD14_3060 METAL6_1951900_299000 METAL6_1951900_300000 0.002
R_VDD14_3061 METAL6_1951900_300000 METAL6_1951900_311000 0.022
R_VDD14_3062 METAL6_1951900_311000 METAL6_1951900_312000 0.002
R_VDD14_3063 METAL6_1951900_312000 METAL6_1951900_355300 0.0866
R_VDD14_3064 METAL6_1951900_355300 METAL6_1951900_362300 0.014
R_VDD14_3065 METAL6_1951900_362300 METAL6_1951900_366800 0.009
R_VDD14_3066 METAL6_1951900_366800 METAL6_1951900_374300 0.015
R_VDD14_3067 METAL6_1951900_374300 METAL6_1963800_374300 0.0238
R_VDD14_3068 METAL6_1963800_374300 METAL6_1963900_374300 0.0002
R_VDD14_3069 METAL6_1963900_374300 METAL6_1988000_374300 0.0482
R_VDD14_3070 METAL6_1988000_374300 METAL6_2000000_374300 0.024
R_VDD14_3071 METAL6_2000000_374300 METAL6_2002400_374300 0.0048
R_VDD14_3072 METAL6_2002400_374300 METAL6_2006900_374300 0.009
R_VDD14_3073 METAL6_2006900_374300 METAL6_2007700_374300 0.0016
R_VDD14_3074 METAL6_2007700_374300 METAL6_2012000_374300 0.0086
R_VDD14_3075 METAL6_2012000_374300 METAL6_2014400_374300 0.0048
R_VDD14_3076 METAL6_2014400_374300 METAL6_2018900_374300 0.009
R_VDD14_3077 METAL6_2018900_362300 METAL6_2018900_374300 0.024
R_VDD14_3078 METAL6_3098900_272300 METAL6_3098900_260300 0.024
R_VDD14_3079 METAL6_3112000_248300 METAL6_3112000_251000 0.0054
R_VDD14_3080 METAL6_3112000_251000 METAL6_3112000_260300 0.0186
R_VDD14_3081 METAL6_3112000_260300 METAL6_3111200_260300 0.0016
R_VDD14_3082 METAL6_3111200_260300 METAL6_3110900_260300 0.0006
R_VDD14_3083 METAL6_3110900_260300 METAL6_3100000_260300 0.0218
R_VDD14_3084 METAL6_3100000_260300 METAL6_3099200_260300 0.0016
R_VDD14_3085 METAL6_3099200_260300 METAL6_3098900_260300 0.0006
I_VDD14_14 METAL6_2018900_362300 gnd 0.003
I_VDD14_15 METAL6_3098900_272300 gnd 0.003

V_VDD15_7 METAL5_3500000_200000 gnd 1.1
R_VDD15_3086 METAL5_3500000_200000 METAL5_3490500_200000 0.038
R_VDD15_3087 METAL5_3490500_200000 METAL6_3490500_200000 0.1
R_VDD15_3088 METAL6_3490500_200000 METAL6_3478500_200000 0.024
R_VDD15_3089 METAL6_3478500_200000 METAL6_3478500_212000 0.024
R_VDD15_3090 METAL6_3478500_212000 METAL6_3478500_248300 0.0726
R_VDD15_3091 METAL6_3478500_248300 METAL6_3478500_260300 0.024
R_VDD15_3092 METAL6_3478500_260300 METAL6_3478500_263000 0.0054
R_VDD15_3093 METAL6_3478500_263000 METAL6_3478500_272300 0.0186
R_VDD15_3094 METAL6_3478500_272300 METAL6_3478500_275000 0.0054
R_VDD15_3095 METAL6_3478500_275000 METAL6_3478500_279300 0.0086
R_VDD15_3096 METAL6_3478500_279300 METAL6_3478500_287000 0.0154
R_VDD15_3097 METAL6_3478500_287000 METAL6_3477000_287000 0.003
R_VDD15_3098 METAL6_3477000_287000 METAL6_3466500_287000 0.021
R_VDD15_3099 METAL6_3466500_287000 METAL6_3465000_287000 0.003
R_VDD15_3100 METAL6_3465000_287000 METAL6_3453000_287000 0.024
R_VDD15_3101 METAL6_3453000_287000 METAL6_3336400_287000 0.2332
R_VDD15_3102 METAL6_3336400_287000 METAL6_3324400_287000 0.024
R_VDD15_3103 METAL6_3324400_287000 METAL6_3312400_287000 0.024
R_VDD15_3104 METAL6_3312400_287000 METAL6_3312400_288000 0.002
R_VDD15_3105 METAL6_3312400_288000 METAL6_3312400_299000 0.022
R_VDD15_3106 METAL6_3312400_299000 METAL6_3312400_300000 0.002
R_VDD15_3107 METAL6_3312400_300000 METAL6_3312400_312000 0.024
R_VDD15_3108 METAL6_3312400_312000 METAL6_3312400_355300 0.0866
R_VDD15_3109 METAL6_3312400_355300 METAL6_3312400_362300 0.014
R_VDD15_3110 METAL6_3312400_362300 METAL6_3312400_374300 0.024
R_VDD15_3111 METAL6_3312400_374300 METAL6_3312400_386300 0.024
R_VDD15_3112 METAL6_3312400_386300 METAL6_3312400_388000 0.0034
R_VDD15_3113 METAL6_3312400_388000 METAL6_3312400_400000 0.024
R_VDD15_3114 METAL6_3312400_400000 METAL6_3312400_402800 0.0056
R_VDD15_3115 METAL6_3312400_402800 METAL6_3312000_402800 0.0008
R_VDD15_3116 METAL6_3312000_402800 METAL6_3305400_402800 0.0132
R_VDD15_3117 METAL6_3305400_402800 METAL6_3300400_402800 0.01
R_VDD15_3118 METAL6_3300400_402800 METAL6_3300000_402800 0.0008
R_VDD15_3119 METAL6_3300000_402800 METAL6_3288000_402800 0.024
R_VDD15_3120 METAL6_3288000_402800 METAL6_3287000_402800 0.002
R_VDD15_3121 METAL6_3287000_402800 METAL6_3275000_402800 0.024
R_VDD15_3122 METAL6_3275000_402800 METAL6_3263000_402800 0.024
R_VDD15_3123 METAL6_3263000_402800 METAL6_3260400_402800 0.0052
R_VDD15_3124 METAL6_3260400_402800 METAL6_3243500_402800 0.0338
R_VDD15_3125 METAL6_3243500_402800 METAL6_3231500_402800 0.024
R_VDD15_3126 METAL6_3231500_402800 METAL6_3219500_402800 0.024
R_VDD15_3127 METAL6_3219500_402800 METAL6_3212500_402800 0.014
R_VDD15_3128 METAL6_3212500_402800 METAL6_3212000_402800 0.001
R_VDD15_3129 METAL6_3212000_402800 METAL6_3200000_402800 0.024
R_VDD15_3130 METAL6_3200000_402800 METAL6_3188000_402800 0.024
R_VDD15_3131 METAL6_3188000_402800 METAL6_3167500_402800 0.041
R_VDD15_3132 METAL6_3167500_402800 METAL6_3167500_412000 0.0184
R_VDD15_3133 METAL6_3167500_412000 METAL6_3167500_449000 0.074
R_VDD15_3134 METAL6_3167500_449000 METAL6_3167500_453000 0.008
R_VDD15_3135 METAL6_3167500_453000 METAL6_3167500_465000 0.024
R_VDD15_3136 METAL6_3167500_465000 METAL6_3167500_477000 0.024
R_VDD15_3137 METAL6_3167500_477000 METAL6_3167500_480400 0.0068
R_VDD15_3138 METAL6_3167500_480400 METAL6_3167500_488000 0.0152
R_VDD15_3139 METAL6_3167500_488000 METAL6_3167500_495000 0.014
R_VDD15_3140 METAL6_3167500_495000 METAL6_3167500_500000 0.01
R_VDD15_3141 METAL6_3167500_500000 METAL6_3167500_504000 0.008
R_VDD15_3142 METAL6_3167500_504000 METAL6_3167500_507000 0.006
R_VDD15_3143 METAL6_3167500_507000 METAL6_3165900_507000 0.0032
R_VDD15_3144 METAL6_3165900_507000 METAL6_3112000_507000 0.1078
R_VDD15_3145 METAL6_3112000_507000 METAL6_3110900_507000 0.0022
R_VDD15_3146 METAL6_3110900_507000 METAL6_3100000_507000 0.0218
R_VDD15_3147 METAL6_3100000_507000 METAL6_3100000_507800 0.0016
R_VDD15_3148 METAL6_3100000_507800 METAL6_3100000_512000 0.0084
R_VDD15_3149 METAL6_3100000_512000 METAL6_3100000_516000 0.008
R_VDD15_3150 METAL6_3100000_516000 METAL6_3100000_519000 0.006
R_VDD15_3151 METAL6_3100000_519000 METAL6_3100000_528000 0.018
R_VDD15_3152 METAL6_3100000_528000 METAL6_3100000_535400 0.0148
R_VDD15_3153 METAL6_3100000_535400 METAL6_3100000_544200 0.0176
R_VDD15_3154 METAL6_3100000_544200 METAL6_3099200_544200 0.0016
R_VDD15_3155 METAL6_3099200_544200 METAL6_3098900_544200 0.0006
R_VDD15_3156 METAL6_3098900_544200 METAL6_3088000_544200 0.0218
R_VDD15_3157 METAL6_3088000_544200 METAL6_3087200_544200 0.0016
R_VDD15_3158 METAL6_3087200_544200 METAL6_3086900_544200 0.0006
R_VDD15_3159 METAL6_3086900_544200 METAL6_3075200_544200 0.0234
R_VDD15_3160 METAL6_3075200_544200 METAL6_3068200_544200 0.014
R_VDD15_3161 METAL6_3068200_544200 METAL6_3060600_544200 0.0152
R_VDD15_3162 METAL6_3060600_544200 METAL6_3023200_544200 0.0748
R_VDD15_3163 METAL6_3023200_544200 METAL6_3012000_544200 0.0224
R_VDD15_3164 METAL6_3012000_544200 METAL6_3006200_544200 0.0116
R_VDD15_3165 METAL6_3006200_544200 METAL6_3000000_544200 0.0124
R_VDD15_3166 METAL6_3000000_544200 METAL6_2994200_544200 0.0116
R_VDD15_3167 METAL6_2994200_544200 METAL6_2993000_544200 0.0024
R_VDD15_3168 METAL6_2993000_544200 METAL6_2988000_544200 0.01
R_VDD15_3169 METAL6_2988000_544200 METAL6_2982200_544200 0.0116
R_VDD15_3170 METAL6_2982200_544200 METAL6_2975200_544200 0.014
R_VDD15_3171 METAL6_2975200_544200 METAL6_2965900_544200 0.0186
R_VDD15_3172 METAL6_2965900_544200 METAL6_2951900_544200 0.028
R_VDD15_3173 METAL6_2951900_544200 METAL6_2930200_544200 0.0434
R_VDD15_3174 METAL6_2930200_544200 METAL6_2925600_544200 0.0092
R_VDD15_3175 METAL6_2925600_544200 METAL6_2913600_544200 0.024
R_VDD15_3176 METAL6_2913600_544200 METAL6_2910900_544200 0.0054
R_VDD15_3177 METAL6_2910900_544200 METAL6_2901600_544200 0.0186
R_VDD15_3178 METAL6_2901600_544200 METAL6_2898900_544200 0.0054
R_VDD15_3179 METAL6_2898900_544200 METAL6_2897100_544200 0.0036
R_VDD15_3180 METAL6_2897100_544200 METAL6_2886900_544200 0.0204
R_VDD15_3181 METAL6_2886900_544200 METAL6_2874800_544200 0.0242
R_VDD15_3182 METAL6_2874800_544200 METAL6_2862800_544200 0.024
R_VDD15_3183 METAL6_2862800_544200 METAL6_2860600_544200 0.0044
R_VDD15_3184 METAL6_2860600_544200 METAL6_2850800_544200 0.0196
R_VDD15_3185 METAL6_2850800_544200 METAL6_2846600_544200 0.0084
R_VDD15_3186 METAL6_2846600_544200 METAL6_2843800_544200 0.0056
R_VDD15_3187 METAL6_2843800_544200 METAL6_2812000_544200 0.0636
R_VDD15_3188 METAL6_2812000_544200 METAL6_2805600_544200 0.0128
R_VDD15_3189 METAL6_2805600_544200 METAL6_2800000_544200 0.0112
R_VDD15_3190 METAL6_2800000_544200 METAL6_2798800_544200 0.0024
R_VDD15_3191 METAL6_2798800_544200 METAL6_2793600_544200 0.0104
R_VDD15_3192 METAL6_2793600_544200 METAL6_2788000_544200 0.0112
R_VDD15_3193 METAL6_2788000_544200 METAL6_2781600_544200 0.0128
R_VDD15_3194 METAL6_2781600_544200 METAL6_2765900_544200 0.0314
R_VDD15_3195 METAL6_2765900_544200 METAL6_2751900_544200 0.028
R_VDD15_3196 METAL6_2751900_544200 METAL6_2728200_544200 0.0474
R_VDD15_3197 METAL6_2728200_544200 METAL6_2710900_544200 0.0346
R_VDD15_3198 METAL6_2710900_544200 METAL6_2698900_544200 0.024
R_VDD15_3199 METAL6_2698900_544200 METAL6_2686900_544200 0.024
R_VDD15_3200 METAL6_2686900_544200 METAL6_2683200_544200 0.0074
R_VDD15_3201 METAL6_2683200_544200 METAL6_2676200_544200 0.014
R_VDD15_3202 METAL6_2676200_544200 METAL6_2664200_544200 0.024
R_VDD15_3203 METAL6_2664200_544200 METAL6_2664200_547400 0.0064
R_VDD15_3204 METAL6_2664200_547400 METAL6_2664200_559400 0.024
R_VDD15_3205 METAL6_2664200_559400 METAL6_2664200_573000 0.0272
R_VDD15_3206 METAL6_2664200_573000 METAL6_2664200_579800 0.0136
R_VDD15_3207 METAL6_2664200_579800 METAL6_2664200_586400 0.0132
R_VDD15_3208 METAL6_2664200_586400 METAL6_2664200_588000 0.0032
R_VDD15_3209 METAL6_2664200_588000 METAL6_2664200_600000 0.024
R_VDD15_3210 METAL6_2664200_600000 METAL6_2664200_612000 0.024
R_VDD15_3211 METAL6_2664200_612000 METAL6_2664200_637800 0.0516
R_VDD15_3212 METAL6_2664200_637800 METAL6_2664200_641400 0.0072
R_VDD15_3213 METAL6_2664200_641400 METAL6_2664200_649800 0.0168
R_VDD15_3214 METAL6_2664200_649800 METAL6_2664200_653400 0.0072
R_VDD15_3215 METAL6_2664200_653400 METAL6_2664200_661800 0.0168
R_VDD15_3216 METAL6_2664200_661800 METAL6_2664200_665400 0.0072
R_VDD15_3217 METAL6_2664200_665400 METAL6_2664200_688000 0.0452
R_VDD15_3218 METAL6_2664200_688000 METAL6_2664200_700000 0.024
R_VDD15_3219 METAL6_2664200_700000 METAL6_2664200_702800 0.0056
R_VDD15_3220 METAL6_2664200_702800 METAL6_2664200_709800 0.014
R_VDD15_3221 METAL6_2664200_709800 METAL6_2664200_712000 0.0044
R_VDD15_3222 METAL6_2664200_712000 METAL6_2664200_716800 0.0096
R_VDD15_3223 METAL6_2664200_716800 METAL6_2664200_721800 0.01
R_VDD15_3224 METAL6_2664200_721800 METAL6_2664200_733800 0.024
R_VDD15_3225 METAL6_2664200_733800 METAL6_2664200_735400 0.0032
R_VDD15_3226 METAL6_2664200_735400 METAL6_2664200_758400 0.046
R_VDD15_3227 METAL6_2664200_758400 METAL6_2664200_763000 0.0092
R_VDD15_3228 METAL6_2664200_763000 METAL6_2664200_770400 0.0148
R_VDD15_3229 METAL6_2664200_770400 METAL6_2664200_772000 0.0032
R_VDD15_3230 METAL6_2664200_772000 METAL6_2664200_778400 0.0128
R_VDD15_3231 METAL6_2664200_778400 METAL6_2664200_779200 0.0016
R_VDD15_3232 METAL6_2664200_779200 METAL6_2664200_782400 0.0064
R_VDD15_3233 METAL6_2664200_782400 METAL6_2664200_784500 0.0042
R_VDD15_3234 METAL6_2664200_784500 METAL6_2664200_788000 0.007
R_VDD15_3235 METAL6_2664200_788000 METAL6_2664200_790400 0.0048
R_VDD15_3236 METAL6_2664200_790400 METAL6_2664200_791200 0.0016
R_VDD15_3237 METAL6_2664200_791200 METAL6_2664200_794400 0.0064
R_VDD15_3238 METAL6_2664200_794400 METAL6_2664200_794800 0.0008
R_VDD15_3239 METAL6_2664200_794800 METAL6_2664200_800000 0.0104
R_VDD15_3240 METAL6_2664200_800000 METAL6_2664200_802400 0.0048
R_VDD15_3241 METAL6_2676200_802400 METAL6_2664200_802400 0.024
R_VDD15_3242 METAL6_940400_1926500 METAL6_928400_1926500 0.024
R_VDD15_3243 METAL6_2664200_802400 METAL6_2660600_802400 0.0072
R_VDD15_3244 METAL6_2660600_802400 METAL6_2652200_802400 0.0168
R_VDD15_3245 METAL6_2652200_802400 METAL6_2646600_802400 0.0112
R_VDD15_3246 METAL6_2646600_802400 METAL6_2580400_802400 0.1324
R_VDD15_3247 METAL6_2580400_802400 METAL6_2580400_803200 0.0016
R_VDD15_3248 METAL6_2580400_803200 METAL6_2580400_806400 0.0064
R_VDD15_3249 METAL6_2580400_806400 METAL6_2580400_808000 0.0032
R_VDD15_3250 METAL6_2580400_808000 METAL6_2580400_812000 0.008
R_VDD15_3251 METAL6_2580400_812000 METAL6_2580400_814400 0.0048
R_VDD15_3252 METAL6_2580400_814400 METAL6_2580400_818400 0.008
R_VDD15_3253 METAL6_2580400_818400 METAL6_2580400_820000 0.0032
R_VDD15_3254 METAL6_2580400_820000 METAL6_2580400_830400 0.0208
R_VDD15_3255 METAL6_2580400_830400 METAL6_2580400_832000 0.0032
R_VDD15_3256 METAL6_2580400_832000 METAL6_2580400_839500 0.015
R_VDD15_3257 METAL6_2580400_839500 METAL6_2580400_840700 0.0024
R_VDD15_3258 METAL6_2580400_840700 METAL6_2580400_851500 0.0216
R_VDD15_3259 METAL6_2580400_851500 METAL6_2580400_858200 0.0134
R_VDD15_3260 METAL6_2580400_858200 METAL6_2580400_863500 0.0106
R_VDD15_3261 METAL6_2580400_863500 METAL6_2580400_887000 0.047
R_VDD15_3262 METAL6_2580400_887000 METAL6_2580400_888000 0.002
R_VDD15_3263 METAL6_2580400_888000 METAL6_2580400_900000 0.024
R_VDD15_3264 METAL6_2580400_900000 METAL6_2580400_900400 0.0008
R_VDD15_3265 METAL6_2580400_900400 METAL6_2580400_912000 0.0232
R_VDD15_3266 METAL6_2580400_912000 METAL6_2580400_927300 0.0306
R_VDD15_3267 METAL6_2580400_927300 METAL6_2580400_947000 0.0394
R_VDD15_3268 METAL6_2580400_947000 METAL6_2580400_959000 0.024
R_VDD15_3269 METAL6_2580400_959000 METAL6_2580400_971000 0.024
R_VDD15_3270 METAL6_2580400_971000 METAL6_2580400_976000 0.01
R_VDD15_3271 METAL6_2580400_976000 METAL6_2580400_988000 0.024
R_VDD15_3272 METAL6_2580400_988000 METAL6_2580400_995000 0.014
R_VDD15_3273 METAL6_2580400_995000 METAL6_2580400_1000000 0.01
R_VDD15_3274 METAL6_2580400_1000000 METAL6_2580400_1007000 0.014
R_VDD15_3275 METAL6_2580400_1007000 METAL6_2580400_1012000 0.01
R_VDD15_3276 METAL6_2580400_1012000 METAL6_2580400_1014000 0.004
R_VDD15_3277 METAL6_2580400_1014000 METAL6_2580400_1019000 0.01
R_VDD15_3278 METAL6_2580400_1019000 METAL6_2580400_1026000 0.014
R_VDD15_3279 METAL6_2580400_1026000 METAL6_2580400_1029800 0.0076
R_VDD15_3280 METAL6_2580400_1029800 METAL6_2580400_1031000 0.0024
R_VDD15_3281 METAL6_2580400_1031000 METAL6_2580400_1035700 0.0094
R_VDD15_3282 METAL6_2580400_1035700 METAL6_2580400_1037400 0.0034
R_VDD15_3283 METAL6_2580400_1037400 METAL6_2580400_1038000 0.0012
R_VDD15_3284 METAL6_2580400_1038000 METAL6_2580400_1041800 0.0076
R_VDD15_3285 METAL6_2580400_1041800 METAL6_2580400_1042700 0.0018
R_VDD15_3286 METAL6_2580400_1042700 METAL6_2580400_1049400 0.0134
R_VDD15_3287 METAL6_2580400_1049400 METAL6_2580400_1049800 0.0008
R_VDD15_3288 METAL6_2580400_1049800 METAL6_2580400_1053800 0.008
R_VDD15_3289 METAL6_2580400_1053800 METAL6_2580400_1054700 0.0018
R_VDD15_3290 METAL6_2580400_1054700 METAL6_2580400_1061400 0.0134
R_VDD15_3291 METAL6_2580400_1061400 METAL6_2580400_1061800 0.0008
R_VDD15_3292 METAL6_2580400_1061800 METAL6_2580400_1066700 0.0098
R_VDD15_3293 METAL6_2580400_1066700 METAL6_2580400_1073800 0.0142
R_VDD15_3294 METAL6_2580400_1073800 METAL6_2580400_1086000 0.0244
R_VDD15_3295 METAL6_2580400_1086000 METAL6_2580400_1086300 0.0006
R_VDD15_3296 METAL6_2580400_1086300 METAL6_2580400_1088000 0.0034
R_VDD15_3297 METAL6_2580400_1088000 METAL6_2580400_1096800 0.0176
R_VDD15_3298 METAL6_2580400_1096800 METAL6_2580400_1098300 0.003
R_VDD15_3299 METAL6_2580400_1098300 METAL6_2580400_1098500 0.0004
R_VDD15_3300 METAL6_2580400_1098500 METAL6_2565900_1098500 0.029
R_VDD15_3301 METAL6_2565900_1098500 METAL6_2551900_1098500 0.028
R_VDD15_3302 METAL6_2551900_1098500 METAL6_2535400_1098500 0.033
R_VDD15_3303 METAL6_2535400_1098500 METAL6_2528400_1098500 0.014
R_VDD15_3304 METAL6_2528400_1098500 METAL6_2525600_1098500 0.0056
R_VDD15_3305 METAL6_2525600_1098500 METAL6_2516400_1098500 0.0184
R_VDD15_3306 METAL6_2516400_1098500 METAL6_2513600_1098500 0.0056
R_VDD15_3307 METAL6_2513600_1098500 METAL6_2512000_1098500 0.0032
R_VDD15_3308 METAL6_2512000_1098500 METAL6_2512000_1100000 0.003
R_VDD15_3309 METAL6_2512000_1100000 METAL6_2512000_1108800 0.0176
R_VDD15_3310 METAL6_2512000_1108800 METAL6_2512000_1110300 0.003
R_VDD15_3311 METAL6_2512000_1110300 METAL6_2512000_1112000 0.0034
R_VDD15_3312 METAL6_2512000_1112000 METAL6_2512000_1120800 0.0176
R_VDD15_3313 METAL6_2512000_1120800 METAL6_2512000_1122300 0.003
R_VDD15_3314 METAL6_2512000_1122300 METAL6_2512000_1129300 0.014
R_VDD15_3315 METAL6_2512000_1129300 METAL6_2512000_1134300 0.01
R_VDD15_3316 METAL6_2512000_1134300 METAL6_2512000_1141300 0.014
R_VDD15_3317 METAL6_2512000_1141300 METAL6_2512000_1153300 0.024
R_VDD15_3318 METAL6_2512000_1153300 METAL6_2512000_1160600 0.0146
R_VDD15_3319 METAL6_2512000_1160600 METAL6_2512000_1172600 0.024
R_VDD15_3320 METAL6_2512000_1172600 METAL6_2512000_1184600 0.024
R_VDD15_3321 METAL6_2512000_1184600 METAL6_2512000_1191600 0.014
R_VDD15_3322 METAL6_2512000_1191600 METAL6_2512000_1193800 0.0044
R_VDD15_3323 METAL6_2512000_1193800 METAL6_2512000_1205700 0.0238
R_VDD15_3324 METAL6_2512000_1205700 METAL6_2510900_1205700 0.0022
R_VDD15_3325 METAL6_2510900_1205700 METAL6_2505000_1205700 0.0118
R_VDD15_3326 METAL6_2505000_1205700 METAL6_2504400_1205700 0.0012
R_VDD15_3327 METAL6_2504400_1205700 METAL6_2501600_1205700 0.0056
R_VDD15_3328 METAL6_2501600_1205700 METAL6_2500000_1205700 0.0032
R_VDD15_3329 METAL6_2500000_1205700 METAL6_2498900_1205700 0.0022
R_VDD15_3330 METAL6_2498900_1205700 METAL6_2493000_1205700 0.0118
R_VDD15_3331 METAL6_2493000_1205700 METAL6_2488000_1205700 0.01
R_VDD15_3332 METAL6_2488000_1205700 METAL6_2486900_1205700 0.0022
R_VDD15_3333 METAL6_2486900_1205700 METAL6_2481000_1205700 0.0118
R_VDD15_3334 METAL6_2481000_1205700 METAL6_2481000_1217700 0.024
R_VDD15_3335 METAL6_2481000_1217700 METAL6_2481000_1229700 0.024
R_VDD15_3336 METAL6_2481000_1229700 METAL6_2481000_1235700 0.012
R_VDD15_3337 METAL6_2481000_1235700 METAL6_2476000_1235700 0.01
R_VDD15_3338 METAL6_2476000_1235700 METAL6_2472600_1235700 0.0068
R_VDD15_3339 METAL6_2472600_1235700 METAL6_2460600_1235700 0.024
R_VDD15_3340 METAL6_2460600_1235700 METAL6_2448600_1235700 0.024
R_VDD15_3341 METAL6_2448600_1235700 METAL6_2446600_1235700 0.004
R_VDD15_3342 METAL6_2446600_1235700 METAL6_2436600_1235700 0.02
R_VDD15_3343 METAL6_2436600_1235700 METAL6_2407100_1235700 0.059
R_VDD15_3344 METAL6_2407100_1235700 METAL6_2407100_1238000 0.0046
R_VDD15_3345 METAL6_2407100_1238000 METAL6_2407100_1247700 0.0194
R_VDD15_3346 METAL6_2407100_1247700 METAL6_2407100_1250000 0.0046
R_VDD15_3347 METAL6_2407100_1250000 METAL6_2407100_1259700 0.0194
R_VDD15_3348 METAL6_2407100_1259700 METAL6_2405600_1259700 0.003
R_VDD15_3349 METAL6_2405600_1259700 METAL6_2402100_1259700 0.007
R_VDD15_3350 METAL6_2402100_1259700 METAL6_2395100_1259700 0.014
R_VDD15_3351 METAL6_2395100_1259700 METAL6_2393600_1259700 0.003
R_VDD15_3352 METAL6_2393600_1259700 METAL6_2383100_1259700 0.021
R_VDD15_3353 METAL6_2383100_1259700 METAL6_2381600_1259700 0.003
R_VDD15_3354 METAL6_2381600_1259700 METAL6_2371100_1259700 0.021
R_VDD15_3355 METAL6_2371100_1259700 METAL6_2369600_1259700 0.003
R_VDD15_3356 METAL6_2369600_1259700 METAL6_2365900_1259700 0.0074
R_VDD15_3357 METAL6_2365900_1259700 METAL6_2357600_1259700 0.0166
R_VDD15_3358 METAL6_2357600_1259700 METAL6_2351900_1259700 0.0114
R_VDD15_3359 METAL6_2351900_1259700 METAL6_2343700_1259700 0.0164
R_VDD15_3360 METAL6_2343700_1259700 METAL6_2310900_1259700 0.0656
R_VDD15_3361 METAL6_2310900_1259700 METAL6_2298900_1259700 0.024
R_VDD15_3362 METAL6_2298900_1259700 METAL6_2286900_1259700 0.024
R_VDD15_3363 METAL6_2286900_1259700 METAL6_2272600_1259700 0.0286
R_VDD15_3364 METAL6_2272600_1259700 METAL6_2272400_1259700 0.0004
R_VDD15_3365 METAL6_2272400_1259700 METAL6_2260600_1259700 0.0236
R_VDD15_3366 METAL6_2260600_1259700 METAL6_2260400_1259700 0.0004
R_VDD15_3367 METAL6_2260400_1259700 METAL6_2258600_1259700 0.0036
R_VDD15_3368 METAL6_2258600_1259700 METAL6_2248700_1259700 0.0198
R_VDD15_3369 METAL6_2248700_1259700 METAL6_2248600_1259700 0.0002
R_VDD15_3370 METAL6_2248600_1259700 METAL6_2248600_1262000 0.0046
R_VDD15_3371 METAL6_2248600_1262000 METAL6_2248600_1271700 0.0194
R_VDD15_3372 METAL6_2248600_1271700 METAL6_2248600_1273000 0.0026
R_VDD15_3373 METAL6_2248600_1273000 METAL6_2248600_1283700 0.0214
R_VDD15_3374 METAL6_2248600_1283700 METAL6_2248600_1326000 0.0846
R_VDD15_3375 METAL6_2248600_1326000 METAL6_2248400_1326000 0.0004
R_VDD15_3376 METAL6_2248400_1326000 METAL6_2246600_1326000 0.0036
R_VDD15_3377 METAL6_2246600_1326000 METAL6_2236700_1326000 0.0198
R_VDD15_3378 METAL6_2236700_1326000 METAL6_2234600_1326000 0.0042
R_VDD15_3379 METAL6_2234600_1326000 METAL6_2224700_1326000 0.0198
R_VDD15_3380 METAL6_2224700_1326000 METAL6_2222600_1326000 0.0042
R_VDD15_3381 METAL6_2222600_1326000 METAL6_2221900_1326000 0.0014
R_VDD15_3382 METAL6_2221900_1326000 METAL6_2212700_1326000 0.0184
R_VDD15_3383 METAL6_2212700_1326000 METAL6_2200700_1326000 0.024
R_VDD15_3384 METAL6_2200700_1326000 METAL6_2189900_1326000 0.0216
R_VDD15_3385 METAL6_2189900_1326000 METAL6_2188700_1326000 0.0024
R_VDD15_3386 METAL6_2188700_1326000 METAL6_2177900_1326000 0.0216
R_VDD15_3387 METAL6_2177900_1326000 METAL6_2176700_1326000 0.0024
R_VDD15_3388 METAL6_2176700_1326000 METAL6_2165900_1326000 0.0216
R_VDD15_3389 METAL6_2165900_1326000 METAL6_2165400_1326000 0.001
R_VDD15_3390 METAL6_2165400_1326000 METAL6_2153900_1326000 0.023
R_VDD15_3391 METAL6_2153900_1326000 METAL6_2153400_1326000 0.001
R_VDD15_3392 METAL6_2153400_1326000 METAL6_2151900_1326000 0.003
R_VDD15_3393 METAL6_2151900_1326000 METAL6_2141900_1326000 0.02
R_VDD15_3394 METAL6_2141900_1326000 METAL6_2141400_1326000 0.001
R_VDD15_3395 METAL6_2141400_1326000 METAL6_2129900_1326000 0.023
R_VDD15_3396 METAL6_2129900_1326000 METAL6_2129700_1326000 0.0004
R_VDD15_3397 METAL6_2129700_1326000 METAL6_2125600_1326000 0.0082
R_VDD15_3398 METAL6_2125600_1326000 METAL6_2121400_1326000 0.0084
R_VDD15_3399 METAL6_2121400_1326000 METAL6_2113600_1326000 0.0156
R_VDD15_3400 METAL6_2113600_1326000 METAL6_2101900_1326000 0.0234
R_VDD15_3401 METAL6_2101900_1326000 METAL6_2101600_1326000 0.0006
R_VDD15_3402 METAL6_2101600_1326000 METAL6_2089900_1326000 0.0234
R_VDD15_3403 METAL6_2089900_1326000 METAL6_2079700_1326000 0.0204
R_VDD15_3404 METAL6_2079700_1326000 METAL6_2077900_1326000 0.0036
R_VDD15_3405 METAL6_2077900_1326000 METAL6_2067700_1326000 0.0204
R_VDD15_3406 METAL6_2067700_1326000 METAL6_2060600_1326000 0.0142
R_VDD15_3407 METAL6_2060600_1326000 METAL6_2055700_1326000 0.0098
R_VDD15_3408 METAL6_2055700_1326000 METAL6_2046800_1326000 0.0178
R_VDD15_3409 METAL6_2046800_1326000 METAL6_2046600_1326000 0.0004
R_VDD15_3410 METAL6_2046600_1326000 METAL6_2046400_1326000 0.0004
R_VDD15_3411 METAL6_2046400_1326000 METAL6_2043700_1326000 0.0054
R_VDD15_3412 METAL6_2043700_1326000 METAL6_2031700_1326000 0.024
R_VDD15_3413 METAL6_2031700_1326000 METAL6_2030900_1326000 0.0016
R_VDD15_3414 METAL6_2030900_1326000 METAL6_2026400_1326000 0.009
R_VDD15_3415 METAL6_2026400_1326000 METAL6_2021200_1326000 0.0104
R_VDD15_3416 METAL6_2021200_1326000 METAL6_2019700_1326000 0.003
R_VDD15_3417 METAL6_2019700_1326000 METAL6_2018900_1326000 0.0016
R_VDD15_3418 METAL6_2018900_1326000 METAL6_2014400_1326000 0.009
R_VDD15_3419 METAL6_2014400_1326000 METAL6_2012000_1326000 0.0048
R_VDD15_3420 METAL6_2012000_1326000 METAL6_2006900_1326000 0.0102
R_VDD15_3421 METAL6_2006900_1326000 METAL6_2002400_1326000 0.009
R_VDD15_3422 METAL6_2002400_1326000 METAL6_2000000_1326000 0.0048
R_VDD15_3423 METAL6_2000000_1326000 METAL6_1988000_1326000 0.024
R_VDD15_3424 METAL6_1988000_1326000 METAL6_1951900_1326000 0.0722
R_VDD15_3425 METAL6_1951900_1326000 METAL6_1951800_1326000 0.0002
R_VDD15_3426 METAL6_1951800_1326000 METAL6_1939800_1326000 0.024
R_VDD15_3427 METAL6_1939800_1326000 METAL6_1927800_1326000 0.024
R_VDD15_3428 METAL6_1927800_1326000 METAL6_1926200_1326000 0.0032
R_VDD15_3429 METAL6_1926200_1326000 METAL6_1925600_1326000 0.0012
R_VDD15_3430 METAL6_1925600_1326000 METAL6_1919200_1326000 0.0128
R_VDD15_3431 METAL6_1919200_1326000 METAL5_1919200_1326000 0.1
R_VDD15_3432 METAL5_1919200_1326000 METAL5_1913600_1326000 0.0224
R_VDD15_3433 METAL5_1913600_1326000 METAL5_1907400_1326000 0.0248
R_VDD15_3434 METAL5_1907400_1326000 METAL5_1907200_1326000 0.0008
R_VDD15_3435 METAL5_1907200_1326000 METAL5_1901600_1326000 0.0224
R_VDD15_3436 METAL5_1901600_1326000 METAL5_1900700_1326000 0.0036
R_VDD15_3437 METAL5_1900700_1326000 METAL5_1895200_1326000 0.022
R_VDD15_3438 METAL5_1895200_1326000 METAL5_1888700_1326000 0.026
R_VDD15_3439 METAL5_1888700_1326000 METAL5_1877400_1326000 0.0452
R_VDD15_3440 METAL5_1877400_1326000 METAL5_1876700_1326000 0.0028
R_VDD15_3441 METAL5_1876700_1326000 METAL5_1874700_1326000 0.008
R_VDD15_3442 METAL5_1874700_1326000 METAL5_1870600_1326000 0.0164
R_VDD15_3443 METAL5_1870600_1326000 METAL5_1865400_1326000 0.0208
R_VDD15_3444 METAL5_1865400_1326000 METAL5_1864700_1326000 0.0028
R_VDD15_3445 METAL5_1864700_1326000 METAL5_1858600_1326000 0.0244
R_VDD15_3446 METAL5_1858600_1326000 METAL5_1858400_1326000 0.0008
R_VDD15_3447 METAL5_1858400_1326000 METAL5_1853400_1326000 0.02
R_VDD15_3448 METAL5_1853400_1326000 METAL5_1852700_1326000 0.0028
R_VDD15_3449 METAL5_1852700_1326000 METAL5_1846800_1326000 0.0236
R_VDD15_3450 METAL5_1846800_1326000 METAL5_1846600_1326000 0.0008
R_VDD15_3451 METAL5_1846600_1326000 METAL5_1846400_1326000 0.0008
R_VDD15_3452 METAL5_1846400_1326000 METAL5_1844800_1326000 0.0064
R_VDD15_3453 METAL5_1844800_1326000 METAL5_1834600_1326000 0.0408
R_VDD15_3454 METAL5_1834600_1326000 METAL5_1834400_1326000 0.0008
R_VDD15_3455 METAL5_1834400_1326000 METAL6_1834400_1326000 0.1
R_VDD15_3456 METAL6_1834400_1326000 METAL6_1832800_1326000 0.0032
R_VDD15_3457 METAL6_1832800_1326000 METAL6_1822600_1326000 0.0204
R_VDD15_3458 METAL6_1822600_1326000 METAL6_1820800_1326000 0.0036
R_VDD15_3459 METAL6_1820800_1326000 METAL6_1812000_1326000 0.0176
R_VDD15_3460 METAL6_1812000_1326000 METAL6_1800000_1326000 0.024
R_VDD15_3461 METAL6_1800000_1326000 METAL6_1788000_1326000 0.024
R_VDD15_3462 METAL6_1788000_1326000 METAL6_1755700_1326000 0.0646
R_VDD15_3463 METAL6_1755700_1326000 METAL6_1751800_1326000 0.0078
R_VDD15_3464 METAL6_1751800_1326000 METAL6_1751400_1326000 0.0008
R_VDD15_3465 METAL6_1751400_1326000 METAL6_1744000_1326000 0.0148
R_VDD15_3466 METAL6_1744000_1326000 METAL6_1743700_1326000 0.0006
R_VDD15_3467 METAL6_1743700_1326000 METAL6_1741800_1326000 0.0038
R_VDD15_3468 METAL6_1741800_1326000 METAL6_1739800_1326000 0.004
R_VDD15_3469 METAL6_1739800_1326000 METAL6_1731700_1326000 0.0162
R_VDD15_3470 METAL6_1731700_1326000 METAL6_1729800_1326000 0.0038
R_VDD15_3471 METAL6_1729800_1326000 METAL6_1727800_1326000 0.004
R_VDD15_3472 METAL6_1727800_1326000 METAL6_1719700_1326000 0.0162
R_VDD15_3473 METAL6_1719700_1326000 METAL6_1717800_1326000 0.0038
R_VDD15_3474 METAL6_1717800_1326000 METAL6_1710800_1326000 0.014
R_VDD15_3475 METAL6_1710800_1326000 METAL6_1707700_1326000 0.0062
R_VDD15_3476 METAL6_1707700_1326000 METAL6_1699000_1326000 0.0174
R_VDD15_3477 METAL6_1699000_1326000 METAL6_1692000_1326000 0.014
R_VDD15_3478 METAL6_1692000_1326000 METAL6_1680000_1326000 0.024
R_VDD15_3479 METAL6_1680000_1326000 METAL6_1670800_1326000 0.0184
R_VDD15_3480 METAL6_1670800_1326000 METAL6_1668000_1326000 0.0056
R_VDD15_3481 METAL6_1668000_1326000 METAL6_1658800_1326000 0.0184
R_VDD15_3482 METAL6_1658800_1326000 METAL6_1646800_1326000 0.024
R_VDD15_3483 METAL6_1646800_1326000 METAL6_1634800_1326000 0.024
R_VDD15_3484 METAL6_1634800_1326000 METAL6_1632800_1326000 0.004
R_VDD15_3485 METAL6_1632800_1326000 METAL6_1627800_1326000 0.01
R_VDD15_3486 METAL6_1627800_1326000 METAL6_1615800_1326000 0.024
R_VDD15_3487 METAL6_1615800_1326000 METAL6_1612700_1326000 0.0062
R_VDD15_3488 METAL6_1612700_1326000 METAL6_1612000_1326000 0.0014
R_VDD15_3489 METAL6_1612000_1326000 METAL6_1607900_1326000 0.0082
R_VDD15_3490 METAL6_1607900_1326000 METAL6_1603800_1326000 0.0082
R_VDD15_3491 METAL6_1603800_1326000 METAL6_1600700_1326000 0.0062
R_VDD15_3492 METAL6_1600700_1326000 METAL6_1600000_1326000 0.0014
R_VDD15_3493 METAL6_1600000_1326000 METAL6_1588700_1326000 0.0226
R_VDD15_3494 METAL6_1588700_1326000 METAL6_1588000_1326000 0.0014
R_VDD15_3495 METAL6_1588000_1326000 METAL6_1576700_1326000 0.0226
R_VDD15_3496 METAL6_1576700_1326000 METAL6_1576000_1326000 0.0014
R_VDD15_3497 METAL6_1576000_1326000 METAL6_1574700_1326000 0.0026
R_VDD15_3498 METAL6_1574700_1326000 METAL6_1557000_1326000 0.0354
R_VDD15_3499 METAL6_1557000_1326000 METAL6_1555400_1326000 0.0032
R_VDD15_3500 METAL6_1555400_1326000 METAL6_1551800_1326000 0.0072
R_VDD15_3501 METAL6_1551800_1326000 METAL6_1539800_1326000 0.024
R_VDD15_3502 METAL6_1539800_1326000 METAL6_1527800_1326000 0.024
R_VDD15_3503 METAL6_1527800_1326000 METAL6_1512000_1326000 0.0316
R_VDD15_3504 METAL6_1512000_1326000 METAL6_1510400_1326000 0.0032
R_VDD15_3505 METAL6_1510400_1326000 METAL6_1503400_1326000 0.014
R_VDD15_3506 METAL6_1503400_1326000 METAL6_1500000_1326000 0.0068
R_VDD15_3507 METAL6_1500000_1326000 METAL6_1498300_1326000 0.0034
R_VDD15_3508 METAL6_1498300_1326000 METAL6_1491400_1326000 0.0138
R_VDD15_3509 METAL6_1491400_1326000 METAL6_1488000_1326000 0.0068
R_VDD15_3510 METAL6_1488000_1326000 METAL6_1479400_1326000 0.0172
R_VDD15_3511 METAL6_1479400_1326000 METAL6_1443700_1326000 0.0714
R_VDD15_3512 METAL6_1443700_1326000 METAL6_1432800_1326000 0.0218
R_VDD15_3513 METAL6_1432800_1326000 METAL6_1431700_1326000 0.0022
R_VDD15_3514 METAL6_1431700_1326000 METAL6_1424000_1326000 0.0154
R_VDD15_3515 METAL6_1424000_1326000 METAL6_1419700_1326000 0.0086
R_VDD15_3516 METAL6_1419700_1326000 METAL6_1412000_1326000 0.0154
R_VDD15_3517 METAL6_1412000_1326000 METAL6_1400000_1326000 0.024
R_VDD15_3518 METAL6_1400000_1326000 METAL6_1388000_1326000 0.024
R_VDD15_3519 METAL6_1388000_1326000 METAL6_1337000_1326000 0.102
R_VDD15_3520 METAL6_1337000_1326000 METAL6_1325000_1326000 0.024
R_VDD15_3521 METAL6_1325000_1326000 METAL6_1324000_1326000 0.002
R_VDD15_3522 METAL6_1324000_1326000 METAL6_1323800_1326000 0.0004
R_VDD15_3523 METAL6_1323800_1326000 METAL6_1313000_1326000 0.0216
R_VDD15_3524 METAL6_1313000_1326000 METAL6_1312000_1326000 0.002
R_VDD15_3525 METAL6_1312000_1326000 METAL6_1311800_1326000 0.0004
R_VDD15_3526 METAL6_1311800_1326000 METAL6_1301000_1326000 0.0216
R_VDD15_3527 METAL6_1301000_1326000 METAL6_1300000_1326000 0.002
R_VDD15_3528 METAL6_1300000_1326000 METAL6_1299800_1326000 0.0004
R_VDD15_3529 METAL6_1299800_1326000 METAL6_1288000_1326000 0.0236
R_VDD15_3530 METAL6_1288000_1326000 METAL6_1274700_1326000 0.0266
R_VDD15_3531 METAL6_1274700_1326000 METAL6_1266800_1326000 0.0158
R_VDD15_3532 METAL6_1266800_1326000 METAL6_1259800_1326000 0.014
R_VDD15_3533 METAL6_1259800_1326000 METAL6_1258300_1326000 0.003
R_VDD15_3534 METAL6_1258300_1326000 METAL6_1253300_1326000 0.01
R_VDD15_3535 METAL6_1253300_1326000 METAL6_1247800_1326000 0.011
R_VDD15_3536 METAL6_1247800_1326000 METAL6_1246300_1326000 0.003
R_VDD15_3537 METAL6_1246300_1326000 METAL6_1235800_1326000 0.021
R_VDD15_3538 METAL6_1235800_1326000 METAL6_1234300_1326000 0.003
R_VDD15_3539 METAL6_1234300_1326000 METAL6_1230700_1326000 0.0072
R_VDD15_3540 METAL6_1230700_1326000 METAL5_1230700_1326000 0.1
R_VDD15_3541 METAL5_1230700_1326000 METAL5_1222300_1326000 0.0336
R_VDD15_3542 METAL5_1222300_1326000 METAL5_1218700_1326000 0.0144
R_VDD15_3543 METAL5_1218700_1326000 METAL5_1216400_1326000 0.0092
R_VDD15_3544 METAL5_1216400_1326000 METAL5_1212000_1326000 0.0176
R_VDD15_3545 METAL5_1212000_1326000 METAL5_1206700_1326000 0.0212
R_VDD15_3546 METAL5_1206700_1326000 METAL5_1206700_1338000 0.048
R_VDD15_3547 METAL5_1206700_1338000 METAL5_1206700_1350000 0.048
R_VDD15_3548 METAL5_1206700_1350000 METAL5_1206700_1362000 0.048
R_VDD15_3549 METAL5_1206700_1362000 METAL6_1206700_1362000 0.1
R_VDD15_3550 METAL6_1206700_1362000 METAL6_1206700_1369000 0.014
R_VDD15_3551 METAL6_1206700_1369000 METAL6_1204400_1369000 0.0046
R_VDD15_3552 METAL6_1204400_1369000 METAL6_1200000_1369000 0.0088
R_VDD15_3553 METAL6_1200000_1369000 METAL6_1192400_1369000 0.0152
R_VDD15_3554 METAL6_1192400_1369000 METAL6_1188000_1369000 0.0088
R_VDD15_3555 METAL6_1188000_1369000 METAL6_1180400_1369000 0.0152
R_VDD15_3556 METAL6_1180400_1369000 METAL6_1173700_1369000 0.0134
R_VDD15_3557 METAL6_1173700_1369000 METAL6_1166700_1369000 0.014
R_VDD15_3558 METAL6_1166700_1369000 METAL6_1154700_1369000 0.024
R_VDD15_3559 METAL6_1154700_1369000 METAL6_1142700_1369000 0.024
R_VDD15_3560 METAL6_1142700_1369000 METAL6_1137000_1369000 0.0114
R_VDD15_3561 METAL6_1137000_1369000 METAL6_1130700_1369000 0.0126
R_VDD15_3562 METAL6_1130700_1369000 METAL6_1125000_1369000 0.0114
R_VDD15_3563 METAL6_1125000_1369000 METAL6_1113000_1369000 0.024
R_VDD15_3564 METAL6_1113000_1369000 METAL6_1019000_1369000 0.188
R_VDD15_3565 METAL6_1019000_1369000 METAL6_1007000_1369000 0.024
R_VDD15_3566 METAL6_1007000_1369000 METAL6_995000_1369000 0.024
R_VDD15_3567 METAL6_995000_1369000 METAL6_988000_1369000 0.014
R_VDD15_3568 METAL6_988000_1369000 METAL6_947400_1369000 0.0812
R_VDD15_3569 METAL6_947400_1369000 METAL6_940400_1369000 0.014
R_VDD15_3570 METAL6_940400_1369000 METAL6_928400_1369000 0.024
R_VDD15_3571 METAL6_928400_1369000 METAL6_916400_1369000 0.024
R_VDD15_3572 METAL6_916400_1369000 METAL6_904400_1369000 0.024
R_VDD15_3573 METAL6_904400_1369000 METAL6_904400_1374000 0.01
R_VDD15_3574 METAL6_904400_1374000 METAL6_904400_1381000 0.014
R_VDD15_3575 METAL6_904400_1381000 METAL6_904400_1386600 0.0112
R_VDD15_3576 METAL6_904400_1386600 METAL6_904400_1393000 0.0128
R_VDD15_3577 METAL6_904400_1393000 METAL6_904400_1405000 0.024
R_VDD15_3578 METAL6_904400_1405000 METAL6_904400_1437700 0.0654
R_VDD15_3579 METAL6_904400_1437700 METAL6_904400_1449700 0.024
R_VDD15_3580 METAL6_904400_1449700 METAL6_904400_1461700 0.024
R_VDD15_3581 METAL6_904400_1461700 METAL6_904400_1492300 0.0612
R_VDD15_3582 METAL6_904400_1492300 METAL6_904400_1504300 0.024
R_VDD15_3583 METAL6_904400_1504300 METAL6_904400_1516300 0.024
R_VDD15_3584 METAL6_904400_1516300 METAL6_904400_1528300 0.024
R_VDD15_3585 METAL6_904400_1528300 METAL6_904400_1540300 0.024
R_VDD15_3586 METAL6_904400_1540300 METAL6_904400_1552300 0.024
R_VDD15_3587 METAL6_904400_1552300 METAL6_904400_1554500 0.0044
R_VDD15_3588 METAL6_904400_1554500 METAL6_904400_1564300 0.0196
R_VDD15_3589 METAL6_904400_1564300 METAL6_904400_1571300 0.014
R_VDD15_3590 METAL6_904400_1571300 METAL6_904400_1576300 0.01
R_VDD15_3591 METAL6_904400_1576300 METAL6_904400_1714500 0.2764
R_VDD15_3592 METAL6_904400_1714500 METAL6_904400_1720500 0.012
R_VDD15_3593 METAL6_904400_1720500 METAL6_904400_1726500 0.012
R_VDD15_3594 METAL6_904400_1726500 METAL6_904400_1731700 0.0104
R_VDD15_3595 METAL6_904400_1731700 METAL6_904400_1738500 0.0136
R_VDD15_3596 METAL6_904400_1738500 METAL6_904400_1750500 0.024
R_VDD15_3597 METAL6_904400_1750500 METAL6_904400_1762500 0.024
R_VDD15_3598 METAL6_904400_1762500 METAL6_904400_1774500 0.024
R_VDD15_3599 METAL6_904400_1774500 METAL6_904400_1802500 0.056
R_VDD15_3600 METAL6_904400_1802500 METAL6_904400_1814500 0.024
R_VDD15_3601 METAL6_904400_1814500 METAL6_904400_1826500 0.024
R_VDD15_3602 METAL6_904400_1826500 METAL6_904400_1838500 0.024
R_VDD15_3603 METAL6_904400_1838500 METAL6_904400_1852300 0.0276
R_VDD15_3604 METAL6_904400_1852300 METAL6_904400_1866300 0.028
R_VDD15_3605 METAL6_904400_1866300 METAL6_904400_1914500 0.0964
R_VDD15_3606 METAL6_904400_1914500 METAL6_916400_1914500 0.024
R_VDD15_3607 METAL6_916400_1914500 METAL6_928400_1914500 0.024
R_VDD15_3608 METAL6_928400_1914500 METAL6_928400_1926500 0.024
R_VDD15_3609 METAL6_1717800_2736000 METAL6_1729800_2736000 0.024
R_VDD15_3610 METAL6_1325000_1326000 METAL6_1325000_1338000 0.024
R_VDD15_3611 METAL6_1325000_1338000 METAL6_1325000_1350000 0.024
R_VDD15_3612 METAL6_1325000_1350000 METAL6_1325000_1357000 0.014
R_VDD15_3613 METAL6_1325000_1357000 METAL6_1325000_1362000 0.01
R_VDD15_3614 METAL6_1325000_1362000 METAL5_1325000_1362000 0.1
R_VDD15_3615 METAL5_1325000_1362000 METAL5_1324000_1362000 0.004
R_VDD15_3616 METAL5_1324000_1362000 METAL5_1323800_1362000 0.0008
R_VDD15_3617 METAL5_1323800_1362000 METAL5_1313000_1362000 0.0432
R_VDD15_3618 METAL5_1313000_1362000 METAL5_1312000_1362000 0.004
R_VDD15_3619 METAL5_1312000_1362000 METAL5_1311800_1362000 0.0008
R_VDD15_3620 METAL5_1311800_1362000 METAL5_1301000_1362000 0.0432
R_VDD15_3621 METAL5_1301000_1362000 METAL6_1301000_1362000 0.1
R_VDD15_3622 METAL6_1301000_1362000 METAL6_1301000_1369000 0.014
R_VDD15_3623 METAL6_1301000_1369000 METAL6_1301000_1374000 0.01
R_VDD15_3624 METAL6_1301000_1374000 METAL6_1301000_1381000 0.014
R_VDD15_3625 METAL6_1301000_1381000 METAL6_1301000_1386600 0.0112
R_VDD15_3626 METAL6_1301000_1386600 METAL6_1301000_1393000 0.0128
R_VDD15_3627 METAL6_1301000_1393000 METAL6_1301000_1405000 0.024
R_VDD15_3628 METAL6_1301000_1405000 METAL6_1301000_1437700 0.0654
R_VDD15_3629 METAL6_1301000_1437700 METAL6_1301000_1449700 0.024
R_VDD15_3630 METAL6_1301000_1449700 METAL6_1301000_1461700 0.024
R_VDD15_3631 METAL6_1301000_1461700 METAL6_1301000_1492300 0.0612
R_VDD15_3632 METAL6_1301000_1492300 METAL6_1301000_1504300 0.024
R_VDD15_3633 METAL6_1301000_1504300 METAL6_1301000_1516300 0.024
R_VDD15_3634 METAL6_1301000_1516300 METAL6_1301000_1528300 0.024
R_VDD15_3635 METAL6_1301000_1528300 METAL6_1301000_1540300 0.024
R_VDD15_3636 METAL6_1301000_1540300 METAL6_1301000_1552300 0.024
R_VDD15_3637 METAL6_1301000_1552300 METAL6_1300000_1552300 0.002
R_VDD15_3638 METAL6_1300000_1552300 METAL6_1299800_1552300 0.0004
R_VDD15_3639 METAL6_1299800_1552300 METAL6_1288000_1552300 0.0236
R_VDD15_3640 METAL6_1288000_1552300 METAL6_1274700_1552300 0.0266
R_VDD15_3641 METAL6_1274700_1552300 METAL6_1274700_1554500 0.0044
R_VDD15_3642 METAL6_1274700_1554500 METAL6_1274700_1564300 0.0196
R_VDD15_3643 METAL6_1274700_1564300 METAL6_1274700_1571300 0.014
R_VDD15_3644 METAL6_1274700_1571300 METAL6_1274700_1576300 0.01
R_VDD15_3645 METAL6_1274700_1576300 METAL6_1274700_1714500 0.2764
R_VDD15_3646 METAL6_1274700_1714500 METAL6_1274700_1720500 0.012
R_VDD15_3647 METAL6_1274700_1720500 METAL6_1274700_1726500 0.012
R_VDD15_3648 METAL6_1274700_1726500 METAL6_1274700_1731700 0.0104
R_VDD15_3649 METAL6_1274700_1731700 METAL6_1274700_1738500 0.0136
R_VDD15_3650 METAL6_1274700_1738500 METAL6_1274700_1750500 0.024
R_VDD15_3651 METAL6_1274700_1750500 METAL6_1274700_1762500 0.024
R_VDD15_3652 METAL6_1274700_1762500 METAL6_1274700_1774500 0.024
R_VDD15_3653 METAL6_1274700_1774500 METAL6_1274700_1802500 0.056
R_VDD15_3654 METAL6_1274700_1802500 METAL6_1274700_1814500 0.024
R_VDD15_3655 METAL6_1274700_1814500 METAL6_1274700_1826500 0.024
R_VDD15_3656 METAL6_1274700_1826500 METAL6_1274700_1838500 0.024
R_VDD15_3657 METAL6_1274700_1838500 METAL6_1274700_1852300 0.0276
R_VDD15_3658 METAL6_1274700_1852300 METAL6_1274700_1866300 0.028
R_VDD15_3659 METAL6_1274700_1866300 METAL6_1274700_1902500 0.0724
R_VDD15_3660 METAL6_1274700_1902500 METAL6_1274700_1914500 0.024
R_VDD15_3661 METAL6_1274700_1914500 METAL6_1274700_1926500 0.024
R_VDD15_3662 METAL6_1274700_1926500 METAL6_1274700_1938500 0.024
R_VDD15_3663 METAL6_1274700_1938500 METAL6_1274700_1940500 0.004
R_VDD15_3664 METAL6_1274700_1940500 METAL6_1274700_1950500 0.02
R_VDD15_3665 METAL6_1274700_1950500 METAL6_1274700_1951000 0.001
R_VDD15_3666 METAL6_1274700_1951000 METAL6_1274700_1952500 0.003
R_VDD15_3667 METAL6_1274700_1952500 METAL6_1274700_1963000 0.021
R_VDD15_3668 METAL6_1274700_1963000 METAL6_1274700_1964500 0.003
R_VDD15_3669 METAL6_1274700_1964500 METAL6_1274700_1975000 0.021
R_VDD15_3670 METAL6_1274700_1975000 METAL6_1274700_1976500 0.003
R_VDD15_3671 METAL6_1274700_1976500 METAL6_1274700_1987000 0.021
R_VDD15_3672 METAL6_1274700_1987000 METAL6_1274700_2014500 0.055
R_VDD15_3673 METAL6_1274700_2014500 METAL6_1274700_2026500 0.024
R_VDD15_3674 METAL6_1274700_2026500 METAL6_1274700_2038500 0.024
R_VDD15_3675 METAL6_1274700_2038500 METAL6_1274700_2114500 0.152
R_VDD15_3676 METAL6_1274700_2114500 METAL6_1274700_2126500 0.024
R_VDD15_3677 METAL6_1274700_2126500 METAL6_1274700_2138500 0.024
R_VDD15_3678 METAL6_1274700_2138500 METAL6_1274700_2147300 0.0176
R_VDD15_3679 METAL6_1274700_2147300 METAL6_1274700_2154300 0.014
R_VDD15_3680 METAL6_1274700_2154300 METAL6_1274700_2163000 0.0174
R_VDD15_3681 METAL6_1274700_2163000 METAL6_1274700_2166300 0.0066
R_VDD15_3682 METAL6_1274700_2166300 METAL6_1288000_2166300 0.0266
R_VDD15_3683 METAL6_1288000_2166300 METAL6_1299800_2166300 0.0236
R_VDD15_3684 METAL6_1299800_2166300 METAL6_1299800_2175000 0.0174
R_VDD15_3685 METAL6_1299800_2175000 METAL6_1299800_2178300 0.0066
R_VDD15_3686 METAL6_1299800_2178300 METAL6_1299800_2187000 0.0174
R_VDD15_3687 METAL6_1299800_2187000 METAL6_1299800_2190300 0.0066
R_VDD15_3688 METAL6_1299800_2190300 METAL6_1299800_2222500 0.0644
R_VDD15_3689 METAL6_1299800_2222500 METAL6_1299800_2234500 0.024
R_VDD15_3690 METAL6_1299800_2234500 METAL6_1299800_2246500 0.024
R_VDD15_3691 METAL6_1299800_2246500 METAL6_1299800_2268500 0.044
R_VDD15_3692 METAL6_1299800_2268500 METAL6_1299800_2288000 0.039
R_VDD15_3693 METAL6_1299800_2288000 METAL6_1299800_2300000 0.024
R_VDD15_3694 METAL6_1299800_2300000 METAL6_1299800_2312000 0.024
R_VDD15_3695 METAL6_1299800_2312000 METAL6_1299800_2338000 0.052
R_VDD15_3696 METAL6_1299800_2338000 METAL6_1299800_2350000 0.024
R_VDD15_3697 METAL6_1299800_2350000 METAL6_1299800_2362000 0.024
R_VDD15_3698 METAL6_1299800_2362000 METAL6_1299800_2364000 0.004
R_VDD15_3699 METAL6_1299800_2364000 METAL6_1299800_2365000 0.002
R_VDD15_3700 METAL6_1299800_2365000 METAL6_1300000_2365000 0.0004
R_VDD15_3701 METAL6_1300000_2365000 METAL6_1301000_2365000 0.002
R_VDD15_3702 METAL6_1301000_2365000 METAL6_1311800_2365000 0.0216
R_VDD15_3703 METAL6_1311800_2365000 METAL6_1312000_2365000 0.0004
R_VDD15_3704 METAL6_1312000_2365000 METAL6_1313000_2365000 0.002
R_VDD15_3705 METAL6_1313000_2365000 METAL6_1323800_2365000 0.0216
R_VDD15_3706 METAL6_1323800_2365000 METAL6_1324000_2365000 0.0004
R_VDD15_3707 METAL6_1324000_2365000 METAL6_1325000_2365000 0.002
R_VDD15_3708 METAL6_1325000_2365000 METAL6_1337000_2365000 0.024
R_VDD15_3709 METAL6_1337000_2365000 METAL6_1388000_2365000 0.102
R_VDD15_3710 METAL6_1388000_2365000 METAL6_1400000_2365000 0.024
R_VDD15_3711 METAL6_1400000_2365000 METAL6_1412000_2365000 0.024
R_VDD15_3712 METAL6_1412000_2365000 METAL6_1419700_2365000 0.0154
R_VDD15_3713 METAL6_1419700_2365000 METAL6_1424000_2365000 0.0086
R_VDD15_3714 METAL6_1424000_2365000 METAL6_1431700_2365000 0.0154
R_VDD15_3715 METAL6_1431700_2365000 METAL6_1432800_2365000 0.0022
R_VDD15_3716 METAL6_1432800_2365000 METAL6_1443700_2365000 0.0218
R_VDD15_3717 METAL6_1443700_2365000 METAL6_1479400_2365000 0.0714
R_VDD15_3718 METAL6_1479400_2365000 METAL6_1488000_2365000 0.0172
R_VDD15_3719 METAL6_1488000_2365000 METAL6_1491400_2365000 0.0068
R_VDD15_3720 METAL6_1491400_2365000 METAL6_1498300_2365000 0.0138
R_VDD15_3721 METAL6_1498300_2365000 METAL6_1500000_2365000 0.0034
R_VDD15_3722 METAL6_1500000_2365000 METAL6_1503400_2365000 0.0068
R_VDD15_3723 METAL6_1503400_2365000 METAL6_1510400_2365000 0.014
R_VDD15_3724 METAL6_1510400_2365000 METAL6_1512000_2365000 0.0032
R_VDD15_3725 METAL6_1512000_2365000 METAL6_1527800_2365000 0.0316
R_VDD15_3726 METAL6_1527800_2365000 METAL6_1539800_2365000 0.024
R_VDD15_3727 METAL6_1539800_2365000 METAL6_1551800_2365000 0.024
R_VDD15_3728 METAL6_1551800_2365000 METAL6_1555400_2365000 0.0072
R_VDD15_3729 METAL6_1555400_2365000 METAL6_1557000_2365000 0.0032
R_VDD15_3730 METAL6_1557000_2365000 METAL6_1574700_2365000 0.0354
R_VDD15_3731 METAL6_1574700_2365000 METAL6_1576000_2365000 0.0026
R_VDD15_3732 METAL6_1576000_2365000 METAL6_1576700_2365000 0.0014
R_VDD15_3733 METAL6_1576700_2365000 METAL6_1588000_2365000 0.0226
R_VDD15_3734 METAL6_1588000_2365000 METAL6_1588700_2365000 0.0014
R_VDD15_3735 METAL6_1588700_2365000 METAL6_1600000_2365000 0.0226
R_VDD15_3736 METAL6_1600000_2365000 METAL6_1600700_2365000 0.0014
R_VDD15_3737 METAL6_1600700_2365000 METAL6_1603800_2365000 0.0062
R_VDD15_3738 METAL6_1603800_2365000 METAL6_1607900_2365000 0.0082
R_VDD15_3739 METAL6_1607900_2365000 METAL6_1612000_2365000 0.0082
R_VDD15_3740 METAL6_1612000_2365000 METAL6_1612700_2365000 0.0014
R_VDD15_3741 METAL6_1612700_2365000 METAL6_1615800_2365000 0.0062
R_VDD15_3742 METAL6_1615800_2365000 METAL6_1627800_2365000 0.024
R_VDD15_3743 METAL6_1627800_2365000 METAL6_1632800_2365000 0.01
R_VDD15_3744 METAL6_1632800_2365000 METAL6_1634800_2365000 0.004
R_VDD15_3745 METAL6_1634800_2365000 METAL6_1646800_2365000 0.024
R_VDD15_3746 METAL6_1646800_2365000 METAL6_1658800_2365000 0.024
R_VDD15_3747 METAL6_1658800_2365000 METAL6_1668000_2365000 0.0184
R_VDD15_3748 METAL6_1668000_2365000 METAL6_1670800_2365000 0.0056
R_VDD15_3749 METAL6_1670800_2365000 METAL6_1680000_2365000 0.0184
R_VDD15_3750 METAL6_1680000_2365000 METAL6_1692000_2365000 0.024
R_VDD15_3751 METAL6_1692000_2365000 METAL6_1699000_2365000 0.014
R_VDD15_3752 METAL6_1699000_2365000 METAL6_1707700_2365000 0.0174
R_VDD15_3753 METAL6_1707700_2365000 METAL6_1710800_2365000 0.0062
R_VDD15_3754 METAL6_1710800_2365000 METAL6_1717800_2365000 0.014
R_VDD15_3755 METAL6_1717800_2365000 METAL6_1719700_2365000 0.0038
R_VDD15_3756 METAL6_1719700_2365000 METAL6_1727800_2365000 0.0162
R_VDD15_3757 METAL6_1727800_2365000 METAL6_1729800_2365000 0.004
R_VDD15_3758 METAL6_1729800_2365000 METAL5_1729800_2365000 0.1
R_VDD15_3759 METAL5_1729800_2365000 METAL5_1729800_2376000 0.044
R_VDD15_3760 METAL5_1729800_2376000 METAL5_1729800_2377000 0.004
R_VDD15_3761 METAL5_1729800_2377000 METAL5_1729800_2388000 0.044
R_VDD15_3762 METAL5_1729800_2388000 METAL5_1729800_2389000 0.004
R_VDD15_3763 METAL5_1729800_2389000 METAL5_1729800_2400000 0.044
R_VDD15_3764 METAL5_1729800_2400000 METAL5_1729800_2401000 0.004
R_VDD15_3765 METAL5_1729800_2401000 METAL6_1729800_2401000 0.1
R_VDD15_3766 METAL6_1729800_2401000 METAL6_1729800_2407000 0.012
R_VDD15_3767 METAL6_1729800_2407000 METAL6_1729800_2412000 0.01
R_VDD15_3768 METAL6_1729800_2412000 METAL6_1731700_2412000 0.0038
R_VDD15_3769 METAL6_1731700_2412000 METAL6_1739800_2412000 0.0162
R_VDD15_3770 METAL6_1739800_2412000 METAL6_1741800_2412000 0.004
R_VDD15_3771 METAL6_1741800_2412000 METAL6_1741800_2413000 0.002
R_VDD15_3772 METAL6_1741800_2413000 METAL6_1741800_2438000 0.05
R_VDD15_3773 METAL6_1741800_2438000 METAL6_1741800_2444000 0.012
R_VDD15_3774 METAL6_1741800_2444000 METAL6_1741800_2450000 0.012
R_VDD15_3775 METAL6_1741800_2450000 METAL6_1741800_2456000 0.012
R_VDD15_3776 METAL6_1741800_2456000 METAL6_1741800_2462000 0.012
R_VDD15_3777 METAL6_1741800_2462000 METAL6_1741800_2468000 0.012
R_VDD15_3778 METAL6_1741800_2468000 METAL6_1741800_2481000 0.026
R_VDD15_3779 METAL6_1741800_2481000 METAL6_1741800_2493000 0.024
R_VDD15_3780 METAL6_1741800_2493000 METAL6_1741800_2505000 0.024
R_VDD15_3781 METAL6_1741800_2505000 METAL6_1741800_2512000 0.014
R_VDD15_3782 METAL6_1741800_2512000 METAL6_1741800_2524000 0.024
R_VDD15_3783 METAL6_1741800_2524000 METAL6_1741800_2529700 0.0114
R_VDD15_3784 METAL6_1741800_2529700 METAL6_1741800_2536000 0.0126
R_VDD15_3785 METAL6_1741800_2536000 METAL6_1741800_2541700 0.0114
R_VDD15_3786 METAL6_1741800_2541700 METAL6_1741800_2548000 0.0126
R_VDD15_3787 METAL6_1741800_2548000 METAL6_1741800_2553700 0.0114
R_VDD15_3788 METAL6_1741800_2553700 METAL6_1741800_2589000 0.0706
R_VDD15_3789 METAL6_1741800_2589000 METAL6_1741800_2603000 0.028
R_VDD15_3790 METAL6_1741800_2603000 METAL6_1741800_2644000 0.082
R_VDD15_3791 METAL6_1741800_2644000 METAL6_1741800_2656000 0.024
R_VDD15_3792 METAL6_1741800_2656000 METAL6_1741800_2665700 0.0194
R_VDD15_3793 METAL6_1741800_2665700 METAL6_1741800_2668000 0.0046
R_VDD15_3794 METAL6_1741800_2668000 METAL6_1741800_2701700 0.0674
R_VDD15_3795 METAL6_1741800_2701700 METAL6_1741800_2713000 0.0226
R_VDD15_3796 METAL6_1741800_2713000 METAL6_1739800_2713000 0.004
R_VDD15_3797 METAL6_1739800_2713000 METAL6_1731700_2713000 0.0162
R_VDD15_3798 METAL6_1731700_2713000 METAL6_1729800_2713000 0.0038
R_VDD15_3799 METAL6_1729800_2713000 METAL6_1729800_2713700 0.0014
R_VDD15_3800 METAL6_1729800_2713700 METAL6_1729800_2724000 0.0206
R_VDD15_3801 METAL6_1729800_2724000 METAL6_1729800_2725000 0.002
R_VDD15_3802 METAL6_1729800_2725000 METAL6_1729800_2725700 0.0014
R_VDD15_3803 METAL6_1729800_2725700 METAL6_1729800_2736000 0.0206
R_VDD15_3804 METAL6_1853400_2736000 METAL6_1865400_2736000 0.024
R_VDD15_3805 METAL6_3167500_449000 METAL6_3165900_449000 0.0032
R_VDD15_3806 METAL6_3165900_449000 METAL6_3155500_449000 0.0208
R_VDD15_3807 METAL6_3155500_449000 METAL6_3112000_449000 0.087
R_VDD15_3808 METAL6_3112000_449000 METAL6_3112000_453000 0.008
R_VDD15_3809 METAL6_3112000_453000 METAL6_3112000_465000 0.024
R_VDD15_3810 METAL6_3112000_465000 METAL6_3112000_477000 0.024
R_VDD15_3811 METAL6_3112000_477000 METAL6_3112000_480400 0.0068
R_VDD15_3812 METAL6_3112000_480400 METAL6_3112000_488000 0.0152
R_VDD15_3813 METAL6_3112000_488000 METAL6_3112000_495000 0.014
R_VDD15_3814 METAL6_3112000_495000 METAL6_3110900_495000 0.0022
R_VDD15_3815 METAL6_3110900_495000 METAL6_3100000_495000 0.0218
R_VDD15_3816 METAL6_3100000_495000 METAL6_3099200_495000 0.0016
R_VDD15_3817 METAL6_3099200_495000 METAL6_3098900_495000 0.0006
R_VDD15_3818 METAL6_3098900_495000 METAL6_3088000_495000 0.0218
R_VDD15_3819 METAL6_3088000_495000 METAL6_3088000_500000 0.01
R_VDD15_3820 METAL6_3088000_500000 METAL6_3088000_504000 0.008
R_VDD15_3821 METAL6_3088000_504000 METAL6_3088000_507000 0.006
R_VDD15_3822 METAL6_3088000_507000 METAL6_3087200_507000 0.0016
R_VDD15_3823 METAL6_3087200_507000 METAL6_3087200_507800 0.0016
R_VDD15_3824 METAL6_3087200_507800 METAL6_3087200_512000 0.0084
R_VDD15_3825 METAL6_3087200_512000 METAL6_3087200_516000 0.008
R_VDD15_3826 METAL6_3087200_516000 METAL6_3087200_519000 0.006
R_VDD15_3827 METAL6_3087200_519000 METAL6_3087200_528000 0.018
R_VDD15_3828 METAL6_3087200_528000 METAL6_3087200_532200 0.0084
R_VDD15_3829 METAL6_3087200_532200 METAL6_3086900_532200 0.0006
R_VDD15_3830 METAL6_3086900_532200 METAL6_3075200_532200 0.0234
R_VDD15_3831 METAL6_3075200_532200 METAL6_3068200_532200 0.014
R_VDD15_3832 METAL6_3068200_532200 METAL6_3060600_532200 0.0152
R_VDD15_3833 METAL6_3060600_532200 METAL6_3023200_532200 0.0748
R_VDD15_3834 METAL6_3023200_532200 METAL6_3012000_532200 0.0224
R_VDD15_3835 METAL6_3012000_532200 METAL6_3006200_532200 0.0116
R_VDD15_3836 METAL6_3006200_532200 METAL6_3000000_532200 0.0124
R_VDD15_3837 METAL6_3000000_532200 METAL6_2994200_532200 0.0116
R_VDD15_3838 METAL6_2994200_532200 METAL6_2993000_532200 0.0024
R_VDD15_3839 METAL6_2993000_532200 METAL6_2988000_532200 0.01
R_VDD15_3840 METAL6_2988000_532200 METAL6_2982200_532200 0.0116
R_VDD15_3841 METAL6_2982200_532200 METAL6_2975200_532200 0.014
R_VDD15_3842 METAL6_2975200_532200 METAL6_2965900_532200 0.0186
R_VDD15_3843 METAL6_2965900_532200 METAL6_2951900_532200 0.028
R_VDD15_3844 METAL6_2951900_532200 METAL6_2930200_532200 0.0434
R_VDD15_3845 METAL6_2930200_532200 METAL6_2925600_532200 0.0092
R_VDD15_3846 METAL6_2925600_532200 METAL6_2913600_532200 0.024
R_VDD15_3847 METAL6_2913600_532200 METAL6_2910900_532200 0.0054
R_VDD15_3848 METAL6_2910900_532200 METAL6_2901600_532200 0.0186
R_VDD15_3849 METAL6_2901600_532200 METAL6_2898900_532200 0.0054
R_VDD15_3850 METAL6_2898900_532200 METAL6_2897100_532200 0.0036
R_VDD15_3851 METAL6_2897100_532200 METAL6_2886900_532200 0.0204
R_VDD15_3852 METAL6_2886900_532200 METAL6_2874800_532200 0.0242
R_VDD15_3853 METAL6_2874800_532200 METAL6_2862800_532200 0.024
R_VDD15_3854 METAL6_2862800_532200 METAL6_2860600_532200 0.0044
R_VDD15_3855 METAL6_2860600_532200 METAL6_2850800_532200 0.0196
R_VDD15_3856 METAL6_2850800_532200 METAL6_2846600_532200 0.0084
R_VDD15_3857 METAL6_2846600_532200 METAL6_2843800_532200 0.0056
R_VDD15_3858 METAL6_2843800_532200 METAL6_2812000_532200 0.0636
R_VDD15_3859 METAL6_2812000_532200 METAL6_2805600_532200 0.0128
R_VDD15_3860 METAL6_2805600_532200 METAL6_2800000_532200 0.0112
R_VDD15_3861 METAL6_2800000_532200 METAL6_2798800_532200 0.0024
R_VDD15_3862 METAL6_2798800_532200 METAL6_2793600_532200 0.0104
R_VDD15_3863 METAL6_2793600_532200 METAL6_2788000_532200 0.0112
R_VDD15_3864 METAL6_2788000_532200 METAL6_2781600_532200 0.0128
R_VDD15_3865 METAL6_2781600_532200 METAL6_2765900_532200 0.0314
R_VDD15_3866 METAL6_2765900_532200 METAL6_2751900_532200 0.028
R_VDD15_3867 METAL6_2751900_532200 METAL6_2728200_532200 0.0474
R_VDD15_3868 METAL6_2728200_532200 METAL6_2710900_532200 0.0346
R_VDD15_3869 METAL6_2710900_532200 METAL6_2698900_532200 0.024
R_VDD15_3870 METAL6_2698900_532200 METAL6_2686900_532200 0.024
R_VDD15_3871 METAL6_2686900_532200 METAL6_2683200_532200 0.0074
R_VDD15_3872 METAL6_2683200_532200 METAL6_2676200_532200 0.014
R_VDD15_3873 METAL6_2676200_532200 METAL6_2664200_532200 0.024
R_VDD15_3874 METAL6_2664200_532200 METAL6_2660600_532200 0.0072
R_VDD15_3875 METAL6_2660600_532200 METAL6_2652200_532200 0.0168
R_VDD15_3876 METAL6_2652200_532200 METAL6_2646600_532200 0.0112
R_VDD15_3877 METAL6_2646600_532200 METAL6_2592400_532200 0.1084
R_VDD15_3878 METAL6_2592400_532200 METAL6_2580400_532200 0.024
R_VDD15_3879 METAL6_2580400_532200 METAL6_2568400_532200 0.024
R_VDD15_3880 METAL6_2568400_532200 METAL6_2568400_535400 0.0064
R_VDD15_3881 METAL6_2568400_535400 METAL6_2568400_544200 0.0176
R_VDD15_3882 METAL6_2568400_544200 METAL6_2568400_547400 0.0064
R_VDD15_3883 METAL6_2568400_547400 METAL6_2568400_556200 0.0176
R_VDD15_3884 METAL6_2568400_556200 METAL6_2568400_559400 0.0064
R_VDD15_3885 METAL6_2568400_559400 METAL6_2568400_573000 0.0272
R_VDD15_3886 METAL6_2568400_573000 METAL6_2568400_579800 0.0136
R_VDD15_3887 METAL6_2568400_579800 METAL6_2568400_586400 0.0132
R_VDD15_3888 METAL6_2568400_586400 METAL6_2565900_586400 0.005
R_VDD15_3889 METAL6_2565900_586400 METAL6_2551900_586400 0.028
R_VDD15_3890 METAL6_2551900_586400 METAL6_2535400_586400 0.033
R_VDD15_3891 METAL6_2535400_586400 METAL6_2528400_586400 0.014
R_VDD15_3892 METAL6_2528400_586400 METAL6_2525600_586400 0.0056
R_VDD15_3893 METAL6_2525600_586400 METAL6_2525600_588000 0.0032
R_VDD15_3894 METAL6_2525600_588000 METAL6_2525600_600000 0.024
R_VDD15_3895 METAL6_2525600_600000 METAL6_2525600_612000 0.024
R_VDD15_3896 METAL6_2525600_612000 METAL6_2525600_637800 0.0516
R_VDD15_3897 METAL6_2525600_637800 METAL6_2525600_641400 0.0072
R_VDD15_3898 METAL6_2525600_641400 METAL6_2525600_649800 0.0168
R_VDD15_3899 METAL6_2525600_649800 METAL6_2525600_653400 0.0072
R_VDD15_3900 METAL6_2525600_653400 METAL6_2525600_661800 0.0168
R_VDD15_3901 METAL6_2525600_661800 METAL6_2525600_665400 0.0072
R_VDD15_3902 METAL6_2525600_665400 METAL6_2525600_688000 0.0452
R_VDD15_3903 METAL6_2525600_688000 METAL6_2525600_700000 0.024
R_VDD15_3904 METAL6_2525600_700000 METAL6_2525600_702800 0.0056
R_VDD15_3905 METAL6_2525600_702800 METAL6_2525600_709800 0.014
R_VDD15_3906 METAL6_2525600_709800 METAL6_2525600_712000 0.0044
R_VDD15_3907 METAL6_2525600_712000 METAL6_2525600_716800 0.0096
R_VDD15_3908 METAL6_2525600_716800 METAL6_2525600_721800 0.01
R_VDD15_3909 METAL6_2525600_721800 METAL6_2525600_733800 0.024
R_VDD15_3910 METAL6_2525600_733800 METAL6_2524000_733800 0.0032
R_VDD15_3911 METAL6_2524000_733800 METAL6_2516400_733800 0.0152
R_VDD15_3912 METAL6_2516400_733800 METAL6_2513600_733800 0.0056
R_VDD15_3913 METAL6_2513600_733800 METAL6_2513600_735400 0.0032
R_VDD15_3914 METAL6_2513600_735400 METAL6_2513600_758400 0.046
R_VDD15_3915 METAL6_2513600_758400 METAL6_2513600_763000 0.0092
R_VDD15_3916 METAL6_2513600_763000 METAL6_2513600_770400 0.0148
R_VDD15_3917 METAL6_2513600_770400 METAL6_2513600_772000 0.0032
R_VDD15_3918 METAL6_2513600_772000 METAL6_2513600_778400 0.0128
R_VDD15_3919 METAL6_2513600_778400 METAL6_2512000_778400 0.0032
R_VDD15_3920 METAL6_2512000_778400 METAL6_2510900_778400 0.0022
R_VDD15_3921 METAL6_2510900_778400 METAL6_2505000_778400 0.0118
R_VDD15_3922 METAL6_2505000_778400 METAL6_2505000_779200 0.0016
R_VDD15_3923 METAL6_2505000_779200 METAL6_2505000_782400 0.0064
R_VDD15_3924 METAL6_2505000_782400 METAL6_2505000_784500 0.0042
R_VDD15_3925 METAL6_2505000_784500 METAL6_2505000_788000 0.007
R_VDD15_3926 METAL6_2505000_788000 METAL6_2505000_790400 0.0048
R_VDD15_3927 METAL6_2505000_790400 METAL6_2505000_791200 0.0016
R_VDD15_3928 METAL6_2505000_791200 METAL6_2505000_794400 0.0064
R_VDD15_3929 METAL6_2505000_794400 METAL6_2504400_794400 0.0012
R_VDD15_3930 METAL6_2504400_794400 METAL6_2501600_794400 0.0056
R_VDD15_3931 METAL6_2501600_794400 METAL6_2500000_794400 0.0032
R_VDD15_3932 METAL6_2500000_794400 METAL6_2498900_794400 0.0022
R_VDD15_3933 METAL6_2498900_794400 METAL6_2493000_794400 0.0118
R_VDD15_3934 METAL6_2493000_794400 METAL6_2488000_794400 0.01
R_VDD15_3935 METAL6_2488000_794400 METAL6_2486900_794400 0.0022
R_VDD15_3936 METAL6_2486900_794400 METAL6_2481000_794400 0.0118
R_VDD15_3937 METAL6_2481000_794400 METAL6_2476000_794400 0.01
R_VDD15_3938 METAL6_2476000_794400 METAL6_2472600_794400 0.0068
R_VDD15_3939 METAL6_2472600_794400 METAL6_2469000_794400 0.0072
R_VDD15_3940 METAL6_2469000_794400 METAL6_2460600_794400 0.0168
R_VDD15_3941 METAL6_2460600_794400 METAL6_2448600_794400 0.024
R_VDD15_3942 METAL6_2448600_794400 METAL6_2446600_794400 0.004
R_VDD15_3943 METAL6_2446600_794400 METAL6_2436600_794400 0.02
R_VDD15_3944 METAL6_2436600_794400 METAL6_2419100_794400 0.035
R_VDD15_3945 METAL6_2419100_794400 METAL6_2407100_794400 0.024
R_VDD15_3946 METAL6_2407100_794400 METAL6_2405600_794400 0.003
R_VDD15_3947 METAL6_2405600_794400 METAL6_2402100_794400 0.007
R_VDD15_3948 METAL6_2402100_794400 METAL6_2395100_794400 0.014
R_VDD15_3949 METAL6_2395100_794400 METAL6_2393600_794400 0.003
R_VDD15_3950 METAL6_2393600_794400 METAL6_2383100_794400 0.021
R_VDD15_3951 METAL6_2383100_794400 METAL6_2381600_794400 0.003
R_VDD15_3952 METAL6_2381600_794400 METAL6_2371100_794400 0.021
R_VDD15_3953 METAL6_2371100_794400 METAL6_2369600_794400 0.003
R_VDD15_3954 METAL6_2369600_794400 METAL6_2365900_794400 0.0074
R_VDD15_3955 METAL6_2365900_794400 METAL6_2357600_794400 0.0166
R_VDD15_3956 METAL6_2357600_794400 METAL6_2351900_794400 0.0114
R_VDD15_3957 METAL6_2351900_794400 METAL6_2343700_794400 0.0164
R_VDD15_3958 METAL6_2343700_794400 METAL6_2310900_794400 0.0656
R_VDD15_3959 METAL6_2310900_794400 METAL6_2298900_794400 0.024
R_VDD15_3960 METAL6_2298900_794400 METAL6_2286900_794400 0.024
R_VDD15_3961 METAL6_2286900_794400 METAL6_2272600_794400 0.0286
R_VDD15_3962 METAL6_2272600_794400 METAL6_2272600_794800 0.0008
R_VDD15_3963 METAL6_2272600_794800 METAL6_2272600_800000 0.0104
R_VDD15_3964 METAL6_2272600_800000 METAL6_2272600_802400 0.0048
R_VDD15_3965 METAL6_2272600_802400 METAL6_2272600_803200 0.0016
R_VDD15_3966 METAL6_2272600_803200 METAL6_2272600_806400 0.0064
R_VDD15_3967 METAL6_2272600_806400 METAL6_2272600_808000 0.0032
R_VDD15_3968 METAL6_2272600_808000 METAL6_2272600_812000 0.008
R_VDD15_3969 METAL6_2272600_812000 METAL6_2272600_814400 0.0048
R_VDD15_3970 METAL6_2272600_814400 METAL6_2272600_818400 0.008
R_VDD15_3971 METAL6_2272600_818400 METAL6_2272600_820000 0.0032
R_VDD15_3972 METAL6_2272600_820000 METAL6_2272600_830400 0.0208
R_VDD15_3973 METAL6_2272600_830400 METAL6_2272600_832000 0.0032
R_VDD15_3974 METAL6_2272600_832000 METAL6_2272600_839500 0.015
R_VDD15_3975 METAL6_2272600_839500 METAL6_2272600_840700 0.0024
R_VDD15_3976 METAL6_2272600_840700 METAL6_2272600_851500 0.0216
R_VDD15_3977 METAL6_2272600_851500 METAL6_2272600_858200 0.0134
R_VDD15_3978 METAL6_2272600_858200 METAL6_2272600_863500 0.0106
R_VDD15_3979 METAL6_2272600_863500 METAL6_2272600_887000 0.047
R_VDD15_3980 METAL6_2272600_887000 METAL6_2272600_888000 0.002
R_VDD15_3981 METAL6_2272600_888000 METAL6_2272600_900000 0.024
R_VDD15_3982 METAL6_2272600_900000 METAL6_2272600_900400 0.0008
R_VDD15_3983 METAL6_2272600_900400 METAL6_2272600_912000 0.0232
R_VDD15_3984 METAL6_2272600_912000 METAL6_2272600_927300 0.0306
R_VDD15_3985 METAL6_2272600_927300 METAL6_2272600_947000 0.0394
R_VDD15_3986 METAL6_2272600_947000 METAL6_2272600_959000 0.024
R_VDD15_3987 METAL6_2272600_959000 METAL6_2272600_971000 0.024
R_VDD15_3988 METAL6_2272600_971000 METAL6_2272600_976000 0.01
R_VDD15_3989 METAL6_2272600_976000 METAL6_2272600_988000 0.024
R_VDD15_3990 METAL6_2272600_988000 METAL6_2272600_995000 0.014
R_VDD15_3991 METAL6_2272600_995000 METAL6_2272600_1000000 0.01
R_VDD15_3992 METAL6_2272600_1000000 METAL6_2272600_1007000 0.014
R_VDD15_3993 METAL6_2272600_1007000 METAL6_2272600_1012000 0.01
R_VDD15_3994 METAL6_2272600_1012000 METAL6_2272600_1014000 0.004
R_VDD15_3995 METAL6_2272600_1014000 METAL6_2272600_1019000 0.01
R_VDD15_3996 METAL6_2272600_1019000 METAL6_2272600_1026000 0.014
R_VDD15_3997 METAL6_2272600_1026000 METAL6_2272600_1029800 0.0076
R_VDD15_3998 METAL6_2272600_1029800 METAL6_2272600_1031000 0.0024
R_VDD15_3999 METAL6_2272600_1031000 METAL6_2272600_1035700 0.0094
R_VDD15_4000 METAL6_2272600_1035700 METAL6_2272600_1037400 0.0034
R_VDD15_4001 METAL6_2272600_1037400 METAL6_2272600_1038000 0.0012
R_VDD15_4002 METAL6_2272600_1038000 METAL6_2272600_1041800 0.0076
R_VDD15_4003 METAL6_2272600_1041800 METAL6_2272600_1042700 0.0018
R_VDD15_4004 METAL6_2272600_1042700 METAL6_2272600_1049400 0.0134
R_VDD15_4005 METAL6_2272600_1049400 METAL6_2272600_1049800 0.0008
R_VDD15_4006 METAL6_2272600_1049800 METAL6_2272600_1053800 0.008
R_VDD15_4007 METAL6_2272600_1053800 METAL6_2272600_1054700 0.0018
R_VDD15_4008 METAL6_2272600_1054700 METAL6_2272600_1061400 0.0134
R_VDD15_4009 METAL6_2272600_1061400 METAL6_2272600_1061800 0.0008
R_VDD15_4010 METAL6_2272600_1061800 METAL6_2272600_1066700 0.0098
R_VDD15_4011 METAL6_2272600_1066700 METAL6_2272600_1073800 0.0142
R_VDD15_4012 METAL6_2272600_1073800 METAL6_2272600_1086000 0.0244
R_VDD15_4013 METAL6_2272600_1086000 METAL6_2272600_1086300 0.0006
R_VDD15_4014 METAL6_2272600_1086300 METAL6_2272600_1086500 0.0004
R_VDD15_4015 METAL6_2272600_1086500 METAL6_2272600_1088000 0.003
R_VDD15_4016 METAL6_2272600_1088000 METAL6_2272600_1096800 0.0176
R_VDD15_4017 METAL6_2272600_1096800 METAL6_2272600_1098300 0.003
R_VDD15_4018 METAL6_2272600_1098300 METAL6_2272600_1098500 0.0004
R_VDD15_4019 METAL6_2272600_1098500 METAL6_2272600_1100000 0.003
R_VDD15_4020 METAL6_2272600_1100000 METAL6_2272600_1108800 0.0176
R_VDD15_4021 METAL6_2272600_1108800 METAL6_2272600_1110300 0.003
R_VDD15_4022 METAL6_2272600_1110300 METAL6_2272600_1110500 0.0004
R_VDD15_4023 METAL6_2272600_1110500 METAL6_2272600_1112000 0.003
R_VDD15_4024 METAL6_2272600_1112000 METAL6_2272600_1120800 0.0176
R_VDD15_4025 METAL6_2272600_1120800 METAL6_2272600_1122300 0.003
R_VDD15_4026 METAL6_2272600_1122300 METAL6_2272600_1129300 0.014
R_VDD15_4027 METAL6_2272600_1129300 METAL6_2272600_1134300 0.01
R_VDD15_4028 METAL6_2272600_1134300 METAL6_2272600_1141300 0.014
R_VDD15_4029 METAL6_2272600_1141300 METAL6_2272600_1153300 0.024
R_VDD15_4030 METAL6_2272600_1153300 METAL6_2272600_1160600 0.0146
R_VDD15_4031 METAL6_2272600_1160600 METAL6_2272600_1172600 0.024
R_VDD15_4032 METAL6_2272600_1172600 METAL6_2272600_1184600 0.024
R_VDD15_4033 METAL6_2272600_1184600 METAL6_2272600_1191600 0.014
R_VDD15_4034 METAL6_2272600_1191600 METAL6_2272600_1193700 0.0042
R_VDD15_4035 METAL6_2272600_1193700 METAL6_2272600_1193800 0.0002
R_VDD15_4036 METAL6_2272600_1193800 METAL6_2272600_1205700 0.0238
R_VDD15_4037 METAL6_2272600_1205700 METAL6_2272600_1217700 0.024
R_VDD15_4038 METAL6_2272600_1217700 METAL6_2272600_1223700 0.012
R_VDD15_4039 METAL6_2272600_1223700 METAL6_2272600_1229700 0.012
R_VDD15_4040 METAL6_2272600_1229700 METAL6_2272600_1235700 0.012
R_VDD15_4041 METAL6_2272600_1235700 METAL6_2272600_1238000 0.0046
R_VDD15_4042 METAL6_2272600_1238000 METAL6_2272600_1247700 0.0194
R_VDD15_4043 METAL6_2272600_1247700 METAL5_2272600_1247700 0.1
R_VDD15_4044 METAL5_2272600_1247700 METAL5_2272600_1250000 0.0092
R_VDD15_4045 METAL5_2272600_1250000 METAL5_2272600_1259700 0.0388
R_VDD15_4046 METAL5_2272600_1259700 METAL5_2272600_1262000 0.0092
R_VDD15_4047 METAL5_2272600_1262000 METAL5_2272600_1271700 0.0388
R_VDD15_4048 METAL5_2272600_1271700 METAL5_2272600_1273000 0.0052
R_VDD15_4049 METAL5_2272600_1273000 METAL5_2272600_1283700 0.0428
R_VDD15_4050 METAL5_2272600_1283700 METAL6_2272600_1283700 0.1
R_VDD15_4051 METAL6_2272600_1283700 METAL6_2272600_1314000 0.0606
R_VDD15_4052 METAL6_2272600_1314000 METAL6_2272600_1326000 0.024
R_VDD15_4053 METAL6_2272600_1326000 METAL6_2272600_1338000 0.024
R_VDD15_4054 METAL6_2272600_1338000 METAL6_2272600_1350000 0.024
R_VDD15_4055 METAL6_2272600_1350000 METAL6_2272600_1357000 0.014
R_VDD15_4056 METAL6_2272600_1357000 METAL6_2272600_1362000 0.01
R_VDD15_4057 METAL6_2272600_1362000 METAL6_2272600_1369000 0.014
R_VDD15_4058 METAL6_2272600_1369000 METAL6_2272600_1374000 0.01
R_VDD15_4059 METAL6_2272600_1374000 METAL6_2272600_1381000 0.014
R_VDD15_4060 METAL6_2272600_1381000 METAL6_2272600_1386600 0.0112
R_VDD15_4061 METAL6_2272600_1386600 METAL6_2272600_1393000 0.0128
R_VDD15_4062 METAL6_2272600_1393000 METAL6_2272600_1405000 0.024
R_VDD15_4063 METAL6_2272600_1405000 METAL6_2272600_1437700 0.0654
R_VDD15_4064 METAL6_2272600_1437700 METAL6_2272600_1449700 0.024
R_VDD15_4065 METAL6_2272600_1449700 METAL6_2272600_1461700 0.024
R_VDD15_4066 METAL6_2272600_1461700 METAL6_2272600_1492300 0.0612
R_VDD15_4067 METAL6_2272600_1492300 METAL6_2272600_1504300 0.024
R_VDD15_4068 METAL6_2272600_1504300 METAL6_2272600_1516300 0.024
R_VDD15_4069 METAL6_2272600_1516300 METAL6_2272600_1528300 0.024
R_VDD15_4070 METAL6_2272600_1528300 METAL5_2272600_1528300 0.1
R_VDD15_4071 METAL5_2272600_1528300 METAL5_2272600_1540300 0.048
R_VDD15_4072 METAL5_2272600_1540300 METAL5_2272600_1552300 0.048
R_VDD15_4073 METAL5_2272600_1552300 METAL6_2272600_1552300 0.1
R_VDD15_4074 METAL6_2272600_1552300 METAL6_2272600_1554500 0.0044
R_VDD15_4075 METAL6_2272600_1554500 METAL6_2272600_1564300 0.0196
R_VDD15_4076 METAL6_2272600_1564300 METAL6_2272600_1571300 0.014
R_VDD15_4077 METAL6_2272600_1571300 METAL6_2272600_1576300 0.01
R_VDD15_4078 METAL6_2272600_1576300 METAL6_2272600_1714500 0.2764
R_VDD15_4079 METAL6_2272600_1714500 METAL6_2272600_1720500 0.012
R_VDD15_4080 METAL6_2272600_1720500 METAL6_2272600_1726500 0.012
R_VDD15_4081 METAL6_2272600_1726500 METAL6_2272600_1731700 0.0104
R_VDD15_4082 METAL6_2272600_1731700 METAL6_2272600_1738500 0.0136
R_VDD15_4083 METAL6_2272600_1738500 METAL6_2272600_1750500 0.024
R_VDD15_4084 METAL6_2272600_1750500 METAL6_2272600_1762500 0.024
R_VDD15_4085 METAL6_2272600_1762500 METAL6_2272600_1774500 0.024
R_VDD15_4086 METAL6_2272600_1774500 METAL6_2272600_1802500 0.056
R_VDD15_4087 METAL6_2272600_1802500 METAL6_2272600_1814500 0.024
R_VDD15_4088 METAL6_2272600_1814500 METAL6_2272600_1826500 0.024
R_VDD15_4089 METAL6_2272600_1826500 METAL6_2272600_1838500 0.024
R_VDD15_4090 METAL6_2272600_1838500 METAL6_2272600_1852300 0.0276
R_VDD15_4091 METAL6_2272600_1852300 METAL6_2272600_1866300 0.028
R_VDD15_4092 METAL6_2272600_1866300 METAL6_2272600_1902500 0.0724
R_VDD15_4093 METAL6_2272600_1902500 METAL6_2272600_1914500 0.024
R_VDD15_4094 METAL6_2272600_1914500 METAL6_2272600_1926500 0.024
R_VDD15_4095 METAL6_2272600_1926500 METAL6_2272600_1938500 0.024
R_VDD15_4096 METAL6_2272600_1938500 METAL6_2272600_1940500 0.004
R_VDD15_4097 METAL6_2272600_1940500 METAL6_2272600_1950500 0.02
R_VDD15_4098 METAL6_2272600_1950500 METAL6_2272600_1951000 0.001
R_VDD15_4099 METAL6_2272600_1951000 METAL6_2272600_1952500 0.003
R_VDD15_4100 METAL6_2272600_1952500 METAL6_2272600_1963000 0.021
R_VDD15_4101 METAL6_2272600_1963000 METAL6_2272600_1964500 0.003
R_VDD15_4102 METAL6_2272600_1964500 METAL6_2272600_1975000 0.021
R_VDD15_4103 METAL6_2272600_1975000 METAL6_2272600_1976500 0.003
R_VDD15_4104 METAL6_2272600_1976500 METAL6_2272600_1987000 0.021
R_VDD15_4105 METAL6_2272600_1987000 METAL6_2272600_2014500 0.055
R_VDD15_4106 METAL6_2272600_2014500 METAL6_2272600_2026500 0.024
R_VDD15_4107 METAL6_2272600_2026500 METAL6_2272600_2038500 0.024
R_VDD15_4108 METAL6_2272600_2038500 METAL6_2272600_2114500 0.152
R_VDD15_4109 METAL6_2272600_2114500 METAL6_2272600_2126500 0.024
R_VDD15_4110 METAL6_2272600_2126500 METAL6_2272600_2138500 0.024
R_VDD15_4111 METAL6_2272600_2138500 METAL6_2272600_2147300 0.0176
R_VDD15_4112 METAL6_2272600_2147300 METAL6_2272600_2154300 0.014
R_VDD15_4113 METAL6_2272600_2154300 METAL6_2272600_2163000 0.0174
R_VDD15_4114 METAL6_2272600_2163000 METAL6_2272600_2166300 0.0066
R_VDD15_4115 METAL6_2272600_2166300 METAL6_2272400_2166300 0.0004
R_VDD15_4116 METAL6_2272400_2166300 METAL5_2272400_2166300 0.1
R_VDD15_4117 METAL5_2272400_2166300 METAL5_2260600_2166300 0.0472
R_VDD15_4118 METAL5_2260600_2166300 METAL5_2260400_2166300 0.0008
R_VDD15_4119 METAL5_2260400_2166300 METAL5_2258600_2166300 0.0072
R_VDD15_4120 METAL5_2258600_2166300 METAL5_2248700_2166300 0.0396
R_VDD15_4121 METAL5_2248700_2166300 METAL5_2248600_2166300 0.0004
R_VDD15_4122 METAL5_2248600_2166300 METAL5_2248400_2166300 0.0008
R_VDD15_4123 METAL5_2248400_2166300 METAL5_2246600_2166300 0.0072
R_VDD15_4124 METAL5_2246600_2166300 METAL5_2236700_2166300 0.0396
R_VDD15_4125 METAL5_2236700_2166300 METAL5_2236600_2166300 0.0004
R_VDD15_4126 METAL5_2236600_2166300 METAL5_2234600_2166300 0.008
R_VDD15_4127 METAL5_2234600_2166300 METAL5_2224700_2166300 0.0396
R_VDD15_4128 METAL5_2224700_2166300 METAL5_2222600_2166300 0.0084
R_VDD15_4129 METAL5_2222600_2166300 METAL5_2221900_2166300 0.0028
R_VDD15_4130 METAL5_2221900_2166300 METAL5_2212700_2166300 0.0368
R_VDD15_4131 METAL5_2212700_2166300 METAL5_2200700_2166300 0.048
R_VDD15_4132 METAL5_2200700_2166300 METAL5_2189900_2166300 0.0432
R_VDD15_4133 METAL5_2189900_2166300 METAL5_2188700_2166300 0.0048
R_VDD15_4134 METAL5_2188700_2166300 METAL5_2177900_2166300 0.0432
R_VDD15_4135 METAL5_2177900_2166300 METAL5_2176700_2166300 0.0048
R_VDD15_4136 METAL5_2176700_2166300 METAL5_2165900_2166300 0.0432
R_VDD15_4137 METAL5_2165900_2166300 METAL5_2165400_2166300 0.002
R_VDD15_4138 METAL5_2165400_2166300 METAL5_2153900_2166300 0.046
R_VDD15_4139 METAL5_2153900_2166300 METAL6_2153900_2166300 0.1
R_VDD15_4140 METAL6_2153900_2166300 METAL6_2153400_2166300 0.001
R_VDD15_4141 METAL6_2153400_2166300 METAL6_2151900_2166300 0.003
R_VDD15_4142 METAL6_2151900_2166300 METAL6_2141900_2166300 0.02
R_VDD15_4143 METAL6_2141900_2166300 METAL6_2141900_2175000 0.0174
R_VDD15_4144 METAL6_2141900_2175000 METAL6_2141900_2178300 0.0066
R_VDD15_4145 METAL6_2141900_2178300 METAL6_2141900_2187000 0.0174
R_VDD15_4146 METAL6_2141900_2187000 METAL6_2141900_2190300 0.0066
R_VDD15_4147 METAL6_2141900_2190300 METAL6_2141900_2222500 0.0644
R_VDD15_4148 METAL6_2141900_2222500 METAL6_2141900_2234500 0.024
R_VDD15_4149 METAL6_2141900_2234500 METAL6_2141900_2246500 0.024
R_VDD15_4150 METAL6_2141900_2246500 METAL6_2141900_2268500 0.044
R_VDD15_4151 METAL6_2141900_2268500 METAL6_2141900_2288000 0.039
R_VDD15_4152 METAL6_2141900_2288000 METAL6_2141900_2300000 0.024
R_VDD15_4153 METAL6_2141900_2300000 METAL6_2141900_2312000 0.024
R_VDD15_4154 METAL6_2141900_2312000 METAL6_2141900_2338000 0.052
R_VDD15_4155 METAL6_2141900_2338000 METAL6_2141900_2350000 0.024
R_VDD15_4156 METAL6_2141900_2350000 METAL6_2141900_2353000 0.006
R_VDD15_4157 METAL6_2141900_2353000 METAL6_2141900_2362000 0.018
R_VDD15_4158 METAL6_2141900_2362000 METAL6_2141900_2364000 0.004
R_VDD15_4159 METAL6_2141900_2364000 METAL6_2141400_2364000 0.001
R_VDD15_4160 METAL6_2141400_2364000 METAL6_2129900_2364000 0.023
R_VDD15_4161 METAL6_2129900_2364000 METAL6_2129900_2365000 0.002
R_VDD15_4162 METAL6_2129900_2365000 METAL6_2129700_2365000 0.0004
R_VDD15_4163 METAL6_2129700_2365000 METAL6_2125600_2365000 0.0082
R_VDD15_4164 METAL6_2125600_2365000 METAL6_2121400_2365000 0.0084
R_VDD15_4165 METAL6_2121400_2365000 METAL6_2113600_2365000 0.0156
R_VDD15_4166 METAL6_2113600_2365000 METAL6_2101900_2365000 0.0234
R_VDD15_4167 METAL6_2101900_2365000 METAL6_2101600_2365000 0.0006
R_VDD15_4168 METAL6_2101600_2365000 METAL6_2089900_2365000 0.0234
R_VDD15_4169 METAL6_2089900_2365000 METAL6_2079700_2365000 0.0204
R_VDD15_4170 METAL6_2079700_2365000 METAL6_2077900_2365000 0.0036
R_VDD15_4171 METAL6_2077900_2365000 METAL6_2067700_2365000 0.0204
R_VDD15_4172 METAL6_2067700_2365000 METAL6_2060600_2365000 0.0142
R_VDD15_4173 METAL6_2060600_2365000 METAL6_2055700_2365000 0.0098
R_VDD15_4174 METAL6_2055700_2365000 METAL6_2046800_2365000 0.0178
R_VDD15_4175 METAL6_2046800_2365000 METAL6_2046600_2365000 0.0004
R_VDD15_4176 METAL6_2046600_2365000 METAL6_2046400_2365000 0.0004
R_VDD15_4177 METAL6_2046400_2365000 METAL6_2043700_2365000 0.0054
R_VDD15_4178 METAL6_2043700_2365000 METAL6_2031700_2365000 0.024
R_VDD15_4179 METAL6_2031700_2365000 METAL6_2030900_2365000 0.0016
R_VDD15_4180 METAL6_2030900_2365000 METAL6_2026400_2365000 0.009
R_VDD15_4181 METAL6_2026400_2365000 METAL6_2021200_2365000 0.0104
R_VDD15_4182 METAL6_2021200_2365000 METAL6_2019700_2365000 0.003
R_VDD15_4183 METAL6_2019700_2365000 METAL6_2018900_2365000 0.0016
R_VDD15_4184 METAL6_2018900_2365000 METAL6_2014400_2365000 0.009
R_VDD15_4185 METAL6_2014400_2365000 METAL6_2012000_2365000 0.0048
R_VDD15_4186 METAL6_2012000_2365000 METAL6_2006900_2365000 0.0102
R_VDD15_4187 METAL6_2006900_2365000 METAL6_2002400_2365000 0.009
R_VDD15_4188 METAL6_2002400_2365000 METAL6_2000000_2365000 0.0048
R_VDD15_4189 METAL6_2000000_2365000 METAL6_1988000_2365000 0.024
R_VDD15_4190 METAL6_1988000_2365000 METAL6_1951900_2365000 0.0722
R_VDD15_4191 METAL6_1951900_2365000 METAL6_1951800_2365000 0.0002
R_VDD15_4192 METAL6_1951800_2365000 METAL6_1939800_2365000 0.024
R_VDD15_4193 METAL6_1939800_2365000 METAL6_1931200_2365000 0.0172
R_VDD15_4194 METAL6_1931200_2365000 METAL6_1927800_2365000 0.0068
R_VDD15_4195 METAL6_1927800_2365000 METAL6_1926200_2365000 0.0032
R_VDD15_4196 METAL6_1926200_2365000 METAL6_1925600_2365000 0.0012
R_VDD15_4197 METAL6_1925600_2365000 METAL6_1919200_2365000 0.0128
R_VDD15_4198 METAL6_1919200_2365000 METAL6_1913600_2365000 0.0112
R_VDD15_4199 METAL6_1913600_2365000 METAL6_1907400_2365000 0.0124
R_VDD15_4200 METAL6_1907400_2365000 METAL6_1907200_2365000 0.0004
R_VDD15_4201 METAL6_1907200_2365000 METAL6_1901600_2365000 0.0112
R_VDD15_4202 METAL6_1901600_2365000 METAL6_1900700_2365000 0.0018
R_VDD15_4203 METAL6_1900700_2365000 METAL6_1895200_2365000 0.011
R_VDD15_4204 METAL6_1895200_2365000 METAL5_1895200_2365000 0.1
R_VDD15_4205 METAL5_1895200_2365000 METAL5_1895200_2376000 0.044
R_VDD15_4206 METAL5_1895200_2376000 METAL5_1895200_2377000 0.004
R_VDD15_4207 METAL5_1895200_2377000 METAL5_1895200_2388000 0.044
R_VDD15_4208 METAL5_1895200_2388000 METAL5_1895200_2389000 0.004
R_VDD15_4209 METAL5_1895200_2389000 METAL6_1895200_2389000 0.1
R_VDD15_4210 METAL6_1895200_2389000 METAL6_1895200_2400000 0.022
R_VDD15_4211 METAL6_1895200_2400000 METAL6_1888700_2400000 0.013
R_VDD15_4212 METAL6_1888700_2400000 METAL6_1877400_2400000 0.0226
R_VDD15_4213 METAL6_1877400_2400000 METAL6_1877400_2401000 0.002
R_VDD15_4214 METAL6_1877400_2401000 METAL6_1877400_2407000 0.012
R_VDD15_4215 METAL6_1877400_2407000 METAL6_1877400_2412000 0.01
R_VDD15_4216 METAL6_1877400_2412000 METAL6_1877400_2413000 0.002
R_VDD15_4217 METAL6_1877400_2413000 METAL6_1877400_2424000 0.022
R_VDD15_4218 METAL6_1877400_2424000 METAL6_1877400_2438000 0.028
R_VDD15_4219 METAL6_1877400_2438000 METAL6_1877400_2444000 0.012
R_VDD15_4220 METAL6_1877400_2444000 METAL6_1877400_2450000 0.012
R_VDD15_4221 METAL6_1877400_2450000 METAL6_1877400_2456000 0.012
R_VDD15_4222 METAL6_1877400_2456000 METAL6_1877400_2462000 0.012
R_VDD15_4223 METAL6_1877400_2462000 METAL6_1877400_2468000 0.012
R_VDD15_4224 METAL6_1877400_2468000 METAL6_1877400_2481000 0.026
R_VDD15_4225 METAL6_1877400_2481000 METAL6_1877400_2493000 0.024
R_VDD15_4226 METAL6_1877400_2493000 METAL6_1877400_2505000 0.024
R_VDD15_4227 METAL6_1877400_2505000 METAL6_1877400_2512000 0.014
R_VDD15_4228 METAL6_1877400_2512000 METAL6_1877400_2524000 0.024
R_VDD15_4229 METAL6_1877400_2524000 METAL6_1877400_2529700 0.0114
R_VDD15_4230 METAL6_1877400_2529700 METAL6_1877400_2536000 0.0126
R_VDD15_4231 METAL6_1877400_2536000 METAL6_1877400_2541700 0.0114
R_VDD15_4232 METAL6_1877400_2541700 METAL6_1877400_2548000 0.0126
R_VDD15_4233 METAL6_1877400_2548000 METAL6_1877400_2553700 0.0114
R_VDD15_4234 METAL6_1877400_2553700 METAL6_1877400_2589000 0.0706
R_VDD15_4235 METAL6_1877400_2589000 METAL6_1877400_2603000 0.028
R_VDD15_4236 METAL6_1877400_2603000 METAL6_1877400_2644000 0.082
R_VDD15_4237 METAL6_1877400_2644000 METAL6_1877400_2656000 0.024
R_VDD15_4238 METAL6_1877400_2656000 METAL6_1877400_2665700 0.0194
R_VDD15_4239 METAL6_1877400_2665700 METAL6_1877400_2668000 0.0046
R_VDD15_4240 METAL6_1877400_2668000 METAL6_1877400_2701000 0.066
R_VDD15_4241 METAL6_1877400_2701000 METAL6_1877400_2701700 0.0014
R_VDD15_4242 METAL6_1877400_2701700 METAL6_1877400_2713000 0.0226
R_VDD15_4243 METAL6_1877400_2713000 METAL6_1877400_2713700 0.0014
R_VDD15_4244 METAL6_1877400_2713700 METAL6_1877400_2724000 0.0206
R_VDD15_4245 METAL6_1877400_2724000 METAL6_1877400_2725000 0.002
R_VDD15_4246 METAL6_1877400_2725000 METAL6_1877400_2725700 0.0014
R_VDD15_4247 METAL6_1877400_2725700 METAL6_1877400_2736000 0.0206
R_VDD15_4248 METAL6_1877400_2736000 METAL6_1876700_2736000 0.0014
R_VDD15_4249 METAL6_1876700_2736000 METAL6_1874700_2736000 0.004
R_VDD15_4250 METAL6_1874700_2736000 METAL6_1870600_2736000 0.0082
R_VDD15_4251 METAL6_1870600_2736000 METAL6_1865400_2736000 0.0104
R_VDD15_4252 METAL6_1717800_2536000 METAL6_1729800_2536000 0.024
R_VDD15_4253 METAL6_3490500_200000 METAL6_3490500_190600 0.0188
R_VDD15_4254 METAL6_3490500_190600 METAL6_3490500_188000 0.0052
R_VDD15_4255 METAL6_3490500_188000 METAL6_3478500_188000 0.024
R_VDD15_4256 METAL6_3478500_188000 METAL6_3477000_188000 0.003
R_VDD15_4257 METAL6_3477000_188000 METAL6_3466500_188000 0.021
R_VDD15_4258 METAL6_3466500_188000 METAL6_3466500_190600 0.0052
R_VDD15_4259 METAL6_3466500_190600 METAL6_3466500_200000 0.0188
R_VDD15_4260 METAL6_3466500_200000 METAL6_3466500_212000 0.024
R_VDD15_4261 METAL6_3466500_212000 METAL6_3466500_248300 0.0726
R_VDD15_4262 METAL6_3466500_248300 METAL6_3466500_260300 0.024
R_VDD15_4263 METAL6_3466500_260300 METAL6_3466500_263000 0.0054
R_VDD15_4264 METAL6_3466500_263000 METAL6_3466500_272300 0.0186
R_VDD15_4265 METAL6_3466500_272300 METAL6_3466500_275000 0.0054
R_VDD15_4266 METAL6_3466500_275000 METAL6_3465000_275000 0.003
R_VDD15_4267 METAL6_3465000_275000 METAL6_3453000_275000 0.024
R_VDD15_4268 METAL6_3453000_275000 METAL6_3336400_275000 0.2332
R_VDD15_4269 METAL6_3336400_275000 METAL6_3324400_275000 0.024
R_VDD15_4270 METAL6_3324400_275000 METAL6_3312400_275000 0.024
R_VDD15_4271 METAL6_3312400_275000 METAL6_3312000_275000 0.0008
R_VDD15_4272 METAL6_3312000_275000 METAL6_3305400_275000 0.0132
R_VDD15_4273 METAL6_3305400_275000 METAL6_3300400_275000 0.01
R_VDD15_4274 METAL6_3300400_275000 METAL6_3300400_279300 0.0086
R_VDD15_4275 METAL6_3300400_279300 METAL6_3300400_287000 0.0154
R_VDD15_4276 METAL6_3300400_287000 METAL6_3300400_288000 0.002
R_VDD15_4277 METAL6_3300400_288000 METAL6_3300400_299000 0.022
R_VDD15_4278 METAL6_3300400_299000 METAL6_3300400_300000 0.002
R_VDD15_4279 METAL6_3300400_300000 METAL6_3300400_312000 0.024
R_VDD15_4280 METAL6_3300400_312000 METAL6_3300400_355300 0.0866
R_VDD15_4281 METAL6_3300400_355300 METAL6_3300400_362300 0.014
R_VDD15_4282 METAL6_3300400_362300 METAL6_3300400_374300 0.024
R_VDD15_4283 METAL6_3300400_374300 METAL6_3300400_386300 0.024
R_VDD15_4284 METAL6_3300400_386300 METAL6_3300400_388000 0.0034
R_VDD15_4285 METAL6_3300400_388000 METAL6_3300400_390800 0.0056
R_VDD15_4286 METAL6_3300400_390800 METAL6_3300000_390800 0.0008
R_VDD15_4287 METAL6_3300000_390800 METAL6_3288000_390800 0.024
R_VDD15_4288 METAL6_3288000_390800 METAL6_3287000_390800 0.002
R_VDD15_4289 METAL6_3287000_390800 METAL6_3275000_390800 0.024
R_VDD15_4290 METAL6_3275000_390800 METAL6_3263000_390800 0.024
R_VDD15_4291 METAL6_3263000_390800 METAL6_3260400_390800 0.0052
R_VDD15_4292 METAL6_3260400_390800 METAL6_3243500_390800 0.0338
R_VDD15_4293 METAL6_3243500_390800 METAL6_3231500_390800 0.024
R_VDD15_4294 METAL6_3231500_390800 METAL6_3219500_390800 0.024
R_VDD15_4295 METAL6_3219500_390800 METAL6_3212500_390800 0.014
R_VDD15_4296 METAL6_3212500_390800 METAL6_3212000_390800 0.001
R_VDD15_4297 METAL6_3212000_390800 METAL6_3200000_390800 0.024
R_VDD15_4298 METAL6_3200000_390800 METAL6_3188000_390800 0.024
R_VDD15_4299 METAL6_3188000_390800 METAL6_3179500_390800 0.017
R_VDD15_4300 METAL6_3179500_390800 METAL6_3167500_390800 0.024
R_VDD15_4301 METAL6_3167500_390800 METAL6_3165900_390800 0.0032
R_VDD15_4302 METAL6_3165900_390800 METAL6_3155500_390800 0.0208
R_VDD15_4303 METAL6_3155500_390800 METAL6_3124000_390800 0.063
R_VDD15_4304 METAL6_3124000_390800 METAL6_3112000_390800 0.024
R_VDD15_4305 METAL6_3112000_390800 METAL6_3112000_400000 0.0184
R_VDD15_4306 METAL6_3112000_400000 METAL6_3112000_402800 0.0056
R_VDD15_4307 METAL6_3112000_402800 METAL6_3112000_412000 0.0184
R_VDD15_4308 METAL6_3112000_412000 METAL6_3112000_414800 0.0056
R_VDD15_4309 METAL6_3112000_414800 METAL6_3112000_437000 0.0444
R_VDD15_4310 METAL6_3112000_437000 METAL6_3110900_437000 0.0022
R_VDD15_4311 METAL6_3110900_437000 METAL6_3100000_437000 0.0218
R_VDD15_4312 METAL6_3100000_437000 METAL6_3100000_449000 0.024
R_VDD15_4313 METAL6_3100000_449000 METAL6_3100000_453000 0.008
R_VDD15_4314 METAL6_3100000_453000 METAL6_3100000_461000 0.016
R_VDD15_4315 METAL6_3100000_461000 METAL6_3100000_465000 0.008
R_VDD15_4316 METAL6_3100000_465000 METAL6_3100000_477000 0.024
R_VDD15_4317 METAL6_3100000_477000 METAL6_3100000_480400 0.0068
R_VDD15_4318 METAL6_3100000_480400 METAL6_3100000_483000 0.0052
R_VDD15_4319 METAL6_3100000_483000 METAL6_3099200_483000 0.0016
R_VDD15_4320 METAL6_3099200_483000 METAL6_3098900_483000 0.0006
R_VDD15_4321 METAL6_3098900_483000 METAL6_3088000_483000 0.0218
R_VDD15_4322 METAL6_3088000_483000 METAL6_3087200_483000 0.0016
R_VDD15_4323 METAL6_3087200_483000 METAL6_3086900_483000 0.0006
R_VDD15_4324 METAL6_3086900_483000 METAL6_3076000_483000 0.0218
R_VDD15_4325 METAL6_3076000_483000 METAL6_3076000_488000 0.01
R_VDD15_4326 METAL6_3076000_488000 METAL6_3076000_495000 0.014
R_VDD15_4327 METAL6_3076000_495000 METAL6_3075200_495000 0.0016
R_VDD15_4328 METAL6_3075200_495000 METAL6_3068200_495000 0.014
R_VDD15_4329 METAL6_3068200_495000 METAL6_3060600_495000 0.0152
R_VDD15_4330 METAL6_3060600_495000 METAL6_3023200_495000 0.0748
R_VDD15_4331 METAL6_3023200_495000 METAL6_3012000_495000 0.0224
R_VDD15_4332 METAL6_3012000_495000 METAL6_3006200_495000 0.0116
R_VDD15_4333 METAL6_3006200_495000 METAL6_3000000_495000 0.0124
R_VDD15_4334 METAL6_3000000_495000 METAL6_2994200_495000 0.0116
R_VDD15_4335 METAL6_2994200_495000 METAL6_2994200_500000 0.01
R_VDD15_4336 METAL6_2994200_500000 METAL6_2994200_504000 0.008
R_VDD15_4337 METAL6_2994200_504000 METAL6_2994200_507000 0.006
R_VDD15_4338 METAL6_2994200_507000 METAL6_2993000_507000 0.0024
R_VDD15_4339 METAL6_2993000_507000 METAL6_2988000_507000 0.01
R_VDD15_4340 METAL6_2988000_507000 METAL6_2982200_507000 0.0116
R_VDD15_4341 METAL6_2982200_507000 METAL6_2975200_507000 0.014
R_VDD15_4342 METAL6_2975200_507000 METAL6_2965900_507000 0.0186
R_VDD15_4343 METAL6_2965900_507000 METAL6_2951900_507000 0.028
R_VDD15_4344 METAL6_2951900_507000 METAL6_2930200_507000 0.0434
R_VDD15_4345 METAL6_2930200_507000 METAL6_2925600_507000 0.0092
R_VDD15_4346 METAL6_2925600_507000 METAL6_2913600_507000 0.024
R_VDD15_4347 METAL6_2913600_507000 METAL6_2910900_507000 0.0054
R_VDD15_4348 METAL6_2910900_507000 METAL6_2901600_507000 0.0186
R_VDD15_4349 METAL6_2901600_507000 METAL6_2898900_507000 0.0054
R_VDD15_4350 METAL6_2898900_507000 METAL6_2897100_507000 0.0036
R_VDD15_4351 METAL6_2897100_507000 METAL6_2886900_507000 0.0204
R_VDD15_4352 METAL6_2886900_507000 METAL6_2874800_507000 0.0242
R_VDD15_4353 METAL6_2874800_507000 METAL6_2862800_507000 0.024
R_VDD15_4354 METAL6_2862800_507000 METAL6_2860600_507000 0.0044
R_VDD15_4355 METAL6_2860600_507000 METAL6_2850800_507000 0.0196
R_VDD15_4356 METAL6_2850800_507000 METAL6_2846600_507000 0.0084
R_VDD15_4357 METAL6_2846600_507000 METAL6_2843800_507000 0.0056
R_VDD15_4358 METAL6_2843800_507000 METAL6_2812000_507000 0.0636
R_VDD15_4359 METAL6_2812000_507000 METAL6_2805600_507000 0.0128
R_VDD15_4360 METAL6_2805600_507000 METAL6_2800000_507000 0.0112
R_VDD15_4361 METAL6_2800000_507000 METAL6_2798800_507000 0.0024
R_VDD15_4362 METAL6_2798800_507000 METAL6_2793600_507000 0.0104
R_VDD15_4363 METAL6_2793600_507000 METAL6_2788000_507000 0.0112
R_VDD15_4364 METAL6_2788000_507000 METAL6_2781600_507000 0.0128
R_VDD15_4365 METAL6_2781600_507000 METAL6_2765900_507000 0.0314
R_VDD15_4366 METAL6_2765900_507000 METAL6_2751900_507000 0.028
R_VDD15_4367 METAL6_2751900_507000 METAL6_2728200_507000 0.0474
R_VDD15_4368 METAL6_2728200_507000 METAL6_2710900_507000 0.0346
R_VDD15_4369 METAL6_2710900_507000 METAL6_2698900_507000 0.024
R_VDD15_4370 METAL6_2698900_507000 METAL6_2686900_507000 0.024
R_VDD15_4371 METAL6_2686900_507000 METAL6_2683200_507000 0.0074
R_VDD15_4372 METAL6_2683200_507000 METAL6_2676200_507000 0.014
R_VDD15_4373 METAL6_2676200_507000 METAL6_2664200_507000 0.024
R_VDD15_4374 METAL6_2664200_507000 METAL6_2660600_507000 0.0072
R_VDD15_4375 METAL6_2660600_507000 METAL6_2652200_507000 0.0168
R_VDD15_4376 METAL6_2652200_507000 METAL6_2646600_507000 0.0112
R_VDD15_4377 METAL6_2646600_507000 METAL6_2592400_507000 0.1084
R_VDD15_4378 METAL6_2592400_507000 METAL6_2580400_507000 0.024
R_VDD15_4379 METAL6_2580400_507000 METAL6_2568400_507000 0.024
R_VDD15_4380 METAL6_2568400_507000 METAL6_2565900_507000 0.005
R_VDD15_4381 METAL6_2565900_507000 METAL6_2556400_507000 0.019
R_VDD15_4382 METAL6_2556400_507000 METAL6_2551900_507000 0.009
R_VDD15_4383 METAL6_2551900_507000 METAL6_2537600_507000 0.0286
R_VDD15_4384 METAL6_2537600_507000 METAL6_2535400_507000 0.0044
R_VDD15_4385 METAL6_2535400_507000 METAL6_2528400_507000 0.014
R_VDD15_4386 METAL6_2528400_507000 METAL6_2525600_507000 0.0056
R_VDD15_4387 METAL6_2525600_507000 METAL6_2524000_507000 0.0032
R_VDD15_4388 METAL6_2524000_507000 METAL6_2517000_507000 0.014
R_VDD15_4389 METAL6_2517000_507000 METAL6_2517000_507800 0.0016
R_VDD15_4390 METAL6_2517000_507800 METAL6_2517000_512000 0.0084
R_VDD15_4391 METAL6_2517000_512000 METAL6_2517000_516000 0.008
R_VDD15_4392 METAL6_2517000_516000 METAL6_2517000_519000 0.006
R_VDD15_4393 METAL6_2517000_519000 METAL6_2517000_520200 0.0024
R_VDD15_4394 METAL6_2517000_520200 METAL6_2517000_528000 0.0156
R_VDD15_4395 METAL6_2517000_528000 METAL6_2517000_532200 0.0084
R_VDD15_4396 METAL6_2517000_532200 METAL6_2517000_535400 0.0064
R_VDD15_4397 METAL6_2517000_535400 METAL6_2517000_544200 0.0176
R_VDD15_4398 METAL6_2517000_544200 METAL6_2517000_547400 0.0064
R_VDD15_4399 METAL6_2517000_547400 METAL6_2517000_556200 0.0176
R_VDD15_4400 METAL6_2517000_556200 METAL6_2517000_559400 0.0064
R_VDD15_4401 METAL6_2517000_559400 METAL6_2517000_573000 0.0272
R_VDD15_4402 METAL6_2517000_573000 METAL6_2517000_574400 0.0028
R_VDD15_4403 METAL6_2517000_574400 METAL6_2516400_574400 0.0012
R_VDD15_4404 METAL6_2516400_574400 METAL6_2513600_574400 0.0056
R_VDD15_4405 METAL6_2513600_574400 METAL6_2513600_579800 0.0108
R_VDD15_4406 METAL6_2513600_579800 METAL6_2513600_586400 0.0132
R_VDD15_4407 METAL6_2513600_586400 METAL6_2512000_586400 0.0032
R_VDD15_4408 METAL6_2512000_586400 METAL6_2512000_588000 0.0032
R_VDD15_4409 METAL6_2512000_588000 METAL6_2512000_598400 0.0208
R_VDD15_4410 METAL6_2512000_598400 METAL6_2512000_600000 0.0032
R_VDD15_4411 METAL6_2512000_600000 METAL6_2512000_612000 0.024
R_VDD15_4412 METAL6_2512000_612000 METAL6_2512000_637800 0.0516
R_VDD15_4413 METAL6_2512000_637800 METAL6_2512000_641400 0.0072
R_VDD15_4414 METAL6_2512000_641400 METAL6_2512000_649800 0.0168
R_VDD15_4415 METAL6_2512000_649800 METAL6_2512000_653400 0.0072
R_VDD15_4416 METAL6_2512000_653400 METAL6_2512000_661800 0.0168
R_VDD15_4417 METAL6_2512000_661800 METAL6_2512000_665400 0.0072
R_VDD15_4418 METAL6_2512000_665400 METAL6_2512000_688000 0.0452
R_VDD15_4419 METAL6_2512000_688000 METAL6_2512000_700000 0.024
R_VDD15_4420 METAL6_2512000_700000 METAL6_2512000_702800 0.0056
R_VDD15_4421 METAL6_2512000_702800 METAL6_2512000_709800 0.014
R_VDD15_4422 METAL6_2512000_709800 METAL6_2512000_712000 0.0044
R_VDD15_4423 METAL6_2512000_712000 METAL6_2512000_716800 0.0096
R_VDD15_4424 METAL6_2512000_716800 METAL6_2512000_721800 0.01
R_VDD15_4425 METAL6_2512000_721800 METAL6_2510900_721800 0.0022
R_VDD15_4426 METAL6_2510900_721800 METAL6_2505000_721800 0.0118
R_VDD15_4427 METAL6_2505000_721800 METAL6_2504400_721800 0.0012
R_VDD15_4428 METAL6_2504400_721800 METAL6_2501600_721800 0.0056
R_VDD15_4429 METAL6_2501600_721800 METAL6_2501600_733800 0.024
R_VDD15_4430 METAL6_2501600_733800 METAL6_2500000_733800 0.0032
R_VDD15_4431 METAL6_2500000_733800 METAL6_2500000_735400 0.0032
R_VDD15_4432 METAL6_2500000_735400 METAL6_2500000_745800 0.0208
R_VDD15_4433 METAL6_2500000_745800 METAL6_2500000_758400 0.0252
R_VDD15_4434 METAL6_2500000_758400 METAL6_2500000_763000 0.0092
R_VDD15_4435 METAL6_2500000_763000 METAL6_2500000_766400 0.0068
R_VDD15_4436 METAL6_2500000_766400 METAL6_2498900_766400 0.0022
R_VDD15_4437 METAL6_2498900_766400 METAL6_2493000_766400 0.0118
R_VDD15_4438 METAL6_2493000_766400 METAL6_2488000_766400 0.01
R_VDD15_4439 METAL6_2488000_766400 METAL6_2488000_770400 0.008
R_VDD15_4440 METAL6_2488000_770400 METAL6_2488000_772000 0.0032
R_VDD15_4441 METAL6_2488000_772000 METAL6_2488000_778400 0.0128
R_VDD15_4442 METAL6_2488000_778400 METAL6_2486900_778400 0.0022
R_VDD15_4443 METAL6_2486900_778400 METAL6_2481000_778400 0.0118
R_VDD15_4444 METAL6_2481000_778400 METAL6_2476000_778400 0.01
R_VDD15_4445 METAL6_2476000_778400 METAL6_2472600_778400 0.0068
R_VDD15_4446 METAL6_2472600_778400 METAL6_2469000_778400 0.0072
R_VDD15_4447 METAL6_2469000_778400 METAL6_2460600_778400 0.0168
R_VDD15_4448 METAL6_2460600_778400 METAL6_2448600_778400 0.024
R_VDD15_4449 METAL6_2448600_778400 METAL6_2446600_778400 0.004
R_VDD15_4450 METAL6_2446600_778400 METAL6_2436600_778400 0.02
R_VDD15_4451 METAL6_2436600_778400 METAL6_2419100_778400 0.035
R_VDD15_4452 METAL6_2419100_778400 METAL6_2407100_778400 0.024
R_VDD15_4453 METAL6_2407100_778400 METAL6_2405600_778400 0.003
R_VDD15_4454 METAL6_2405600_778400 METAL6_2402100_778400 0.007
R_VDD15_4455 METAL6_2402100_778400 METAL6_2395100_778400 0.014
R_VDD15_4456 METAL6_2395100_778400 METAL6_2393600_778400 0.003
R_VDD15_4457 METAL6_2393600_778400 METAL6_2383100_778400 0.021
R_VDD15_4458 METAL6_2383100_778400 METAL6_2381600_778400 0.003
R_VDD15_4459 METAL6_2381600_778400 METAL6_2371100_778400 0.021
R_VDD15_4460 METAL6_2371100_778400 METAL6_2369600_778400 0.003
R_VDD15_4461 METAL6_2369600_778400 METAL6_2365900_778400 0.0074
R_VDD15_4462 METAL6_2365900_778400 METAL6_2357600_778400 0.0166
R_VDD15_4463 METAL6_2357600_778400 METAL6_2351900_778400 0.0114
R_VDD15_4464 METAL6_2351900_778400 METAL6_2343700_778400 0.0164
R_VDD15_4465 METAL6_2343700_778400 METAL6_2310900_778400 0.0656
R_VDD15_4466 METAL6_2310900_778400 METAL6_2298900_778400 0.024
R_VDD15_4467 METAL6_2298900_778400 METAL6_2286900_778400 0.024
R_VDD15_4468 METAL6_2286900_778400 METAL6_2284600_778400 0.0046
R_VDD15_4469 METAL6_2284600_778400 METAL6_2284600_779200 0.0016
R_VDD15_4470 METAL6_2284600_779200 METAL6_2284600_782400 0.0064
R_VDD15_4471 METAL6_2284600_782400 METAL6_2284400_782400 0.0004
R_VDD15_4472 METAL6_2284400_782400 METAL6_2272600_782400 0.0236
R_VDD15_4473 METAL6_2272600_782400 METAL6_2272400_782400 0.0004
R_VDD15_4474 METAL6_2272400_782400 METAL6_2260600_782400 0.0236
R_VDD15_4475 METAL6_2260600_782400 METAL6_2260600_784500 0.0042
R_VDD15_4476 METAL6_2260600_784500 METAL6_2260600_788000 0.007
R_VDD15_4477 METAL6_2260600_788000 METAL6_2260600_790400 0.0048
R_VDD15_4478 METAL6_2260600_790400 METAL6_2260600_791200 0.0016
R_VDD15_4479 METAL6_2260600_791200 METAL6_2260600_794400 0.0064
R_VDD15_4480 METAL6_2260600_794400 METAL6_2260600_794800 0.0008
R_VDD15_4481 METAL6_2260600_794800 METAL6_2260600_800000 0.0104
R_VDD15_4482 METAL6_2260600_800000 METAL6_2260600_802400 0.0048
R_VDD15_4483 METAL6_2260600_802400 METAL6_2260600_803200 0.0016
R_VDD15_4484 METAL6_2260600_803200 METAL6_2260600_806400 0.0064
R_VDD15_4485 METAL6_2260600_806400 METAL6_2260600_808000 0.0032
R_VDD15_4486 METAL6_2260600_808000 METAL6_2260600_812000 0.008
R_VDD15_4487 METAL6_2260600_812000 METAL6_2260600_814400 0.0048
R_VDD15_4488 METAL6_2260600_814400 METAL6_2260600_818400 0.008
R_VDD15_4489 METAL6_2260600_818400 METAL6_2260600_820000 0.0032
R_VDD15_4490 METAL6_2260600_820000 METAL6_2260600_830400 0.0208
R_VDD15_4491 METAL6_2260600_830400 METAL6_2260600_832000 0.0032
R_VDD15_4492 METAL6_2260600_832000 METAL6_2260600_839500 0.015
R_VDD15_4493 METAL6_2260600_839500 METAL6_2260600_840700 0.0024
R_VDD15_4494 METAL6_2260600_840700 METAL6_2260600_851500 0.0216
R_VDD15_4495 METAL6_2260600_851500 METAL6_2260600_858200 0.0134
R_VDD15_4496 METAL6_2260600_858200 METAL6_2260600_863500 0.0106
R_VDD15_4497 METAL6_2260600_863500 METAL6_2260600_887000 0.047
R_VDD15_4498 METAL6_2260600_887000 METAL6_2260600_888000 0.002
R_VDD15_4499 METAL6_2260600_888000 METAL6_2260600_900000 0.024
R_VDD15_4500 METAL6_2260600_900000 METAL6_2260600_900400 0.0008
R_VDD15_4501 METAL6_2260600_900400 METAL6_2260600_912000 0.0232
R_VDD15_4502 METAL6_2260600_912000 METAL6_2260600_927300 0.0306
R_VDD15_4503 METAL6_2260600_927300 METAL6_2260600_947000 0.0394
R_VDD15_4504 METAL6_2260600_947000 METAL6_2260600_959000 0.024
R_VDD15_4505 METAL6_2260600_959000 METAL6_2260600_971000 0.024
R_VDD15_4506 METAL6_2260600_971000 METAL6_2260600_976000 0.01
R_VDD15_4507 METAL6_2260600_976000 METAL6_2260600_988000 0.024
R_VDD15_4508 METAL6_2260600_988000 METAL6_2260600_995000 0.014
R_VDD15_4509 METAL6_2260600_995000 METAL6_2260600_1000000 0.01
R_VDD15_4510 METAL6_2260600_1000000 METAL6_2260600_1007000 0.014
R_VDD15_4511 METAL6_2260600_1007000 METAL6_2260600_1012000 0.01
R_VDD15_4512 METAL6_2260600_1012000 METAL6_2260600_1014000 0.004
R_VDD15_4513 METAL6_2260600_1014000 METAL6_2260600_1019000 0.01
R_VDD15_4514 METAL6_2260600_1019000 METAL6_2260600_1026000 0.014
R_VDD15_4515 METAL6_2260600_1026000 METAL6_2260600_1029800 0.0076
R_VDD15_4516 METAL6_2260600_1029800 METAL6_2260600_1031000 0.0024
R_VDD15_4517 METAL6_2260600_1031000 METAL6_2260600_1035700 0.0094
R_VDD15_4518 METAL6_2260600_1035700 METAL6_2260600_1037400 0.0034
R_VDD15_4519 METAL6_2260600_1037400 METAL6_2260600_1038000 0.0012
R_VDD15_4520 METAL6_2260600_1038000 METAL6_2260600_1041800 0.0076
R_VDD15_4521 METAL6_2260600_1041800 METAL6_2260600_1042700 0.0018
R_VDD15_4522 METAL6_2260600_1042700 METAL6_2260600_1049400 0.0134
R_VDD15_4523 METAL6_2260600_1049400 METAL6_2260600_1049800 0.0008
R_VDD15_4524 METAL6_2260600_1049800 METAL6_2260600_1053800 0.008
R_VDD15_4525 METAL6_2260600_1053800 METAL6_2260600_1054700 0.0018
R_VDD15_4526 METAL6_2260600_1054700 METAL6_2260600_1061400 0.0134
R_VDD15_4527 METAL6_2260600_1061400 METAL6_2260600_1061800 0.0008
R_VDD15_4528 METAL6_2260600_1061800 METAL6_2260600_1066700 0.0098
R_VDD15_4529 METAL6_2260600_1066700 METAL6_2260600_1073800 0.0142
R_VDD15_4530 METAL6_2260600_1073800 METAL6_2260600_1086000 0.0244
R_VDD15_4531 METAL6_2260600_1086000 METAL6_2260600_1086300 0.0006
R_VDD15_4532 METAL6_2260600_1086300 METAL6_2260600_1086500 0.0004
R_VDD15_4533 METAL6_2260600_1086500 METAL6_2260600_1088000 0.003
R_VDD15_4534 METAL6_2260600_1088000 METAL6_2260600_1096800 0.0176
R_VDD15_4535 METAL6_2260600_1096800 METAL6_2260600_1098300 0.003
R_VDD15_4536 METAL6_2260600_1098300 METAL6_2260600_1098500 0.0004
R_VDD15_4537 METAL6_2260600_1098500 METAL6_2260600_1100000 0.003
R_VDD15_4538 METAL6_2260600_1100000 METAL6_2260600_1108800 0.0176
R_VDD15_4539 METAL6_2260600_1108800 METAL6_2260600_1110300 0.003
R_VDD15_4540 METAL6_2260600_1110300 METAL6_2260600_1110500 0.0004
R_VDD15_4541 METAL6_2260600_1110500 METAL6_2260600_1112000 0.003
R_VDD15_4542 METAL6_2260600_1112000 METAL6_2260600_1120800 0.0176
R_VDD15_4543 METAL6_2260600_1120800 METAL6_2260600_1122300 0.003
R_VDD15_4544 METAL6_2260600_1122300 METAL6_2260600_1129300 0.014
R_VDD15_4545 METAL6_2260600_1129300 METAL6_2260600_1134300 0.01
R_VDD15_4546 METAL6_2260600_1134300 METAL6_2260600_1141300 0.014
R_VDD15_4547 METAL6_2260600_1141300 METAL6_2260600_1153300 0.024
R_VDD15_4548 METAL6_2260600_1153300 METAL6_2260600_1160600 0.0146
R_VDD15_4549 METAL6_2260600_1160600 METAL6_2260600_1172600 0.024
R_VDD15_4550 METAL6_2260600_1172600 METAL6_2260600_1184600 0.024
R_VDD15_4551 METAL6_2260600_1184600 METAL6_2260600_1191600 0.014
R_VDD15_4552 METAL6_2260600_1191600 METAL6_2260600_1193700 0.0042
R_VDD15_4553 METAL6_2260600_1193700 METAL6_2260600_1193800 0.0002
R_VDD15_4554 METAL6_2260600_1193800 METAL6_2260600_1205700 0.0238
R_VDD15_4555 METAL6_2260600_1205700 METAL6_2260600_1217700 0.024
R_VDD15_4556 METAL6_2260600_1217700 METAL6_2260600_1223700 0.012
R_VDD15_4557 METAL6_2260600_1223700 METAL6_2260600_1229700 0.012
R_VDD15_4558 METAL6_2260600_1229700 METAL6_2260600_1235700 0.012
R_VDD15_4559 METAL6_2260600_1235700 METAL5_2260600_1235700 0.1
R_VDD15_4560 METAL5_2260600_1235700 METAL5_2272400_1235700 0.0472
R_VDD15_4561 METAL5_2272400_1235700 METAL5_2272600_1235700 0.0008
R_VDD15_4562 METAL5_2272600_1235700 METAL5_2284400_1235700 0.0472
R_VDD15_4563 METAL5_2284400_1235700 METAL5_2284600_1235700 0.0008
R_VDD15_4564 METAL5_2284600_1235700 METAL5_2284600_1238000 0.0092
R_VDD15_4565 METAL5_2284600_1238000 METAL5_2284600_1247700 0.0388
R_VDD15_4566 METAL5_2284600_1247700 METAL5_2284600_1250000 0.0092
R_VDD15_4567 METAL5_2284600_1250000 METAL5_2284600_1259700 0.0388
R_VDD15_4568 METAL5_2284600_1259700 METAL5_2284600_1262000 0.0092
R_VDD15_4569 METAL5_2284600_1262000 METAL5_2284600_1271700 0.0388
R_VDD15_4570 METAL5_2284600_1271700 METAL5_2284600_1273000 0.0052
R_VDD15_4571 METAL5_2284600_1273000 METAL5_2284600_1283700 0.0428
R_VDD15_4572 METAL5_2284600_1283700 METAL6_2284600_1283700 0.1
R_VDD15_4573 METAL6_2284600_1283700 METAL6_2284600_1295700 0.024
R_VDD15_4574 METAL6_2284600_1295700 METAL6_2284600_1314000 0.0366
R_VDD15_4575 METAL6_2284600_1314000 METAL6_2284600_1326000 0.024
R_VDD15_4576 METAL6_2284600_1326000 METAL6_2284600_1338000 0.024
R_VDD15_4577 METAL6_2284600_1338000 METAL6_2284600_1350000 0.024
R_VDD15_4578 METAL6_2284600_1350000 METAL6_2284600_1357000 0.014
R_VDD15_4579 METAL6_2284600_1357000 METAL6_2284600_1362000 0.01
R_VDD15_4580 METAL6_2284600_1362000 METAL6_2284600_1369000 0.014
R_VDD15_4581 METAL6_2284600_1369000 METAL6_2284600_1374000 0.01
R_VDD15_4582 METAL6_2284600_1374000 METAL6_2284600_1381000 0.014
R_VDD15_4583 METAL6_2284600_1381000 METAL6_2284600_1386600 0.0112
R_VDD15_4584 METAL6_2284600_1386600 METAL6_2284600_1393000 0.0128
R_VDD15_4585 METAL6_2284600_1393000 METAL6_2284600_1405000 0.024
R_VDD15_4586 METAL6_2284600_1405000 METAL6_2284600_1437700 0.0654
R_VDD15_4587 METAL6_2284600_1437700 METAL6_2284600_1449700 0.024
R_VDD15_4588 METAL6_2284600_1449700 METAL6_2284600_1461700 0.024
R_VDD15_4589 METAL6_2284600_1461700 METAL6_2284600_1492300 0.0612
R_VDD15_4590 METAL6_2284600_1492300 METAL6_2284600_1504300 0.024
R_VDD15_4591 METAL6_2284600_1504300 METAL6_2284600_1516300 0.024
R_VDD15_4592 METAL6_2284600_1516300 METAL6_2284600_1528300 0.024
R_VDD15_4593 METAL6_2284600_1528300 METAL5_2284600_1528300 0.1
R_VDD15_4594 METAL5_2284600_1528300 METAL5_2284600_1540300 0.048
R_VDD15_4595 METAL5_2284600_1540300 METAL5_2284600_1552300 0.048
R_VDD15_4596 METAL5_2284600_1552300 METAL6_2284600_1552300 0.1
R_VDD15_4597 METAL6_2284600_1552300 METAL6_2284600_1554500 0.0044
R_VDD15_4598 METAL6_2284600_1554500 METAL6_2284600_1564300 0.0196
R_VDD15_4599 METAL6_2284600_1564300 METAL6_2284600_1571300 0.014
R_VDD15_4600 METAL6_2284600_1571300 METAL6_2284600_1576300 0.01
R_VDD15_4601 METAL6_2284600_1576300 METAL6_2284600_1714500 0.2764
R_VDD15_4602 METAL6_2284600_1714500 METAL6_2284600_1720500 0.012
R_VDD15_4603 METAL6_2284600_1720500 METAL6_2284600_1726500 0.012
R_VDD15_4604 METAL6_2284600_1726500 METAL6_2284600_1731700 0.0104
R_VDD15_4605 METAL6_2284600_1731700 METAL6_2284600_1738500 0.0136
R_VDD15_4606 METAL6_2284600_1738500 METAL6_2284600_1750500 0.024
R_VDD15_4607 METAL6_2284600_1750500 METAL6_2284600_1762500 0.024
R_VDD15_4608 METAL6_2284600_1762500 METAL6_2284600_1774500 0.024
R_VDD15_4609 METAL6_2284600_1774500 METAL6_2284600_1802500 0.056
R_VDD15_4610 METAL6_2284600_1802500 METAL6_2284600_1814500 0.024
R_VDD15_4611 METAL6_2284600_1814500 METAL6_2284600_1826500 0.024
R_VDD15_4612 METAL6_2284600_1826500 METAL6_2284600_1838500 0.024
R_VDD15_4613 METAL6_2284600_1838500 METAL6_2284600_1852300 0.0276
R_VDD15_4614 METAL6_2284600_1852300 METAL6_2284600_1866300 0.028
R_VDD15_4615 METAL6_2284600_1866300 METAL6_2284600_1902500 0.0724
R_VDD15_4616 METAL6_2284600_1902500 METAL6_2284600_1914500 0.024
R_VDD15_4617 METAL6_2284600_1914500 METAL6_2284600_1926500 0.024
R_VDD15_4618 METAL6_2284600_1926500 METAL6_2284600_1938500 0.024
R_VDD15_4619 METAL6_2284600_1938500 METAL6_2284600_1940500 0.004
R_VDD15_4620 METAL6_2284600_1940500 METAL6_2284600_1950500 0.02
R_VDD15_4621 METAL6_2284600_1950500 METAL6_2284600_1951000 0.001
R_VDD15_4622 METAL6_2284600_1951000 METAL6_2284600_1952500 0.003
R_VDD15_4623 METAL6_2284600_1952500 METAL6_2284600_1963000 0.021
R_VDD15_4624 METAL6_2284600_1963000 METAL6_2284600_1964500 0.003
R_VDD15_4625 METAL6_2284600_1964500 METAL6_2284600_1975000 0.021
R_VDD15_4626 METAL6_2284600_1975000 METAL6_2284600_1976500 0.003
R_VDD15_4627 METAL6_2284600_1976500 METAL6_2284600_1987000 0.021
R_VDD15_4628 METAL6_2284600_1987000 METAL6_2284600_2014500 0.055
R_VDD15_4629 METAL6_2284600_2014500 METAL6_2284600_2026500 0.024
R_VDD15_4630 METAL6_2284600_2026500 METAL6_2284600_2038500 0.024
R_VDD15_4631 METAL6_2284600_2038500 METAL6_2284600_2114500 0.152
R_VDD15_4632 METAL6_2284600_2114500 METAL6_2284600_2126500 0.024
R_VDD15_4633 METAL6_2284600_2126500 METAL6_2284600_2138500 0.024
R_VDD15_4634 METAL6_2284600_2138500 METAL6_2284600_2147300 0.0176
R_VDD15_4635 METAL6_2284600_2147300 METAL6_2284600_2154300 0.014
R_VDD15_4636 METAL6_2284600_2154300 METAL6_2284600_2163000 0.0174
R_VDD15_4637 METAL6_2284600_2163000 METAL6_2284600_2166300 0.0066
R_VDD15_4638 METAL6_2284600_2166300 METAL6_2284600_2175000 0.0174
R_VDD15_4639 METAL6_2284600_2175000 METAL6_2284600_2178300 0.0066
R_VDD15_4640 METAL6_2284600_2178300 METAL6_2284600_2187000 0.0174
R_VDD15_4641 METAL6_2284600_2187000 METAL6_2284600_2190300 0.0066
R_VDD15_4642 METAL6_2284600_2190300 METAL6_2284600_2222500 0.0644
R_VDD15_4643 METAL6_2284600_2222500 METAL6_2284600_2234500 0.024
R_VDD15_4644 METAL6_2284600_2234500 METAL6_2284600_2246500 0.024
R_VDD15_4645 METAL6_2284600_2246500 METAL6_2284600_2268500 0.044
R_VDD15_4646 METAL6_2284600_2268500 METAL6_2284600_2288000 0.039
R_VDD15_4647 METAL6_2284600_2288000 METAL6_2284600_2300000 0.024
R_VDD15_4648 METAL6_2284600_2300000 METAL6_2284600_2312000 0.024
R_VDD15_4649 METAL6_2284600_2312000 METAL6_2284600_2338000 0.052
R_VDD15_4650 METAL6_2284600_2338000 METAL6_2284600_2350000 0.024
R_VDD15_4651 METAL6_2284600_2350000 METAL6_2284600_2352000 0.004
R_VDD15_4652 METAL6_2284600_2352000 METAL6_2284400_2352000 0.0004
R_VDD15_4653 METAL6_2284400_2352000 METAL6_2272600_2352000 0.0236
R_VDD15_4654 METAL6_2272600_2352000 METAL6_2272400_2352000 0.0004
R_VDD15_4655 METAL6_2272400_2352000 METAL5_2272400_2352000 0.1
R_VDD15_4656 METAL5_2272400_2352000 METAL5_2260600_2352000 0.0472
R_VDD15_4657 METAL5_2260600_2352000 METAL5_2260400_2352000 0.0008
R_VDD15_4658 METAL5_2260400_2352000 METAL5_2258600_2352000 0.0072
R_VDD15_4659 METAL5_2258600_2352000 METAL5_2248700_2352000 0.0396
R_VDD15_4660 METAL5_2248700_2352000 METAL5_2248600_2352000 0.0004
R_VDD15_4661 METAL5_2248600_2352000 METAL5_2248400_2352000 0.0008
R_VDD15_4662 METAL5_2248400_2352000 METAL5_2246600_2352000 0.0072
R_VDD15_4663 METAL5_2246600_2352000 METAL5_2236700_2352000 0.0396
R_VDD15_4664 METAL5_2236700_2352000 METAL5_2236600_2352000 0.0004
R_VDD15_4665 METAL5_2236600_2352000 METAL5_2234600_2352000 0.008
R_VDD15_4666 METAL5_2234600_2352000 METAL5_2224700_2352000 0.0396
R_VDD15_4667 METAL5_2224700_2352000 METAL5_2222600_2352000 0.0084
R_VDD15_4668 METAL5_2222600_2352000 METAL5_2221900_2352000 0.0028
R_VDD15_4669 METAL5_2221900_2352000 METAL5_2212700_2352000 0.0368
R_VDD15_4670 METAL5_2212700_2352000 METAL5_2200700_2352000 0.048
R_VDD15_4671 METAL5_2200700_2352000 METAL5_2189900_2352000 0.0432
R_VDD15_4672 METAL5_2189900_2352000 METAL5_2188700_2352000 0.0048
R_VDD15_4673 METAL5_2188700_2352000 METAL5_2177900_2352000 0.0432
R_VDD15_4674 METAL5_2177900_2352000 METAL5_2176700_2352000 0.0048
R_VDD15_4675 METAL5_2176700_2352000 METAL5_2165900_2352000 0.0432
R_VDD15_4676 METAL5_2165900_2352000 METAL5_2165400_2352000 0.002
R_VDD15_4677 METAL5_2165400_2352000 METAL5_2153900_2352000 0.046
R_VDD15_4678 METAL5_2153900_2352000 METAL5_2153400_2352000 0.002
R_VDD15_4679 METAL5_2153400_2352000 METAL5_2151900_2352000 0.006
R_VDD15_4680 METAL5_2151900_2352000 METAL5_2141900_2352000 0.04
R_VDD15_4681 METAL5_2141900_2352000 METAL5_2141400_2352000 0.002
R_VDD15_4682 METAL5_2141400_2352000 METAL5_2129900_2352000 0.046
R_VDD15_4683 METAL5_2129900_2352000 METAL6_2129900_2352000 0.1
R_VDD15_4684 METAL6_2129900_2352000 METAL6_2129700_2352000 0.0004
R_VDD15_4685 METAL6_2129700_2352000 METAL6_2125600_2352000 0.0082
R_VDD15_4686 METAL6_2125600_2352000 METAL6_2121400_2352000 0.0084
R_VDD15_4687 METAL6_2121400_2352000 METAL6_2117900_2352000 0.007
R_VDD15_4688 METAL6_2117900_2352000 METAL6_2113600_2352000 0.0086
R_VDD15_4689 METAL6_2113600_2352000 METAL6_2101900_2352000 0.0234
R_VDD15_4690 METAL6_2101900_2352000 METAL6_2101900_2353000 0.002
R_VDD15_4691 METAL6_2101900_2353000 METAL6_2101600_2353000 0.0006
R_VDD15_4692 METAL6_2101600_2353000 METAL6_2089900_2353000 0.0234
R_VDD15_4693 METAL6_2089900_2353000 METAL6_2079700_2353000 0.0204
R_VDD15_4694 METAL6_2079700_2353000 METAL6_2077900_2353000 0.0036
R_VDD15_4695 METAL6_2077900_2353000 METAL6_2067700_2353000 0.0204
R_VDD15_4696 METAL6_2067700_2353000 METAL6_2060600_2353000 0.0142
R_VDD15_4697 METAL6_2060600_2353000 METAL6_2055700_2353000 0.0098
R_VDD15_4698 METAL6_2055700_2353000 METAL6_2046800_2353000 0.0178
R_VDD15_4699 METAL6_2046800_2353000 METAL6_2046600_2353000 0.0004
R_VDD15_4700 METAL6_2046600_2353000 METAL6_2046400_2353000 0.0004
R_VDD15_4701 METAL6_2046400_2353000 METAL6_2043700_2353000 0.0054
R_VDD15_4702 METAL6_2043700_2353000 METAL6_2031700_2353000 0.024
R_VDD15_4703 METAL6_2031700_2353000 METAL6_2030900_2353000 0.0016
R_VDD15_4704 METAL6_2030900_2353000 METAL6_2026400_2353000 0.009
R_VDD15_4705 METAL6_2026400_2353000 METAL6_2021200_2353000 0.0104
R_VDD15_4706 METAL6_2021200_2353000 METAL6_2019700_2353000 0.003
R_VDD15_4707 METAL6_2019700_2353000 METAL6_2018900_2353000 0.0016
R_VDD15_4708 METAL6_2018900_2353000 METAL6_2014400_2353000 0.009
R_VDD15_4709 METAL6_2014400_2353000 METAL6_2012000_2353000 0.0048
R_VDD15_4710 METAL6_2012000_2353000 METAL6_2006900_2353000 0.0102
R_VDD15_4711 METAL6_2006900_2353000 METAL6_2002400_2353000 0.009
R_VDD15_4712 METAL6_2002400_2353000 METAL6_2000000_2353000 0.0048
R_VDD15_4713 METAL6_2000000_2353000 METAL6_1988000_2353000 0.024
R_VDD15_4714 METAL6_1988000_2353000 METAL6_1951900_2353000 0.0722
R_VDD15_4715 METAL6_1951900_2353000 METAL6_1951800_2353000 0.0002
R_VDD15_4716 METAL6_1951800_2353000 METAL6_1939800_2353000 0.024
R_VDD15_4717 METAL6_1939800_2353000 METAL6_1931200_2353000 0.0172
R_VDD15_4718 METAL6_1931200_2353000 METAL6_1927800_2353000 0.0068
R_VDD15_4719 METAL6_1927800_2353000 METAL6_1926200_2353000 0.0032
R_VDD15_4720 METAL6_1926200_2353000 METAL6_1925600_2353000 0.0012
R_VDD15_4721 METAL6_1925600_2353000 METAL6_1919200_2353000 0.0128
R_VDD15_4722 METAL6_1919200_2353000 METAL6_1913600_2353000 0.0112
R_VDD15_4723 METAL6_1913600_2353000 METAL6_1907400_2353000 0.0124
R_VDD15_4724 METAL6_1907400_2353000 METAL6_1907200_2353000 0.0004
R_VDD15_4725 METAL6_1907200_2353000 METAL6_1901600_2353000 0.0112
R_VDD15_4726 METAL6_1901600_2353000 METAL6_1900700_2353000 0.0018
R_VDD15_4727 METAL6_1900700_2353000 METAL6_1895200_2353000 0.011
R_VDD15_4728 METAL6_1895200_2353000 METAL6_1889400_2353000 0.0116
R_VDD15_4729 METAL6_1889400_2353000 METAL6_1888700_2353000 0.0014
R_VDD15_4730 METAL6_1888700_2353000 METAL6_1883200_2353000 0.011
R_VDD15_4731 METAL6_1883200_2353000 METAL6_1883200_2362000 0.018
R_VDD15_4732 METAL6_1883200_2362000 METAL6_1877400_2362000 0.0116
R_VDD15_4733 METAL6_1877400_2362000 METAL6_1877400_2364000 0.004
R_VDD15_4734 METAL6_1877400_2364000 METAL6_1877400_2365000 0.002
R_VDD15_4735 METAL6_1877400_2365000 METAL6_1876700_2365000 0.0014
R_VDD15_4736 METAL6_1876700_2365000 METAL6_1874700_2365000 0.004
R_VDD15_4737 METAL6_1874700_2365000 METAL6_1870600_2365000 0.0082
R_VDD15_4738 METAL6_1870600_2365000 METAL6_1865400_2365000 0.0104
R_VDD15_4739 METAL6_1865400_2365000 METAL6_1864700_2365000 0.0014
R_VDD15_4740 METAL6_1864700_2365000 METAL6_1858600_2365000 0.0122
R_VDD15_4741 METAL6_1858600_2365000 METAL6_1858400_2365000 0.0004
R_VDD15_4742 METAL6_1858400_2365000 METAL6_1853400_2365000 0.01
R_VDD15_4743 METAL6_1853400_2365000 METAL6_1852700_2365000 0.0014
R_VDD15_4744 METAL6_1852700_2365000 METAL6_1846800_2365000 0.0118
R_VDD15_4745 METAL6_1846800_2365000 METAL6_1846600_2365000 0.0004
R_VDD15_4746 METAL6_1846600_2365000 METAL6_1846400_2365000 0.0004
R_VDD15_4747 METAL6_1846400_2365000 METAL6_1844800_2365000 0.0032
R_VDD15_4748 METAL6_1844800_2365000 METAL6_1834600_2365000 0.0204
R_VDD15_4749 METAL6_1834600_2365000 METAL6_1834400_2365000 0.0004
R_VDD15_4750 METAL6_1834400_2365000 METAL6_1832800_2365000 0.0032
R_VDD15_4751 METAL6_1832800_2365000 METAL6_1822600_2365000 0.0204
R_VDD15_4752 METAL6_1822600_2365000 METAL6_1822400_2365000 0.0004
R_VDD15_4753 METAL6_1822400_2365000 METAL6_1820800_2365000 0.0032
R_VDD15_4754 METAL6_1820800_2365000 METAL6_1812000_2365000 0.0176
R_VDD15_4755 METAL6_1812000_2365000 METAL6_1800000_2365000 0.024
R_VDD15_4756 METAL6_1800000_2365000 METAL6_1788000_2365000 0.024
R_VDD15_4757 METAL6_1788000_2365000 METAL6_1755700_2365000 0.0646
R_VDD15_4758 METAL6_1755700_2365000 METAL6_1753800_2365000 0.0038
R_VDD15_4759 METAL6_1753800_2365000 METAL6_1751800_2365000 0.004
R_VDD15_4760 METAL6_1751800_2365000 METAL6_1751400_2365000 0.0008
R_VDD15_4761 METAL6_1751400_2365000 METAL6_1744000_2365000 0.0148
R_VDD15_4762 METAL6_1744000_2365000 METAL6_1743700_2365000 0.0006
R_VDD15_4763 METAL6_1743700_2365000 METAL6_1741800_2365000 0.0038
R_VDD15_4764 METAL6_1741800_2365000 METAL5_1741800_2365000 0.1
R_VDD15_4765 METAL5_1741800_2365000 METAL5_1741800_2376000 0.044
R_VDD15_4766 METAL5_1741800_2376000 METAL5_1741800_2377000 0.004
R_VDD15_4767 METAL5_1741800_2377000 METAL5_1741800_2388000 0.044
R_VDD15_4768 METAL5_1741800_2388000 METAL5_1741800_2389000 0.004
R_VDD15_4769 METAL5_1741800_2389000 METAL5_1741800_2400000 0.044
R_VDD15_4770 METAL5_1741800_2400000 METAL5_1741800_2401000 0.004
R_VDD15_4771 METAL5_1741800_2401000 METAL5_1741800_2407000 0.024
R_VDD15_4772 METAL5_1741800_2407000 METAL5_1741800_2412000 0.02
R_VDD15_4773 METAL5_1741800_2412000 METAL5_1741800_2413000 0.004
R_VDD15_4774 METAL5_1741800_2413000 METAL5_1741800_2424000 0.044
R_VDD15_4775 METAL5_1741800_2424000 METAL5_1739800_2424000 0.008
R_VDD15_4776 METAL5_1739800_2424000 METAL5_1731700_2424000 0.0324
R_VDD15_4777 METAL5_1731700_2424000 METAL5_1729800_2424000 0.0076
R_VDD15_4778 METAL5_1729800_2424000 METAL6_1729800_2424000 0.1
R_VDD15_4779 METAL6_1729800_2424000 METAL6_1729800_2438000 0.028
R_VDD15_4780 METAL6_1729800_2438000 METAL6_1729800_2444000 0.012
R_VDD15_4781 METAL6_1729800_2444000 METAL6_1729800_2450000 0.012
R_VDD15_4782 METAL6_1729800_2450000 METAL6_1729800_2456000 0.012
R_VDD15_4783 METAL6_1729800_2456000 METAL6_1729800_2462000 0.012
R_VDD15_4784 METAL6_1729800_2462000 METAL6_1729800_2468000 0.012
R_VDD15_4785 METAL6_1729800_2468000 METAL6_1729800_2481000 0.026
R_VDD15_4786 METAL6_1729800_2481000 METAL6_1729800_2493000 0.024
R_VDD15_4787 METAL6_1729800_2493000 METAL6_1729800_2505000 0.024
R_VDD15_4788 METAL6_1729800_2505000 METAL6_1729800_2512000 0.014
R_VDD15_4789 METAL6_1729800_2512000 METAL6_1729800_2524000 0.024
R_VDD15_4790 METAL6_1729800_2524000 METAL6_1729800_2529700 0.0114
R_VDD15_4791 METAL6_1729800_2529700 METAL6_1729800_2536000 0.0126
R_VDD15_4792 METAL6_1919200_2656000 METAL6_1913600_2656000 0.0112
R_VDD15_4793 METAL6_1913600_2656000 METAL6_1907400_2656000 0.0124
R_VDD15_4794 METAL6_1907400_2656000 METAL6_1907200_2656000 0.0004
R_VDD15_4795 METAL5_3490500_200000 METAL5_3478500_200000 0.048
R_VDD15_4796 METAL5_3478500_200000 METAL5_3477000_200000 0.006
R_VDD15_4797 METAL5_3477000_200000 METAL5_3466500_200000 0.042
R_VDD15_4798 METAL5_3466500_200000 METAL5_3465000_200000 0.006
R_VDD15_4799 METAL5_3465000_200000 METAL5_3454500_200000 0.042
R_VDD15_4800 METAL5_3454500_200000 METAL6_3454500_200000 0.1
R_VDD15_4801 METAL6_3454500_200000 METAL6_3454500_212000 0.024
R_VDD15_4802 METAL6_3454500_212000 METAL6_3454500_248300 0.0726
R_VDD15_4803 METAL6_3454500_248300 METAL6_3454500_260300 0.024
R_VDD15_4804 METAL6_3454500_260300 METAL6_3454500_263000 0.0054
R_VDD15_4805 METAL6_3454500_263000 METAL6_3453000_263000 0.003
R_VDD15_4806 METAL6_3453000_263000 METAL6_3336400_263000 0.2332
R_VDD15_4807 METAL6_3336400_263000 METAL6_3324400_263000 0.024
R_VDD15_4808 METAL6_3324400_263000 METAL6_3312400_263000 0.024
R_VDD15_4809 METAL6_3312400_263000 METAL6_3312000_263000 0.0008
R_VDD15_4810 METAL6_3312000_263000 METAL6_3305400_263000 0.0132
R_VDD15_4811 METAL6_3305400_263000 METAL6_3300400_263000 0.01
R_VDD15_4812 METAL6_3300400_263000 METAL6_3300000_263000 0.0008
R_VDD15_4813 METAL6_3300000_263000 METAL6_3288400_263000 0.0232
R_VDD15_4814 METAL6_3288400_263000 METAL6_3288400_272300 0.0186
R_VDD15_4815 METAL6_3288400_272300 METAL6_3288400_275000 0.0054
R_VDD15_4816 METAL6_3288400_275000 METAL6_3288400_279300 0.0086
R_VDD15_4817 METAL6_3288400_279300 METAL6_3288400_287000 0.0154
R_VDD15_4818 METAL6_3288400_287000 METAL6_3288400_288000 0.002
R_VDD15_4819 METAL6_3288400_288000 METAL6_3288400_299000 0.022
R_VDD15_4820 METAL6_3288400_299000 METAL6_3288400_300000 0.002
R_VDD15_4821 METAL6_3288400_300000 METAL6_3288400_312000 0.024
R_VDD15_4822 METAL6_3288400_312000 METAL6_3288400_355300 0.0866
R_VDD15_4823 METAL6_3288400_355300 METAL6_3288400_362300 0.014
R_VDD15_4824 METAL6_3288400_362300 METAL6_3288400_374300 0.024
R_VDD15_4825 METAL6_3288400_374300 METAL6_3288400_378800 0.009
R_VDD15_4826 METAL6_3288400_378800 METAL6_3288000_378800 0.0008
R_VDD15_4827 METAL6_3288000_378800 METAL6_3287000_378800 0.002
R_VDD15_4828 METAL6_3287000_378800 METAL6_3275000_378800 0.024
R_VDD15_4829 METAL6_3275000_378800 METAL6_3263000_378800 0.024
R_VDD15_4830 METAL6_3263000_378800 METAL6_3260400_378800 0.0052
R_VDD15_4831 METAL6_3260400_378800 METAL6_3243500_378800 0.0338
R_VDD15_4832 METAL6_3243500_378800 METAL6_3231500_378800 0.024
R_VDD15_4833 METAL6_3231500_378800 METAL6_3219500_378800 0.024
R_VDD15_4834 METAL6_3219500_378800 METAL6_3212500_378800 0.014
R_VDD15_4835 METAL6_3212500_378800 METAL6_3212000_378800 0.001
R_VDD15_4836 METAL6_3212000_378800 METAL6_3200000_378800 0.024
R_VDD15_4837 METAL6_3200000_378800 METAL6_3188000_378800 0.024
R_VDD15_4838 METAL6_3188000_378800 METAL6_3179500_378800 0.017
R_VDD15_4839 METAL6_3179500_378800 METAL6_3167500_378800 0.024
R_VDD15_4840 METAL6_3167500_378800 METAL6_3165900_378800 0.0032
R_VDD15_4841 METAL6_3165900_378800 METAL6_3155500_378800 0.0208
R_VDD15_4842 METAL6_3155500_378800 METAL6_3124000_378800 0.063
R_VDD15_4843 METAL6_3124000_378800 METAL6_3112000_378800 0.024
R_VDD15_4844 METAL6_3112000_378800 METAL6_3110900_378800 0.0022
R_VDD15_4845 METAL6_3110900_378800 METAL6_3100000_378800 0.0218
R_VDD15_4846 METAL6_3100000_378800 METAL6_3100000_386300 0.015
R_VDD15_4847 METAL6_3100000_386300 METAL6_3100000_388000 0.0034
R_VDD15_4848 METAL6_3100000_388000 METAL6_3100000_390800 0.0056
R_VDD15_4849 METAL6_3100000_390800 METAL6_3100000_400000 0.0184
R_VDD15_4850 METAL6_3100000_400000 METAL6_3100000_402800 0.0056
R_VDD15_4851 METAL6_3100000_402800 METAL6_3100000_412000 0.0184
R_VDD15_4852 METAL6_3100000_412000 METAL6_3100000_414800 0.0056
R_VDD15_4853 METAL6_3100000_414800 METAL6_3100000_425000 0.0204
R_VDD15_4854 METAL6_3100000_425000 METAL6_3099200_425000 0.0016
R_VDD15_4855 METAL6_3099200_425000 METAL6_3098900_425000 0.0006
R_VDD15_4856 METAL6_3098900_425000 METAL6_3088000_425000 0.0218
R_VDD15_4857 METAL6_3088000_425000 METAL6_3088000_437000 0.024
R_VDD15_4858 METAL6_3088000_437000 METAL6_3088000_449000 0.024
R_VDD15_4859 METAL6_3088000_449000 METAL6_3088000_453000 0.008
R_VDD15_4860 METAL6_3088000_453000 METAL6_3088000_461000 0.016
R_VDD15_4861 METAL6_3088000_461000 METAL6_3088000_465000 0.008
R_VDD15_4862 METAL6_3088000_465000 METAL6_3088000_471000 0.012
R_VDD15_4863 METAL6_3088000_471000 METAL6_3087200_471000 0.0016
R_VDD15_4864 METAL6_3087200_471000 METAL6_3086900_471000 0.0006
R_VDD15_4865 METAL6_3086900_471000 METAL6_3076000_471000 0.0218
R_VDD15_4866 METAL6_3076000_471000 METAL6_3075200_471000 0.0016
R_VDD15_4867 METAL6_3075200_471000 METAL6_3068200_471000 0.014
R_VDD15_4868 METAL6_3068200_471000 METAL6_3064000_471000 0.0084
R_VDD15_4869 METAL6_3064000_471000 METAL6_3064000_477000 0.012
R_VDD15_4870 METAL6_3064000_477000 METAL6_3064000_480400 0.0068
R_VDD15_4871 METAL6_3064000_480400 METAL6_3060600_480400 0.0068
R_VDD15_4872 METAL6_3060600_480400 METAL6_3023200_480400 0.0748
R_VDD15_4873 METAL6_3023200_480400 METAL6_3012000_480400 0.0224
R_VDD15_4874 METAL6_3012000_480400 METAL6_3006200_480400 0.0116
R_VDD15_4875 METAL6_3006200_480400 METAL6_3000000_480400 0.0124
R_VDD15_4876 METAL6_3000000_480400 METAL6_2994200_480400 0.0116
R_VDD15_4877 METAL6_2994200_480400 METAL6_2994200_483000 0.0052
R_VDD15_4878 METAL6_2994200_483000 METAL6_2993000_483000 0.0024
R_VDD15_4879 METAL6_2993000_483000 METAL6_2988000_483000 0.01
R_VDD15_4880 METAL6_2988000_483000 METAL6_2982200_483000 0.0116
R_VDD15_4881 METAL6_2982200_483000 METAL6_2975200_483000 0.014
R_VDD15_4882 METAL6_2975200_483000 METAL6_2965900_483000 0.0186
R_VDD15_4883 METAL6_2965900_483000 METAL6_2951900_483000 0.028
R_VDD15_4884 METAL6_2951900_483000 METAL6_2930200_483000 0.0434
R_VDD15_4885 METAL6_2930200_483000 METAL6_2930200_488000 0.01
R_VDD15_4886 METAL6_2930200_488000 METAL6_2930200_495000 0.014
R_VDD15_4887 METAL6_2930200_495000 METAL6_2925600_495000 0.0092
R_VDD15_4888 METAL6_2925600_495000 METAL6_2913600_495000 0.024
R_VDD15_4889 METAL6_2913600_495000 METAL6_2910900_495000 0.0054
R_VDD15_4890 METAL6_2910900_495000 METAL6_2901600_495000 0.0186
R_VDD15_4891 METAL6_2901600_495000 METAL6_2898900_495000 0.0054
R_VDD15_4892 METAL6_2898900_495000 METAL6_2897100_495000 0.0036
R_VDD15_4893 METAL6_2897100_495000 METAL6_2886900_495000 0.0204
R_VDD15_4894 METAL6_2886900_495000 METAL6_2874800_495000 0.0242
R_VDD15_4895 METAL6_2874800_495000 METAL6_2862800_495000 0.024
R_VDD15_4896 METAL6_2862800_495000 METAL6_2860600_495000 0.0044
R_VDD15_4897 METAL6_2860600_495000 METAL6_2850800_495000 0.0196
R_VDD15_4898 METAL6_2850800_495000 METAL6_2846600_495000 0.0084
R_VDD15_4899 METAL6_2846600_495000 METAL6_2843800_495000 0.0056
R_VDD15_4900 METAL6_2843800_495000 METAL6_2812000_495000 0.0636
R_VDD15_4901 METAL6_2812000_495000 METAL6_2805600_495000 0.0128
R_VDD15_4902 METAL6_2805600_495000 METAL6_2800000_495000 0.0112
R_VDD15_4903 METAL6_2800000_495000 METAL6_2798800_495000 0.0024
R_VDD15_4904 METAL6_2798800_495000 METAL6_2793600_495000 0.0104
R_VDD15_4905 METAL6_2793600_495000 METAL6_2788000_495000 0.0112
R_VDD15_4906 METAL6_2788000_495000 METAL6_2781600_495000 0.0128
R_VDD15_4907 METAL6_2781600_495000 METAL6_2765900_495000 0.0314
R_VDD15_4908 METAL6_2765900_495000 METAL6_2751900_495000 0.028
R_VDD15_4909 METAL6_2751900_495000 METAL6_2728200_495000 0.0474
R_VDD15_4910 METAL6_2728200_495000 METAL6_2710900_495000 0.0346
R_VDD15_4911 METAL6_2710900_495000 METAL6_2698900_495000 0.024
R_VDD15_4912 METAL6_2698900_495000 METAL6_2686900_495000 0.024
R_VDD15_4913 METAL6_2686900_495000 METAL6_2683200_495000 0.0074
R_VDD15_4914 METAL6_2683200_495000 METAL6_2676200_495000 0.014
R_VDD15_4915 METAL6_2676200_495000 METAL6_2664200_495000 0.024
R_VDD15_4916 METAL6_2664200_495000 METAL6_2660600_495000 0.0072
R_VDD15_4917 METAL6_2660600_495000 METAL6_2652200_495000 0.0168
R_VDD15_4918 METAL6_2652200_495000 METAL6_2646600_495000 0.0112
R_VDD15_4919 METAL6_2646600_495000 METAL6_2592400_495000 0.1084
R_VDD15_4920 METAL6_2592400_495000 METAL6_2580400_495000 0.024
R_VDD15_4921 METAL6_2580400_495000 METAL6_2568400_495000 0.024
R_VDD15_4922 METAL6_2568400_495000 METAL6_2565900_495000 0.005
R_VDD15_4923 METAL6_2565900_495000 METAL6_2556400_495000 0.019
R_VDD15_4924 METAL6_2556400_495000 METAL6_2551900_495000 0.009
R_VDD15_4925 METAL6_2551900_495000 METAL6_2537600_495000 0.0286
R_VDD15_4926 METAL6_2537600_495000 METAL6_2535400_495000 0.0044
R_VDD15_4927 METAL6_2535400_495000 METAL6_2529000_495000 0.0128
R_VDD15_4928 METAL6_2529000_495000 METAL6_2528400_495000 0.0012
R_VDD15_4929 METAL6_2528400_495000 METAL6_2525600_495000 0.0056
R_VDD15_4930 METAL6_2525600_495000 METAL6_2524000_495000 0.0032
R_VDD15_4931 METAL6_2524000_495000 METAL6_2517000_495000 0.014
R_VDD15_4932 METAL6_2517000_495000 METAL6_2516400_495000 0.0012
R_VDD15_4933 METAL6_2516400_495000 METAL6_2513600_495000 0.0056
R_VDD15_4934 METAL6_2513600_495000 METAL6_2512000_495000 0.0032
R_VDD15_4935 METAL6_2512000_495000 METAL6_2510900_495000 0.0022
R_VDD15_4936 METAL6_2510900_495000 METAL6_2505000_495000 0.0118
R_VDD15_4937 METAL6_2505000_495000 METAL6_2505000_500000 0.01
R_VDD15_4938 METAL6_2505000_500000 METAL6_2505000_504000 0.008
R_VDD15_4939 METAL6_2505000_504000 METAL6_2505000_507000 0.006
R_VDD15_4940 METAL6_2505000_507000 METAL6_2505000_507800 0.0016
R_VDD15_4941 METAL6_2505000_507800 METAL6_2505000_512000 0.0084
R_VDD15_4942 METAL6_2505000_512000 METAL6_2505000_516000 0.008
R_VDD15_4943 METAL6_2505000_516000 METAL6_2505000_519000 0.006
R_VDD15_4944 METAL6_2505000_519000 METAL6_2505000_520200 0.0024
R_VDD15_4945 METAL6_2505000_520200 METAL6_2505000_528000 0.0156
R_VDD15_4946 METAL6_2505000_528000 METAL6_2505000_532200 0.0084
R_VDD15_4947 METAL6_2505000_532200 METAL6_2505000_535400 0.0064
R_VDD15_4948 METAL6_2505000_535400 METAL6_2505000_544200 0.0176
R_VDD15_4949 METAL6_2505000_544200 METAL6_2505000_547400 0.0064
R_VDD15_4950 METAL6_2505000_547400 METAL6_2505000_556200 0.0176
R_VDD15_4951 METAL6_2505000_556200 METAL6_2505000_559400 0.0064
R_VDD15_4952 METAL6_2505000_559400 METAL6_2505000_562400 0.006
R_VDD15_4953 METAL6_2505000_562400 METAL6_2504400_562400 0.0012
R_VDD15_4954 METAL6_2504400_562400 METAL6_2501600_562400 0.0056
R_VDD15_4955 METAL6_2501600_562400 METAL6_2501600_573000 0.0212
R_VDD15_4956 METAL6_2501600_573000 METAL6_2500000_573000 0.0032
R_VDD15_4957 METAL6_2500000_573000 METAL6_2500000_574400 0.0028
R_VDD15_4958 METAL6_2500000_574400 METAL6_2500000_579800 0.0108
R_VDD15_4959 METAL6_2500000_579800 METAL6_2500000_586400 0.0132
R_VDD15_4960 METAL6_2500000_586400 METAL6_2500000_588000 0.0032
R_VDD15_4961 METAL6_2500000_588000 METAL6_2500000_598400 0.0208
R_VDD15_4962 METAL6_2500000_598400 METAL6_2500000_600000 0.0032
R_VDD15_4963 METAL6_2500000_600000 METAL6_2500000_612000 0.024
R_VDD15_4964 METAL6_2500000_612000 METAL6_2500000_637800 0.0516
R_VDD15_4965 METAL6_2500000_637800 METAL6_2500000_641400 0.0072
R_VDD15_4966 METAL6_2500000_641400 METAL6_2500000_649800 0.0168
R_VDD15_4967 METAL6_2500000_649800 METAL6_2500000_653400 0.0072
R_VDD15_4968 METAL6_2500000_653400 METAL6_2500000_661800 0.0168
R_VDD15_4969 METAL6_2500000_661800 METAL6_2500000_665400 0.0072
R_VDD15_4970 METAL6_2500000_665400 METAL6_2500000_688000 0.0452
R_VDD15_4971 METAL6_2500000_688000 METAL6_2500000_700000 0.024
R_VDD15_4972 METAL6_2500000_700000 METAL6_2500000_702800 0.0056
R_VDD15_4973 METAL6_2500000_702800 METAL6_2500000_709800 0.014
R_VDD15_4974 METAL6_2500000_709800 METAL6_2498900_709800 0.0022
R_VDD15_4975 METAL6_2498900_709800 METAL6_2493000_709800 0.0118
R_VDD15_4976 METAL6_2493000_709800 METAL6_2489600_709800 0.0068
R_VDD15_4977 METAL6_2489600_709800 METAL6_2489600_712000 0.0044
R_VDD15_4978 METAL6_2489600_712000 METAL6_2489600_716800 0.0096
R_VDD15_4979 METAL6_2489600_716800 METAL6_2489600_721800 0.01
R_VDD15_4980 METAL6_2489600_721800 METAL6_2488000_721800 0.0032
R_VDD15_4981 METAL6_2488000_721800 METAL6_2488000_733800 0.024
R_VDD15_4982 METAL6_2488000_733800 METAL6_2488000_735400 0.0032
R_VDD15_4983 METAL6_2488000_735400 METAL6_2488000_745800 0.0208
R_VDD15_4984 METAL6_2488000_745800 METAL6_2488000_754400 0.0172
R_VDD15_4985 METAL6_2488000_754400 METAL6_2486900_754400 0.0022
R_VDD15_4986 METAL6_2486900_754400 METAL6_2481000_754400 0.0118
R_VDD15_4987 METAL6_2481000_754400 METAL6_2476000_754400 0.01
R_VDD15_4988 METAL6_2476000_754400 METAL6_2476000_758400 0.008
R_VDD15_4989 METAL6_2476000_758400 METAL6_2476000_763000 0.0092
R_VDD15_4990 METAL6_2476000_763000 METAL6_2476000_766400 0.0068
R_VDD15_4991 METAL6_2476000_766400 METAL6_2472600_766400 0.0068
R_VDD15_4992 METAL6_2472600_766400 METAL6_2469000_766400 0.0072
R_VDD15_4993 METAL6_2469000_766400 METAL6_2460600_766400 0.0168
R_VDD15_4994 METAL6_2460600_766400 METAL6_2448600_766400 0.024
R_VDD15_4995 METAL6_2448600_766400 METAL6_2446600_766400 0.004
R_VDD15_4996 METAL6_2446600_766400 METAL6_2436600_766400 0.02
R_VDD15_4997 METAL6_2436600_766400 METAL6_2419100_766400 0.035
R_VDD15_4998 METAL6_2419100_766400 METAL6_2407100_766400 0.024
R_VDD15_4999 METAL6_2407100_766400 METAL6_2405600_766400 0.003
R_VDD15_5000 METAL6_2405600_766400 METAL6_2402100_766400 0.007
R_VDD15_5001 METAL6_2402100_766400 METAL6_2395100_766400 0.014
R_VDD15_5002 METAL6_2395100_766400 METAL6_2393600_766400 0.003
R_VDD15_5003 METAL6_2393600_766400 METAL6_2383100_766400 0.021
R_VDD15_5004 METAL6_2383100_766400 METAL6_2381600_766400 0.003
R_VDD15_5005 METAL6_2381600_766400 METAL6_2371100_766400 0.021
R_VDD15_5006 METAL6_2371100_766400 METAL6_2369600_766400 0.003
R_VDD15_5007 METAL6_2369600_766400 METAL6_2365900_766400 0.0074
R_VDD15_5008 METAL6_2365900_766400 METAL6_2357600_766400 0.0166
R_VDD15_5009 METAL6_2357600_766400 METAL6_2351900_766400 0.0114
R_VDD15_5010 METAL6_2351900_766400 METAL6_2343700_766400 0.0164
R_VDD15_5011 METAL6_2343700_766400 METAL6_2310900_766400 0.0656
R_VDD15_5012 METAL6_2310900_766400 METAL6_2298900_766400 0.024
R_VDD15_5013 METAL6_2298900_766400 METAL6_2296600_766400 0.0046
R_VDD15_5014 METAL6_2296600_766400 METAL6_2286900_766400 0.0194
R_VDD15_5015 METAL6_2286900_766400 METAL6_2284600_766400 0.0046
R_VDD15_5016 METAL6_2284600_766400 METAL6_2284400_766400 0.0004
R_VDD15_5017 METAL6_2284400_766400 METAL6_2272600_766400 0.0236
R_VDD15_5018 METAL6_2272600_766400 METAL6_2272600_770400 0.008
R_VDD15_5019 METAL6_2272600_770400 METAL6_2272400_770400 0.0004
R_VDD15_5020 METAL6_2272400_770400 METAL6_2260600_770400 0.0236
R_VDD15_5021 METAL6_2260600_770400 METAL6_2260400_770400 0.0004
R_VDD15_5022 METAL6_2260400_770400 METAL6_2258600_770400 0.0036
R_VDD15_5023 METAL6_2258600_770400 METAL6_2248700_770400 0.0198
R_VDD15_5024 METAL6_2248700_770400 METAL6_2248600_770400 0.0002
R_VDD15_5025 METAL6_2248600_770400 METAL6_2248600_772000 0.0032
R_VDD15_5026 METAL6_2248600_772000 METAL6_2248600_778400 0.0128
R_VDD15_5027 METAL6_2248600_778400 METAL6_2248600_779200 0.0016
R_VDD15_5028 METAL6_2248600_779200 METAL6_2248600_782400 0.0064
R_VDD15_5029 METAL6_2248600_782400 METAL6_2248600_784500 0.0042
R_VDD15_5030 METAL6_2248600_784500 METAL6_2248600_788000 0.007
R_VDD15_5031 METAL6_2248600_788000 METAL6_2248600_790400 0.0048
R_VDD15_5032 METAL6_2248600_790400 METAL6_2248600_791200 0.0016
R_VDD15_5033 METAL6_2248600_791200 METAL6_2248600_794400 0.0064
R_VDD15_5034 METAL6_2248600_794400 METAL6_2248600_794800 0.0008
R_VDD15_5035 METAL6_2248600_794800 METAL6_2248600_800000 0.0104
R_VDD15_5036 METAL6_2248600_800000 METAL6_2248600_802400 0.0048
R_VDD15_5037 METAL6_2248600_802400 METAL6_2248600_803200 0.0016
R_VDD15_5038 METAL6_2248600_803200 METAL6_2248600_806400 0.0064
R_VDD15_5039 METAL6_2248600_806400 METAL6_2248600_808000 0.0032
R_VDD15_5040 METAL6_2248600_808000 METAL6_2248600_812000 0.008
R_VDD15_5041 METAL6_2248600_812000 METAL6_2248600_814400 0.0048
R_VDD15_5042 METAL6_2248600_814400 METAL6_2248600_818400 0.008
R_VDD15_5043 METAL6_2248600_818400 METAL6_2248600_820000 0.0032
R_VDD15_5044 METAL6_2248600_820000 METAL6_2248600_830400 0.0208
R_VDD15_5045 METAL6_2248600_830400 METAL6_2248600_832000 0.0032
R_VDD15_5046 METAL6_2248600_832000 METAL6_2248600_839500 0.015
R_VDD15_5047 METAL6_2248600_839500 METAL6_2248600_840700 0.0024
R_VDD15_5048 METAL6_2248600_840700 METAL6_2248600_851500 0.0216
R_VDD15_5049 METAL6_2248600_851500 METAL6_2248600_858200 0.0134
R_VDD15_5050 METAL6_2248600_858200 METAL6_2248600_863500 0.0106
R_VDD15_5051 METAL6_2248600_863500 METAL6_2248600_887000 0.047
R_VDD15_5052 METAL6_2248600_887000 METAL6_2248600_888000 0.002
R_VDD15_5053 METAL6_2248600_888000 METAL6_2248600_900000 0.024
R_VDD15_5054 METAL6_2248600_900000 METAL6_2248600_900400 0.0008
R_VDD15_5055 METAL6_2248600_900400 METAL6_2248600_912000 0.0232
R_VDD15_5056 METAL6_2248600_912000 METAL6_2248600_927300 0.0306
R_VDD15_5057 METAL6_2248600_927300 METAL6_2248600_947000 0.0394
R_VDD15_5058 METAL6_2248600_947000 METAL6_2248600_959000 0.024
R_VDD15_5059 METAL6_2248600_959000 METAL6_2248600_971000 0.024
R_VDD15_5060 METAL6_2248600_971000 METAL6_2248600_976000 0.01
R_VDD15_5061 METAL6_2248600_976000 METAL6_2248600_988000 0.024
R_VDD15_5062 METAL6_2248600_988000 METAL6_2248600_995000 0.014
R_VDD15_5063 METAL6_2248600_995000 METAL6_2248600_1000000 0.01
R_VDD15_5064 METAL6_2248600_1000000 METAL6_2248600_1007000 0.014
R_VDD15_5065 METAL6_2248600_1007000 METAL6_2248600_1012000 0.01
R_VDD15_5066 METAL6_2248600_1012000 METAL6_2248600_1014000 0.004
R_VDD15_5067 METAL6_2248600_1014000 METAL6_2248600_1019000 0.01
R_VDD15_5068 METAL6_2248600_1019000 METAL6_2248600_1026000 0.014
R_VDD15_5069 METAL6_2248600_1026000 METAL6_2248600_1029800 0.0076
R_VDD15_5070 METAL6_2248600_1029800 METAL6_2248600_1031000 0.0024
R_VDD15_5071 METAL6_2248600_1031000 METAL6_2248600_1035700 0.0094
R_VDD15_5072 METAL6_2248600_1035700 METAL6_2248400_1035700 0.0004
R_VDD15_5073 METAL6_2248400_1035700 METAL6_2246600_1035700 0.0036
R_VDD15_5074 METAL6_2246600_1035700 METAL6_2236700_1035700 0.0198
R_VDD15_5075 METAL6_2236700_1035700 METAL6_2236600_1035700 0.0002
R_VDD15_5076 METAL6_2236600_1035700 METAL6_2234600_1035700 0.004
R_VDD15_5077 METAL6_2234600_1035700 METAL6_2224700_1035700 0.0198
R_VDD15_5078 METAL6_2224700_1035700 METAL6_2222600_1035700 0.0042
R_VDD15_5079 METAL6_2222600_1035700 METAL6_2222600_1037400 0.0034
R_VDD15_5080 METAL6_2222600_1037400 METAL6_2221900_1037400 0.0014
R_VDD15_5081 METAL6_2221900_1037400 METAL6_2212700_1037400 0.0184
R_VDD15_5082 METAL6_2212700_1037400 METAL6_2212700_1038000 0.0012
R_VDD15_5083 METAL6_2212700_1038000 METAL6_2212700_1041800 0.0076
R_VDD15_5084 METAL6_2212700_1041800 METAL6_2212700_1042700 0.0018
R_VDD15_5085 METAL6_2212700_1042700 METAL6_2212700_1049400 0.0134
R_VDD15_5086 METAL6_2212700_1049400 METAL6_2212700_1049800 0.0008
R_VDD15_5087 METAL6_2212700_1049800 METAL6_2212700_1053800 0.008
R_VDD15_5088 METAL6_2212700_1053800 METAL6_2212700_1054700 0.0018
R_VDD15_5089 METAL6_2212700_1054700 METAL6_2212700_1061400 0.0134
R_VDD15_5090 METAL6_2212700_1061400 METAL6_2212700_1061800 0.0008
R_VDD15_5091 METAL6_2212700_1061800 METAL6_2212700_1066700 0.0098
R_VDD15_5092 METAL6_2212700_1066700 METAL6_2212700_1073800 0.0142
R_VDD15_5093 METAL6_2212700_1073800 METAL6_2212700_1086000 0.0244
R_VDD15_5094 METAL6_2212700_1086000 METAL6_2212700_1086300 0.0006
R_VDD15_5095 METAL6_2212700_1086300 METAL6_2212700_1086500 0.0004
R_VDD15_5096 METAL6_2212700_1086500 METAL6_2212700_1088000 0.003
R_VDD15_5097 METAL6_2212700_1088000 METAL6_2212700_1096800 0.0176
R_VDD15_5098 METAL6_2212700_1096800 METAL6_2212700_1098300 0.003
R_VDD15_5099 METAL6_2212700_1098300 METAL6_2212700_1098500 0.0004
R_VDD15_5100 METAL6_2212700_1098500 METAL6_2212700_1100000 0.003
R_VDD15_5101 METAL6_2212700_1100000 METAL6_2212700_1108800 0.0176
R_VDD15_5102 METAL6_2212700_1108800 METAL6_2212700_1110300 0.003
R_VDD15_5103 METAL6_2212700_1110300 METAL6_2212700_1110500 0.0004
R_VDD15_5104 METAL6_2212700_1110500 METAL6_2212700_1112000 0.003
R_VDD15_5105 METAL6_2212700_1112000 METAL6_2212700_1120800 0.0176
R_VDD15_5106 METAL6_2212700_1120800 METAL6_2212700_1122300 0.003
R_VDD15_5107 METAL6_2212700_1122300 METAL6_2212700_1129300 0.014
R_VDD15_5108 METAL6_2212700_1129300 METAL6_2212700_1134300 0.01
R_VDD15_5109 METAL6_2212700_1134300 METAL6_2212700_1141300 0.014
R_VDD15_5110 METAL6_2212700_1141300 METAL6_2212700_1153300 0.024
R_VDD15_5111 METAL6_2212700_1153300 METAL6_2212700_1160600 0.0146
R_VDD15_5112 METAL6_2212700_1160600 METAL6_2212700_1172600 0.024
R_VDD15_5113 METAL6_2212700_1172600 METAL6_2212700_1184600 0.024
R_VDD15_5114 METAL6_2212700_1184600 METAL6_2212700_1191600 0.014
R_VDD15_5115 METAL6_2212700_1191600 METAL6_2212700_1193700 0.0042
R_VDD15_5116 METAL6_2212700_1193700 METAL6_2212700_1193800 0.0002
R_VDD15_5117 METAL6_2212700_1193800 METAL6_2212700_1205700 0.0238
R_VDD15_5118 METAL6_2212700_1205700 METAL6_2212700_1217700 0.024
R_VDD15_5119 METAL6_2212700_1217700 METAL6_2212700_1223700 0.012
R_VDD15_5120 METAL6_2212700_1223700 METAL6_2212700_1229700 0.012
R_VDD15_5121 METAL6_2212700_1229700 METAL6_2212700_1235700 0.012
R_VDD15_5122 METAL6_2212700_1235700 METAL6_2212700_1238000 0.0046
R_VDD15_5123 METAL6_2212700_1238000 METAL6_2212700_1247700 0.0194
R_VDD15_5124 METAL6_2212700_1247700 METAL6_2212700_1250000 0.0046
R_VDD15_5125 METAL6_2212700_1250000 METAL6_2212700_1259700 0.0194
R_VDD15_5126 METAL6_2212700_1259700 METAL6_2212700_1262000 0.0046
R_VDD15_5127 METAL6_2212700_1262000 METAL6_2212700_1271700 0.0194
R_VDD15_5128 METAL6_2212700_1271700 METAL6_2212700_1273000 0.0026
R_VDD15_5129 METAL6_2212700_1273000 METAL6_2212700_1283700 0.0214
R_VDD15_5130 METAL6_2212700_1283700 METAL6_2212700_1295700 0.024
R_VDD15_5131 METAL6_2212700_1295700 METAL6_2212700_1314000 0.0366
R_VDD15_5132 METAL6_2212700_1314000 METAL5_2212700_1314000 0.1
R_VDD15_5133 METAL5_2212700_1314000 METAL5_2212700_1326000 0.048
R_VDD15_5134 METAL5_2212700_1326000 METAL5_2212700_1338000 0.048
R_VDD15_5135 METAL5_2212700_1338000 METAL6_2212700_1338000 0.1
R_VDD15_5136 METAL6_2212700_1338000 METAL6_2212700_1350000 0.024
R_VDD15_5137 METAL6_2212700_1350000 METAL6_2212700_1357000 0.014
R_VDD15_5138 METAL6_2212700_1357000 METAL6_2212700_1362000 0.01
R_VDD15_5139 METAL6_2212700_1362000 METAL6_2212700_1369000 0.014
R_VDD15_5140 METAL6_2212700_1369000 METAL6_2212700_1374000 0.01
R_VDD15_5141 METAL6_2212700_1374000 METAL6_2212700_1381000 0.014
R_VDD15_5142 METAL6_2212700_1381000 METAL6_2212700_1386600 0.0112
R_VDD15_5143 METAL6_2212700_1386600 METAL6_2212700_1393000 0.0128
R_VDD15_5144 METAL6_2212700_1393000 METAL6_2212700_1405000 0.024
R_VDD15_5145 METAL6_2212700_1405000 METAL6_2212700_1437700 0.0654
R_VDD15_5146 METAL6_2212700_1437700 METAL6_2212700_1449700 0.024
R_VDD15_5147 METAL6_2212700_1449700 METAL6_2212700_1461700 0.024
R_VDD15_5148 METAL6_2212700_1461700 METAL6_2212700_1492300 0.0612
R_VDD15_5149 METAL6_2212700_1492300 METAL6_2212700_1504300 0.024
R_VDD15_5150 METAL6_2212700_1504300 METAL6_2212700_1516300 0.024
R_VDD15_5151 METAL6_2212700_1516300 METAL6_2212700_1528300 0.024
R_VDD15_5152 METAL6_2212700_1528300 METAL5_2212700_1528300 0.1
R_VDD15_5153 METAL5_2212700_1528300 METAL5_2212700_1540300 0.048
R_VDD15_5154 METAL5_2212700_1540300 METAL5_2212700_1552300 0.048
R_VDD15_5155 METAL5_2212700_1552300 METAL5_2212700_1554500 0.0088
R_VDD15_5156 METAL5_2212700_1554500 METAL5_2212700_1564300 0.0392
R_VDD15_5157 METAL5_2212700_1564300 METAL6_2212700_1564300 0.1
R_VDD15_5158 METAL6_2212700_1564300 METAL6_2212700_1571300 0.014
R_VDD15_5159 METAL6_2212700_1571300 METAL6_2212700_1576300 0.01
R_VDD15_5160 METAL6_2212700_1576300 METAL6_2212700_1714500 0.2764
R_VDD15_5161 METAL6_2212700_1714500 METAL6_2212700_1720500 0.012
R_VDD15_5162 METAL6_2212700_1720500 METAL6_2212700_1726500 0.012
R_VDD15_5163 METAL6_2212700_1726500 METAL6_2212700_1731700 0.0104
R_VDD15_5164 METAL6_2212700_1731700 METAL6_2212700_1738500 0.0136
R_VDD15_5165 METAL6_2212700_1738500 METAL6_2212700_1750500 0.024
R_VDD15_5166 METAL6_2212700_1750500 METAL6_2212700_1762500 0.024
R_VDD15_5167 METAL6_2212700_1762500 METAL6_2212700_1774500 0.024
R_VDD15_5168 METAL6_2212700_1774500 METAL6_2212700_1802500 0.056
R_VDD15_5169 METAL6_2212700_1802500 METAL6_2212700_1814500 0.024
R_VDD15_5170 METAL6_2212700_1814500 METAL6_2212700_1826500 0.024
R_VDD15_5171 METAL6_2212700_1826500 METAL6_2212700_1838500 0.024
R_VDD15_5172 METAL6_2212700_1838500 METAL6_2212700_1852300 0.0276
R_VDD15_5173 METAL6_2212700_1852300 METAL6_2212700_1866300 0.028
R_VDD15_5174 METAL6_2212700_1866300 METAL6_2212700_1902500 0.0724
R_VDD15_5175 METAL6_2212700_1902500 METAL6_2212700_1914500 0.024
R_VDD15_5176 METAL6_2212700_1914500 METAL6_2212700_1926500 0.024
R_VDD15_5177 METAL6_2212700_1926500 METAL5_2212700_1926500 0.1
R_VDD15_5178 METAL5_2212700_1926500 METAL5_2212700_1938500 0.048
R_VDD15_5179 METAL5_2212700_1938500 METAL5_2221900_1938500 0.0368
R_VDD15_5180 METAL5_2221900_1938500 METAL5_2221900_1940500 0.008
R_VDD15_5181 METAL5_2221900_1940500 METAL5_2221900_1950500 0.04
R_VDD15_5182 METAL5_2221900_1950500 METAL5_2222600_1950500 0.0028
R_VDD15_5183 METAL5_2222600_1950500 METAL5_2224700_1950500 0.0084
R_VDD15_5184 METAL5_2224700_1950500 METAL6_2224700_1950500 0.1
R_VDD15_5185 METAL6_2224700_1950500 METAL6_2224700_1951000 0.001
R_VDD15_5186 METAL6_2224700_1951000 METAL6_2224700_1952500 0.003
R_VDD15_5187 METAL6_2224700_1952500 METAL6_2224700_1963000 0.021
R_VDD15_5188 METAL6_2224700_1963000 METAL6_2224700_1964500 0.003
R_VDD15_5189 METAL6_2224700_1964500 METAL6_2224700_1975000 0.021
R_VDD15_5190 METAL6_2224700_1975000 METAL6_2224700_1976500 0.003
R_VDD15_5191 METAL6_2224700_1976500 METAL6_2224700_1987000 0.021
R_VDD15_5192 METAL6_2224700_1987000 METAL6_2224700_2014500 0.055
R_VDD15_5193 METAL6_2224700_2014500 METAL6_2224700_2026500 0.024
R_VDD15_5194 METAL6_2224700_2026500 METAL6_2224700_2038500 0.024
R_VDD15_5195 METAL6_2224700_2038500 METAL6_2224700_2114500 0.152
R_VDD15_5196 METAL6_2224700_2114500 METAL6_2224700_2126500 0.024
R_VDD15_5197 METAL6_2224700_2126500 METAL6_2224700_2138500 0.024
R_VDD15_5198 METAL6_2224700_2138500 METAL6_2224700_2147300 0.0176
R_VDD15_5199 METAL6_2224700_2147300 METAL6_2224700_2154300 0.014
R_VDD15_5200 METAL6_2224700_2154300 METAL6_2224700_2163000 0.0174
R_VDD15_5201 METAL6_2224700_2163000 METAL6_2224700_2166300 0.0066
R_VDD15_5202 METAL6_2224700_2166300 METAL6_2224700_2175000 0.0174
R_VDD15_5203 METAL6_2224700_2175000 METAL6_2224700_2178300 0.0066
R_VDD15_5204 METAL6_2224700_2178300 METAL6_2224700_2187000 0.0174
R_VDD15_5205 METAL6_2224700_2187000 METAL6_2224700_2190300 0.0066
R_VDD15_5206 METAL6_2224700_2190300 METAL6_2224700_2222500 0.0644
R_VDD15_5207 METAL6_2224700_2222500 METAL6_2224700_2234500 0.024
R_VDD15_5208 METAL6_2224700_2234500 METAL6_2224700_2246500 0.024
R_VDD15_5209 METAL6_2224700_2246500 METAL6_2224700_2268500 0.044
R_VDD15_5210 METAL6_2224700_2268500 METAL6_2224700_2288000 0.039
R_VDD15_5211 METAL6_2224700_2288000 METAL6_2224700_2300000 0.024
R_VDD15_5212 METAL6_2224700_2300000 METAL6_2224700_2312000 0.024
R_VDD15_5213 METAL6_2224700_2312000 METAL6_2224700_2338000 0.052
R_VDD15_5214 METAL6_2224700_2338000 METAL6_2222600_2338000 0.0042
R_VDD15_5215 METAL6_2222600_2338000 METAL6_2222600_2340000 0.004
R_VDD15_5216 METAL6_2222600_2340000 METAL6_2221900_2340000 0.0014
R_VDD15_5217 METAL6_2221900_2340000 METAL6_2212700_2340000 0.0184
R_VDD15_5218 METAL6_2212700_2340000 METAL5_2212700_2340000 0.1
R_VDD15_5219 METAL5_2212700_2340000 METAL5_2200700_2340000 0.048
R_VDD15_5220 METAL5_2200700_2340000 METAL5_2189900_2340000 0.0432
R_VDD15_5221 METAL5_2189900_2340000 METAL5_2188700_2340000 0.0048
R_VDD15_5222 METAL5_2188700_2340000 METAL5_2177900_2340000 0.0432
R_VDD15_5223 METAL5_2177900_2340000 METAL5_2176700_2340000 0.0048
R_VDD15_5224 METAL5_2176700_2340000 METAL5_2165900_2340000 0.0432
R_VDD15_5225 METAL5_2165900_2340000 METAL5_2165400_2340000 0.002
R_VDD15_5226 METAL5_2165400_2340000 METAL5_2153900_2340000 0.046
R_VDD15_5227 METAL5_2153900_2340000 METAL5_2153400_2340000 0.002
R_VDD15_5228 METAL5_2153400_2340000 METAL5_2151900_2340000 0.006
R_VDD15_5229 METAL5_2151900_2340000 METAL5_2141900_2340000 0.04
R_VDD15_5230 METAL5_2141900_2340000 METAL5_2141400_2340000 0.002
R_VDD15_5231 METAL5_2141400_2340000 METAL5_2129900_2340000 0.046
R_VDD15_5232 METAL5_2129900_2340000 METAL6_2129900_2340000 0.1
R_VDD15_5233 METAL6_2129900_2340000 METAL6_2129700_2340000 0.0004
R_VDD15_5234 METAL6_2129700_2340000 METAL6_2125600_2340000 0.0082
R_VDD15_5235 METAL6_2125600_2340000 METAL6_2121400_2340000 0.0084
R_VDD15_5236 METAL6_2121400_2340000 METAL6_2117900_2340000 0.007
R_VDD15_5237 METAL6_2117900_2340000 METAL6_2113900_2340000 0.008
R_VDD15_5238 METAL6_2113900_2340000 METAL6_2113600_2340000 0.0006
R_VDD15_5239 METAL6_2113600_2340000 METAL6_2101900_2340000 0.0234
R_VDD15_5240 METAL6_2101900_2340000 METAL6_2101600_2340000 0.0006
R_VDD15_5241 METAL6_2101600_2340000 METAL6_2089900_2340000 0.0234
R_VDD15_5242 METAL6_2089900_2340000 METAL6_2079700_2340000 0.0204
R_VDD15_5243 METAL6_2079700_2340000 METAL6_2077900_2340000 0.0036
R_VDD15_5244 METAL6_2077900_2340000 METAL6_2067700_2340000 0.0204
R_VDD15_5245 METAL6_2067700_2340000 METAL6_2060600_2340000 0.0142
R_VDD15_5246 METAL6_2060600_2340000 METAL6_2055700_2340000 0.0098
R_VDD15_5247 METAL6_2055700_2340000 METAL6_2046800_2340000 0.0178
R_VDD15_5248 METAL6_2046800_2340000 METAL6_2046800_2341000 0.002
R_VDD15_5249 METAL6_2046800_2341000 METAL6_2046600_2341000 0.0004
R_VDD15_5250 METAL6_2046600_2341000 METAL6_2046400_2341000 0.0004
R_VDD15_5251 METAL6_2046400_2341000 METAL6_2043700_2341000 0.0054
R_VDD15_5252 METAL6_2043700_2341000 METAL6_2031700_2341000 0.024
R_VDD15_5253 METAL6_2031700_2341000 METAL6_2030900_2341000 0.0016
R_VDD15_5254 METAL6_2030900_2341000 METAL6_2026400_2341000 0.009
R_VDD15_5255 METAL6_2026400_2341000 METAL6_2021200_2341000 0.0104
R_VDD15_5256 METAL6_2021200_2341000 METAL6_2019700_2341000 0.003
R_VDD15_5257 METAL6_2019700_2341000 METAL6_2018900_2341000 0.0016
R_VDD15_5258 METAL6_2018900_2341000 METAL6_2014400_2341000 0.009
R_VDD15_5259 METAL6_2014400_2341000 METAL6_2012000_2341000 0.0048
R_VDD15_5260 METAL6_2012000_2341000 METAL6_2006900_2341000 0.0102
R_VDD15_5261 METAL6_2006900_2341000 METAL6_2002400_2341000 0.009
R_VDD15_5262 METAL6_2002400_2341000 METAL6_2000000_2341000 0.0048
R_VDD15_5263 METAL6_2000000_2341000 METAL6_1988000_2341000 0.024
R_VDD15_5264 METAL6_1988000_2341000 METAL6_1951900_2341000 0.0722
R_VDD15_5265 METAL6_1951900_2341000 METAL6_1951800_2341000 0.0002
R_VDD15_5266 METAL6_1951800_2341000 METAL6_1939800_2341000 0.024
R_VDD15_5267 METAL6_1939800_2341000 METAL6_1931200_2341000 0.0172
R_VDD15_5268 METAL6_1931200_2341000 METAL6_1927800_2341000 0.0068
R_VDD15_5269 METAL6_1927800_2341000 METAL6_1926200_2341000 0.0032
R_VDD15_5270 METAL6_1926200_2341000 METAL6_1925600_2341000 0.0012
R_VDD15_5271 METAL6_1925600_2341000 METAL6_1919200_2341000 0.0128
R_VDD15_5272 METAL6_1919200_2341000 METAL6_1913600_2341000 0.0112
R_VDD15_5273 METAL6_1913600_2341000 METAL6_1907400_2341000 0.0124
R_VDD15_5274 METAL6_1907400_2341000 METAL6_1907200_2341000 0.0004
R_VDD15_5275 METAL6_1907200_2341000 METAL5_1907200_2341000 0.1
R_VDD15_5276 METAL5_1907200_2341000 METAL5_1907200_2350000 0.036
R_VDD15_5277 METAL5_1907200_2350000 METAL5_1907200_2352000 0.008
R_VDD15_5278 METAL5_1907200_2352000 METAL5_1907200_2353000 0.004
R_VDD15_5279 METAL5_1907200_2353000 METAL5_1907200_2362000 0.036
R_VDD15_5280 METAL5_1907200_2362000 METAL5_1907200_2364000 0.008
R_VDD15_5281 METAL5_1907200_2364000 METAL5_1907200_2365000 0.004
R_VDD15_5282 METAL5_1907200_2365000 METAL5_1907200_2374000 0.036
R_VDD15_5283 METAL5_1907200_2374000 METAL5_1907200_2376000 0.008
R_VDD15_5284 METAL5_1907200_2376000 METAL5_1907200_2377000 0.004
R_VDD15_5285 METAL5_1907200_2377000 METAL5_1907200_2388000 0.044
R_VDD15_5286 METAL5_1907200_2388000 METAL5_1907200_2389000 0.004
R_VDD15_5287 METAL5_1907200_2389000 METAL5_1907200_2400000 0.044
R_VDD15_5288 METAL5_1907200_2400000 METAL5_1907200_2401000 0.004
R_VDD15_5289 METAL5_1907200_2401000 METAL5_1907200_2407000 0.024
R_VDD15_5290 METAL5_1907200_2407000 METAL5_1901600_2407000 0.0224
R_VDD15_5291 METAL5_1901600_2407000 METAL5_1901600_2412000 0.02
R_VDD15_5292 METAL5_1901600_2412000 METAL5_1900700_2412000 0.0036
R_VDD15_5293 METAL5_1900700_2412000 METAL5_1895200_2412000 0.022
R_VDD15_5294 METAL5_1895200_2412000 METAL6_1895200_2412000 0.1
R_VDD15_5295 METAL6_1895200_2412000 METAL6_1895200_2413000 0.002
R_VDD15_5296 METAL6_1895200_2413000 METAL6_1895200_2424000 0.022
R_VDD15_5297 METAL6_1895200_2424000 METAL6_1895200_2436000 0.024
R_VDD15_5298 METAL6_1895200_2436000 METAL6_1895200_2438000 0.004
R_VDD15_5299 METAL6_1895200_2438000 METAL6_1895200_2444000 0.012
R_VDD15_5300 METAL6_1895200_2444000 METAL6_1895200_2450000 0.012
R_VDD15_5301 METAL6_1895200_2450000 METAL6_1895200_2456000 0.012
R_VDD15_5302 METAL6_1895200_2456000 METAL6_1895200_2462000 0.012
R_VDD15_5303 METAL6_1895200_2462000 METAL6_1895200_2468000 0.012
R_VDD15_5304 METAL6_1895200_2468000 METAL6_1895200_2481000 0.026
R_VDD15_5305 METAL6_1895200_2481000 METAL6_1895200_2493000 0.024
R_VDD15_5306 METAL6_1895200_2493000 METAL6_1895200_2505000 0.024
R_VDD15_5307 METAL6_1895200_2505000 METAL6_1895200_2512000 0.014
R_VDD15_5308 METAL6_1895200_2512000 METAL6_1895200_2524000 0.024
R_VDD15_5309 METAL6_1895200_2524000 METAL6_1895200_2529700 0.0114
R_VDD15_5310 METAL6_1895200_2529700 METAL6_1895200_2536000 0.0126
R_VDD15_5311 METAL6_1895200_2536000 METAL6_1895200_2541700 0.0114
R_VDD15_5312 METAL6_1895200_2541700 METAL6_1895200_2548000 0.0126
R_VDD15_5313 METAL6_1895200_2548000 METAL6_1895200_2553700 0.0114
R_VDD15_5314 METAL6_1895200_2553700 METAL6_1895200_2589000 0.0706
R_VDD15_5315 METAL6_1895200_2589000 METAL6_1895200_2603000 0.028
R_VDD15_5316 METAL6_1895200_2603000 METAL6_1895200_2644000 0.082
R_VDD15_5317 METAL6_1895200_2644000 METAL6_1895200_2656000 0.024
R_VDD15_5318 METAL6_1895200_2656000 METAL6_1900700_2656000 0.011
R_VDD15_5319 METAL6_1900700_2656000 METAL6_1901600_2656000 0.0018
R_VDD15_5320 METAL6_1901600_2656000 METAL6_1907200_2656000 0.0112
I_VDD15_16 METAL6_2676200_802400 gnd 0.001
I_VDD15_17 METAL6_940400_1926500 gnd 0.0016
I_VDD15_18 METAL6_1717800_2736000 gnd 0.003
I_VDD15_19 METAL6_1853400_2736000 gnd 0.003
I_VDD15_20 METAL6_1717800_2536000 gnd 0.003
I_VDD15_21 METAL6_1919200_2656000 gnd 0.003

V_VDD16_8 METAL5_3500000_300000 gnd 1
R_VDD16_5321 METAL5_3500000_300000 METAL5_3490500_300000 0.038
R_VDD16_5322 METAL5_3490500_300000 METAL6_3490500_300000 0.1
R_VDD16_5323 METAL6_3490500_300000 METAL6_3478500_300000 0.024
R_VDD16_5324 METAL6_3478500_300000 METAL6_3478500_311000 0.022
R_VDD16_5325 METAL6_3478500_311000 METAL6_3477000_311000 0.003
R_VDD16_5326 METAL6_3477000_311000 METAL6_3466500_311000 0.021
R_VDD16_5327 METAL6_3466500_311000 METAL6_3465000_311000 0.003
R_VDD16_5328 METAL6_3465000_311000 METAL6_3454500_311000 0.021
R_VDD16_5329 METAL6_3454500_311000 METAL6_3453000_311000 0.003
R_VDD16_5330 METAL6_3453000_311000 METAL6_3442500_311000 0.021
R_VDD16_5331 METAL6_3442500_311000 METAL6_3372400_311000 0.1402
R_VDD16_5332 METAL6_3372400_311000 METAL6_3360400_311000 0.024
R_VDD16_5333 METAL6_3360400_311000 METAL6_3348400_311000 0.024
R_VDD16_5334 METAL6_3348400_311000 METAL6_3336400_311000 0.024
R_VDD16_5335 METAL6_3336400_311000 METAL6_3324400_311000 0.024
R_VDD16_5336 METAL6_3324400_311000 METAL5_3324400_311000 0.1
R_VDD16_5337 METAL5_3324400_311000 METAL5_3312400_311000 0.048
R_VDD16_5338 METAL5_3312400_311000 METAL5_3312000_311000 0.0016
R_VDD16_5339 METAL5_3312000_311000 METAL5_3305400_311000 0.0264
R_VDD16_5340 METAL5_3305400_311000 METAL5_3300400_311000 0.02
R_VDD16_5341 METAL5_3300400_311000 METAL5_3300000_311000 0.0016
R_VDD16_5342 METAL5_3300000_311000 METAL5_3299000_311000 0.004
R_VDD16_5343 METAL5_3299000_311000 METAL5_3288400_311000 0.0424
R_VDD16_5344 METAL5_3288400_311000 METAL5_3288000_311000 0.0016
R_VDD16_5345 METAL5_3288000_311000 METAL5_3287000_311000 0.004
R_VDD16_5346 METAL5_3287000_311000 METAL5_3276400_311000 0.0424
R_VDD16_5347 METAL5_3276400_311000 METAL6_3276400_311000 0.1
R_VDD16_5348 METAL6_3276400_311000 METAL6_3275000_311000 0.0028
R_VDD16_5349 METAL6_3275000_311000 METAL6_3263000_311000 0.024
R_VDD16_5350 METAL6_3263000_311000 METAL6_3260400_311000 0.0052
R_VDD16_5351 METAL6_3260400_311000 METAL6_3255500_311000 0.0098
R_VDD16_5352 METAL6_3255500_311000 METAL6_3243500_311000 0.024
R_VDD16_5353 METAL6_3243500_311000 METAL6_3231500_311000 0.024
R_VDD16_5354 METAL6_3231500_311000 METAL6_3224500_311000 0.014
R_VDD16_5355 METAL6_3224500_311000 METAL6_3219500_311000 0.01
R_VDD16_5356 METAL6_3219500_311000 METAL6_3212500_311000 0.014
R_VDD16_5357 METAL6_3212500_311000 METAL6_3212500_312000 0.002
R_VDD16_5358 METAL6_3212500_312000 METAL6_3212500_355300 0.0866
R_VDD16_5359 METAL6_3212500_355300 METAL6_3212500_362300 0.014
R_VDD16_5360 METAL6_3212500_362300 METAL6_3212500_366800 0.009
R_VDD16_5361 METAL6_3212500_366800 METAL6_3212000_366800 0.001
R_VDD16_5362 METAL6_3212000_366800 METAL6_3207500_366800 0.009
R_VDD16_5363 METAL6_3207500_366800 METAL6_3200500_366800 0.014
R_VDD16_5364 METAL6_3200500_366800 METAL6_3200000_366800 0.001
R_VDD16_5365 METAL6_3200000_366800 METAL6_3188000_366800 0.024
R_VDD16_5366 METAL6_3188000_366800 METAL6_3179500_366800 0.017
R_VDD16_5367 METAL6_3179500_366800 METAL6_3167500_366800 0.024
R_VDD16_5368 METAL6_3167500_366800 METAL6_3165900_366800 0.0032
R_VDD16_5369 METAL6_3165900_366800 METAL5_3165900_366800 0.1
R_VDD16_5370 METAL5_3165900_366800 METAL5_3165900_374300 0.03
R_VDD16_5371 METAL5_3165900_374300 METAL5_3155500_374300 0.0416
R_VDD16_5372 METAL5_3155500_374300 METAL5_3124000_374300 0.126
R_VDD16_5373 METAL5_3124000_374300 METAL5_3123200_374300 0.0032
R_VDD16_5374 METAL5_3123200_374300 METAL5_3112000_374300 0.0448
R_VDD16_5375 METAL5_3112000_374300 METAL5_3111200_374300 0.0032
R_VDD16_5376 METAL5_3111200_374300 METAL5_3110900_374300 0.0012
R_VDD16_5377 METAL5_3110900_374300 METAL5_3100000_374300 0.0436
R_VDD16_5378 METAL5_3100000_374300 METAL5_3099200_374300 0.0032
R_VDD16_5379 METAL5_3099200_374300 METAL5_3098900_374300 0.0012
R_VDD16_5380 METAL5_3098900_374300 METAL5_3088000_374300 0.0436
R_VDD16_5381 METAL5_3088000_374300 METAL6_3088000_374300 0.1
R_VDD16_5382 METAL6_3088000_374300 METAL6_3088000_378800 0.009
R_VDD16_5383 METAL6_3088000_378800 METAL6_3087200_378800 0.0016
R_VDD16_5384 METAL6_3087200_378800 METAL6_3086900_378800 0.0006
R_VDD16_5385 METAL6_3086900_378800 METAL6_3076000_378800 0.0218
R_VDD16_5386 METAL6_3076000_378800 METAL6_3075200_378800 0.0016
R_VDD16_5387 METAL6_3075200_378800 METAL6_3072600_378800 0.0052
R_VDD16_5388 METAL6_3072600_378800 METAL6_3068200_378800 0.0088
R_VDD16_5389 METAL6_3068200_378800 METAL6_3064000_378800 0.0084
R_VDD16_5390 METAL6_3064000_378800 METAL6_3064000_386300 0.015
R_VDD16_5391 METAL6_3064000_386300 METAL6_3064000_388000 0.0034
R_VDD16_5392 METAL6_3064000_388000 METAL6_3064000_389000 0.002
R_VDD16_5393 METAL6_3064000_389000 METAL6_3063200_389000 0.0016
R_VDD16_5394 METAL6_3063200_389000 METAL6_3060600_389000 0.0052
R_VDD16_5395 METAL6_3060600_389000 METAL6_3052000_389000 0.0172
R_VDD16_5396 METAL6_3052000_389000 METAL6_3048600_389000 0.0068
R_VDD16_5397 METAL6_3048600_389000 METAL6_3035200_389000 0.0268
R_VDD16_5398 METAL6_3035200_389000 METAL6_3024000_389000 0.0224
R_VDD16_5399 METAL6_3024000_389000 METAL6_3024000_390800 0.0036
R_VDD16_5400 METAL6_3024000_390800 METAL6_3024000_400000 0.0184
R_VDD16_5401 METAL6_3024000_400000 METAL6_3024000_401000 0.002
R_VDD16_5402 METAL6_3024000_401000 METAL6_3024000_402800 0.0036
R_VDD16_5403 METAL6_3024000_402800 METAL6_3024000_412000 0.0184
R_VDD16_5404 METAL6_3024000_412000 METAL6_3024000_413000 0.002
R_VDD16_5405 METAL6_3024000_413000 METAL6_3024000_414800 0.0036
R_VDD16_5406 METAL6_3024000_414800 METAL6_3024000_424000 0.0184
R_VDD16_5407 METAL6_3024000_424000 METAL6_3024000_425000 0.002
R_VDD16_5408 METAL6_3024000_425000 METAL6_3023200_425000 0.0016
R_VDD16_5409 METAL6_3023200_425000 METAL6_3018200_425000 0.01
R_VDD16_5410 METAL6_3018200_425000 METAL6_3012000_425000 0.0124
R_VDD16_5411 METAL6_3012000_425000 METAL6_3011200_425000 0.0016
R_VDD16_5412 METAL6_3011200_425000 METAL6_3006200_425000 0.01
R_VDD16_5413 METAL6_3006200_425000 METAL6_3000000_425000 0.0124
R_VDD16_5414 METAL6_3000000_425000 METAL6_2994200_425000 0.0116
R_VDD16_5415 METAL6_2994200_425000 METAL6_2993000_425000 0.0024
R_VDD16_5416 METAL6_2993000_425000 METAL6_2988000_425000 0.01
R_VDD16_5417 METAL6_2988000_425000 METAL6_2987200_425000 0.0016
R_VDD16_5418 METAL6_2987200_425000 METAL6_2982200_425000 0.01
R_VDD16_5419 METAL6_2982200_425000 METAL6_2976000_425000 0.0124
R_VDD16_5420 METAL6_2976000_425000 METAL6_2975200_425000 0.0016
R_VDD16_5421 METAL6_2975200_425000 METAL6_2970200_425000 0.01
R_VDD16_5422 METAL6_2970200_425000 METAL6_2965900_425000 0.0086
R_VDD16_5423 METAL6_2965900_425000 METAL6_2963200_425000 0.0054
R_VDD16_5424 METAL6_2963200_425000 METAL6_2958200_425000 0.01
R_VDD16_5425 METAL6_2958200_425000 METAL6_2951900_425000 0.0126
R_VDD16_5426 METAL6_2951900_425000 METAL6_2942200_425000 0.0194
R_VDD16_5427 METAL6_2942200_425000 METAL6_2930200_425000 0.024
R_VDD16_5428 METAL6_2930200_425000 METAL6_2925600_425000 0.0092
R_VDD16_5429 METAL6_2925600_425000 METAL6_2918200_425000 0.0148
R_VDD16_5430 METAL6_2918200_425000 METAL6_2913600_425000 0.0092
R_VDD16_5431 METAL6_2913600_425000 METAL6_2910900_425000 0.0054
R_VDD16_5432 METAL6_2910900_425000 METAL6_2901600_425000 0.0186
R_VDD16_5433 METAL6_2901600_425000 METAL6_2898900_425000 0.0054
R_VDD16_5434 METAL6_2898900_425000 METAL6_2897100_425000 0.0036
R_VDD16_5435 METAL6_2897100_425000 METAL6_2886900_425000 0.0204
R_VDD16_5436 METAL6_2886900_425000 METAL6_2886800_425000 0.0002
R_VDD16_5437 METAL6_2886800_425000 METAL6_2874900_425000 0.0238
R_VDD16_5438 METAL6_2874900_425000 METAL6_2874800_425000 0.0002
R_VDD16_5439 METAL6_2874800_425000 METAL6_2862800_425000 0.024
R_VDD16_5440 METAL6_2862800_425000 METAL6_2860600_425000 0.0044
R_VDD16_5441 METAL6_2860600_425000 METAL6_2850800_425000 0.0196
R_VDD16_5442 METAL6_2850800_425000 METAL6_2846600_425000 0.0084
R_VDD16_5443 METAL6_2846600_425000 METAL6_2843800_425000 0.0056
R_VDD16_5444 METAL6_2843800_425000 METAL6_2824000_425000 0.0396
R_VDD16_5445 METAL6_2824000_425000 METAL6_2817600_425000 0.0128
R_VDD16_5446 METAL6_2817600_425000 METAL6_2812000_425000 0.0112
R_VDD16_5447 METAL6_2812000_425000 METAL6_2810800_425000 0.0024
R_VDD16_5448 METAL6_2810800_425000 METAL6_2805600_425000 0.0104
R_VDD16_5449 METAL6_2805600_425000 METAL6_2800000_425000 0.0112
R_VDD16_5450 METAL6_2800000_425000 METAL6_2798800_425000 0.0024
R_VDD16_5451 METAL6_2798800_425000 METAL6_2793600_425000 0.0104
R_VDD16_5452 METAL6_2793600_425000 METAL6_2788000_425000 0.0112
R_VDD16_5453 METAL6_2788000_425000 METAL6_2786800_425000 0.0024
R_VDD16_5454 METAL6_2786800_425000 METAL6_2781600_425000 0.0104
R_VDD16_5455 METAL6_2781600_425000 METAL6_2769600_425000 0.024
R_VDD16_5456 METAL6_2769600_425000 METAL6_2765900_425000 0.0074
R_VDD16_5457 METAL6_2765900_425000 METAL6_2751900_425000 0.028
R_VDD16_5458 METAL6_2751900_425000 METAL6_2728200_425000 0.0474
R_VDD16_5459 METAL6_2728200_425000 METAL6_2710900_425000 0.0346
R_VDD16_5460 METAL6_2710900_425000 METAL6_2698900_425000 0.024
R_VDD16_5461 METAL6_2698900_425000 METAL6_2686900_425000 0.024
R_VDD16_5462 METAL6_2686900_425000 METAL6_2683200_425000 0.0074
R_VDD16_5463 METAL6_2683200_425000 METAL6_2676200_425000 0.014
R_VDD16_5464 METAL6_2676200_425000 METAL6_2664200_425000 0.024
R_VDD16_5465 METAL6_2664200_425000 METAL6_2660600_425000 0.0072
R_VDD16_5466 METAL6_2660600_425000 METAL6_2652200_425000 0.0168
R_VDD16_5467 METAL6_2652200_425000 METAL5_2652200_425000 0.1
R_VDD16_5468 METAL5_2652200_425000 METAL5_2652200_426800 0.0072
R_VDD16_5469 METAL5_2652200_426800 METAL5_2652200_432400 0.0224
R_VDD16_5470 METAL5_2652200_432400 METAL5_2652200_437000 0.0184
R_VDD16_5471 METAL5_2652200_437000 METAL5_2652200_438800 0.0072
R_VDD16_5472 METAL5_2652200_438800 METAL5_2652200_444400 0.0224
R_VDD16_5473 METAL5_2652200_444400 METAL5_2652200_447000 0.0104
R_VDD16_5474 METAL5_2652200_447000 METAL5_2652200_449000 0.008
R_VDD16_5475 METAL5_2652200_449000 METAL5_2652200_453000 0.016
R_VDD16_5476 METAL5_2652200_453000 METAL5_2652200_456400 0.0136
R_VDD16_5477 METAL5_2652200_456400 METAL5_2652200_459000 0.0104
R_VDD16_5478 METAL5_2652200_459000 METAL5_2652200_461000 0.008
R_VDD16_5479 METAL5_2652200_461000 METAL5_2652200_465000 0.016
R_VDD16_5480 METAL5_2652200_465000 METAL5_2652200_468400 0.0136
R_VDD16_5481 METAL5_2652200_468400 METAL5_2652200_471000 0.0104
R_VDD16_5482 METAL5_2652200_471000 METAL5_2652200_473000 0.008
R_VDD16_5483 METAL5_2652200_473000 METAL5_2652200_477000 0.016
R_VDD16_5484 METAL5_2652200_477000 METAL5_2652200_480400 0.0136
R_VDD16_5485 METAL5_2652200_480400 METAL5_2652200_483000 0.0104
R_VDD16_5486 METAL5_2652200_483000 METAL5_2652200_488000 0.02
R_VDD16_5487 METAL5_2652200_488000 METAL5_2652200_492000 0.016
R_VDD16_5488 METAL5_2652200_492000 METAL5_2652200_492400 0.0016
R_VDD16_5489 METAL5_2652200_492400 METAL5_2652200_495000 0.0104
R_VDD16_5490 METAL5_2652200_495000 METAL5_2652200_500000 0.02
R_VDD16_5491 METAL5_2652200_500000 METAL5_2652200_504000 0.016
R_VDD16_5492 METAL5_2652200_504000 METAL5_2652200_504400 0.0016
R_VDD16_5493 METAL5_2652200_504400 METAL5_2652200_507000 0.0104
R_VDD16_5494 METAL5_2652200_507000 METAL5_2652200_507800 0.0032
R_VDD16_5495 METAL5_2652200_507800 METAL5_2652200_512000 0.0168
R_VDD16_5496 METAL5_2652200_512000 METAL5_2652200_516000 0.016
R_VDD16_5497 METAL5_2652200_516000 METAL5_2652200_516400 0.0016
R_VDD16_5498 METAL5_2652200_516400 METAL5_2652200_519000 0.0104
R_VDD16_5499 METAL5_2652200_519000 METAL5_2652200_520200 0.0048
R_VDD16_5500 METAL5_2652200_520200 METAL5_2652200_528000 0.0312
R_VDD16_5501 METAL5_2652200_528000 METAL5_2652200_532200 0.0168
R_VDD16_5502 METAL5_2652200_532200 METAL5_2652200_535400 0.0128
R_VDD16_5503 METAL5_2652200_535400 METAL5_2652200_538400 0.012
R_VDD16_5504 METAL5_2652200_538400 METAL5_2652200_544200 0.0232
R_VDD16_5505 METAL5_2652200_544200 METAL6_2652200_544200 0.1
R_VDD16_5506 METAL6_2652200_544200 METAL6_2646600_544200 0.0112
R_VDD16_5507 METAL6_2646600_544200 METAL6_2604400_544200 0.0844
R_VDD16_5508 METAL6_2604400_544200 METAL6_2592400_544200 0.024
R_VDD16_5509 METAL6_2592400_544200 METAL6_2580400_544200 0.024
R_VDD16_5510 METAL6_2580400_544200 METAL6_2580400_547400 0.0064
R_VDD16_5511 METAL6_2580400_547400 METAL6_2580400_550400 0.006
R_VDD16_5512 METAL6_2580400_550400 METAL6_2580400_556200 0.0116
R_VDD16_5513 METAL6_2580400_556200 METAL6_2580400_559400 0.0064
R_VDD16_5514 METAL6_2580400_559400 METAL6_2580400_561000 0.0032
R_VDD16_5515 METAL6_2580400_561000 METAL6_2580400_562400 0.0028
R_VDD16_5516 METAL6_2580400_562400 METAL6_2580400_568200 0.0116
R_VDD16_5517 METAL6_2580400_568200 METAL6_2580400_571400 0.0064
R_VDD16_5518 METAL6_2580400_571400 METAL6_2580400_573000 0.0032
R_VDD16_5519 METAL6_2580400_573000 METAL6_2580400_574400 0.0028
R_VDD16_5520 METAL6_2580400_574400 METAL6_2580400_579800 0.0108
R_VDD16_5521 METAL6_2580400_579800 METAL6_2580400_585000 0.0104
R_VDD16_5522 METAL6_2580400_585000 METAL6_2580400_586400 0.0028
R_VDD16_5523 METAL6_2580400_586400 METAL6_2580400_588000 0.0032
R_VDD16_5524 METAL6_2580400_588000 METAL6_2580400_597000 0.018
R_VDD16_5525 METAL6_2580400_597000 METAL6_2580400_598400 0.0028
R_VDD16_5526 METAL6_2580400_598400 METAL6_2568400_598400 0.024
R_VDD16_5527 METAL6_2568400_598400 METAL6_2565900_598400 0.005
R_VDD16_5528 METAL6_2565900_598400 METAL6_2556400_598400 0.019
R_VDD16_5529 METAL6_2556400_598400 METAL6_2551900_598400 0.009
R_VDD16_5530 METAL6_2551900_598400 METAL6_2548000_598400 0.0078
R_VDD16_5531 METAL6_2548000_598400 METAL6_2537600_598400 0.0208
R_VDD16_5532 METAL6_2537600_598400 METAL6_2537600_600000 0.0032
R_VDD16_5533 METAL6_2537600_600000 METAL6_2537600_605400 0.0108
R_VDD16_5534 METAL6_2537600_605400 METAL6_2537600_610400 0.01
R_VDD16_5535 METAL6_2537600_610400 METAL6_2537600_612000 0.0032
R_VDD16_5536 METAL6_2537600_612000 METAL6_2537600_617400 0.0108
R_VDD16_5537 METAL6_2537600_617400 METAL6_2537600_629400 0.024
R_VDD16_5538 METAL6_2537600_629400 METAL6_2537600_637800 0.0168
R_VDD16_5539 METAL6_2537600_637800 METAL6_2537600_641400 0.0072
R_VDD16_5540 METAL6_2537600_641400 METAL6_2537600_649800 0.0168
R_VDD16_5541 METAL6_2537600_649800 METAL6_2537600_653400 0.0072
R_VDD16_5542 METAL6_2537600_653400 METAL6_2537600_661800 0.0168
R_VDD16_5543 METAL6_2537600_661800 METAL6_2537600_665400 0.0072
R_VDD16_5544 METAL6_2537600_665400 METAL6_2537600_685800 0.0408
R_VDD16_5545 METAL6_2537600_685800 METAL6_2537600_688000 0.0044
R_VDD16_5546 METAL6_2537600_688000 METAL6_2537600_697800 0.0196
R_VDD16_5547 METAL6_2537600_697800 METAL6_2537600_700000 0.0044
R_VDD16_5548 METAL6_2537600_700000 METAL6_2537600_702800 0.0056
R_VDD16_5549 METAL6_2537600_702800 METAL6_2537600_704800 0.004
R_VDD16_5550 METAL6_2537600_704800 METAL6_2537600_709800 0.01
R_VDD16_5551 METAL6_2537600_709800 METAL6_2537600_712000 0.0044
R_VDD16_5552 METAL6_2537600_712000 METAL6_2537600_716800 0.0096
R_VDD16_5553 METAL6_2537600_716800 METAL6_2537600_721800 0.01
R_VDD16_5554 METAL6_2537600_721800 METAL6_2537600_722400 0.0012
R_VDD16_5555 METAL6_2537600_722400 METAL6_2537600_728800 0.0128
R_VDD16_5556 METAL6_2537600_728800 METAL6_2537600_733800 0.01
R_VDD16_5557 METAL6_2537600_733800 METAL6_2537600_734400 0.0012
R_VDD16_5558 METAL6_2537600_734400 METAL6_2537600_735400 0.002
R_VDD16_5559 METAL6_2537600_735400 METAL6_2537600_742400 0.014
R_VDD16_5560 METAL6_2537600_742400 METAL6_2537600_745800 0.0068
R_VDD16_5561 METAL6_2537600_745800 METAL6_2536000_745800 0.0032
R_VDD16_5562 METAL6_2536000_745800 METAL6_2536000_746400 0.0012
R_VDD16_5563 METAL6_2536000_746400 METAL6_2536000_754400 0.016
R_VDD16_5564 METAL6_2536000_754400 METAL6_2536000_757800 0.0068
R_VDD16_5565 METAL6_2536000_757800 METAL6_2535400_757800 0.0012
R_VDD16_5566 METAL6_2535400_757800 METAL6_2529000_757800 0.0128
R_VDD16_5567 METAL6_2529000_757800 METAL6_2528400_757800 0.0012
R_VDD16_5568 METAL6_2528400_757800 METAL6_2525600_757800 0.0056
R_VDD16_5569 METAL6_2525600_757800 METAL6_2525600_758400 0.0012
R_VDD16_5570 METAL6_2525600_758400 METAL6_2525600_760000 0.0032
R_VDD16_5571 METAL6_2525600_760000 METAL6_2525600_763000 0.006
R_VDD16_5572 METAL6_2525600_763000 METAL6_2525600_766400 0.0068
R_VDD16_5573 METAL6_2525600_766400 METAL6_2525600_769800 0.0068
R_VDD16_5574 METAL6_2525600_769800 METAL6_2525600_770400 0.0012
R_VDD16_5575 METAL6_2525600_770400 METAL6_2525600_772000 0.0032
R_VDD16_5576 METAL6_2525600_772000 METAL6_2525600_778400 0.0128
R_VDD16_5577 METAL6_2525600_778400 METAL6_2525600_779200 0.0016
R_VDD16_5578 METAL6_2525600_779200 METAL6_2525600_781800 0.0052
R_VDD16_5579 METAL6_2525600_781800 METAL6_2525600_782400 0.0012
R_VDD16_5580 METAL6_2525600_782400 METAL6_2525600_782800 0.0008
R_VDD16_5581 METAL6_2525600_782800 METAL6_2525600_784000 0.0024
R_VDD16_5582 METAL6_2525600_784000 METAL6_2525600_784500 0.001
R_VDD16_5583 METAL6_2525600_784500 METAL5_2525600_784500 0.1
R_VDD16_5584 METAL5_2525600_784500 METAL5_2524000_784500 0.0064
R_VDD16_5585 METAL5_2524000_784500 METAL5_2517000_784500 0.028
R_VDD16_5586 METAL5_2517000_784500 METAL5_2516400_784500 0.0024
R_VDD16_5587 METAL5_2516400_784500 METAL5_2516400_788000 0.014
R_VDD16_5588 METAL5_2516400_788000 METAL5_2516400_790400 0.0096
R_VDD16_5589 METAL5_2516400_790400 METAL5_2516400_791200 0.0032
R_VDD16_5590 METAL5_2516400_791200 METAL5_2516400_794400 0.0128
R_VDD16_5591 METAL5_2516400_794400 METAL5_2516400_794800 0.0016
R_VDD16_5592 METAL5_2516400_794800 METAL5_2516400_800000 0.0208
R_VDD16_5593 METAL5_2516400_800000 METAL5_2516400_802400 0.0096
R_VDD16_5594 METAL5_2516400_802400 METAL5_2516400_803200 0.0032
R_VDD16_5595 METAL5_2516400_803200 METAL5_2516400_806400 0.0128
R_VDD16_5596 METAL5_2516400_806400 METAL6_2516400_806400 0.1
R_VDD16_5597 METAL6_2516400_806400 METAL6_2516400_806800 0.0008
R_VDD16_5598 METAL6_2516400_806800 METAL6_2516400_808000 0.0024
R_VDD16_5599 METAL6_2516400_808000 METAL6_2516400_812000 0.008
R_VDD16_5600 METAL6_2516400_812000 METAL6_2516400_814400 0.0048
R_VDD16_5601 METAL6_2516400_814400 METAL6_2516400_818400 0.008
R_VDD16_5602 METAL6_2516400_818400 METAL6_2516400_820000 0.0032
R_VDD16_5603 METAL6_2516400_820000 METAL6_2516400_828700 0.0174
R_VDD16_5604 METAL6_2516400_828700 METAL6_2516400_830400 0.0034
R_VDD16_5605 METAL6_2516400_830400 METAL6_2516400_832000 0.0032
R_VDD16_5606 METAL6_2516400_832000 METAL6_2516400_839500 0.015
R_VDD16_5607 METAL6_2516400_839500 METAL6_2516400_840700 0.0024
R_VDD16_5608 METAL6_2516400_840700 METAL6_2516400_842400 0.0034
R_VDD16_5609 METAL6_2516400_842400 METAL6_2516400_851500 0.0182
R_VDD16_5610 METAL6_2528400_851500 METAL6_2516400_851500 0.024
I_VDD16_22 METAL6_2528400_851500 gnd 0.001

V_VDD17_9 METAL5_3500000_400000 gnd 1
R_VDD17_5611 METAL5_3500000_400000 METAL5_3490500_400000 0.038
R_VDD17_5612 METAL5_3490500_400000 METAL6_3490500_400000 0.1
R_VDD17_5613 METAL6_3490500_400000 METAL6_3478500_400000 0.024
R_VDD17_5614 METAL6_3478500_400000 METAL6_3478500_402800 0.0056
R_VDD17_5615 METAL6_3478500_402800 METAL6_3478500_412000 0.0184
R_VDD17_5616 METAL6_3478500_412000 METAL6_3477000_412000 0.003
R_VDD17_5617 METAL6_3477000_412000 METAL6_3466500_412000 0.021
R_VDD17_5618 METAL6_3466500_412000 METAL6_3465000_412000 0.003
R_VDD17_5619 METAL6_3465000_412000 METAL6_3454500_412000 0.021
R_VDD17_5620 METAL6_3454500_412000 METAL6_3453000_412000 0.003
R_VDD17_5621 METAL6_3453000_412000 METAL6_3442500_412000 0.021
R_VDD17_5622 METAL6_3442500_412000 METAL6_3360400_412000 0.1642
R_VDD17_5623 METAL6_3360400_412000 METAL6_3348400_412000 0.024
R_VDD17_5624 METAL6_3348400_412000 METAL6_3336400_412000 0.024
R_VDD17_5625 METAL6_3336400_412000 METAL6_3324400_412000 0.024
R_VDD17_5626 METAL6_3324400_412000 METAL6_3324400_413000 0.002
R_VDD17_5627 METAL6_3324400_413000 METAL6_3324400_414800 0.0036
R_VDD17_5628 METAL6_3324400_414800 METAL6_3312400_414800 0.024
R_VDD17_5629 METAL6_3312400_414800 METAL6_3312000_414800 0.0008
R_VDD17_5630 METAL6_3312000_414800 METAL6_3305400_414800 0.0132
R_VDD17_5631 METAL6_3305400_414800 METAL6_3300400_414800 0.01
R_VDD17_5632 METAL6_3300400_414800 METAL6_3300000_414800 0.0008
R_VDD17_5633 METAL6_3300000_414800 METAL6_3299000_414800 0.002
R_VDD17_5634 METAL6_3299000_414800 METAL6_3288400_414800 0.0212
R_VDD17_5635 METAL6_3288400_414800 METAL6_3288000_414800 0.0008
R_VDD17_5636 METAL6_3288000_414800 METAL6_3287000_414800 0.002
R_VDD17_5637 METAL6_3287000_414800 METAL6_3276400_414800 0.0212
R_VDD17_5638 METAL6_3276400_414800 METAL6_3275000_414800 0.0028
R_VDD17_5639 METAL6_3275000_414800 METAL6_3263000_414800 0.024
R_VDD17_5640 METAL6_3263000_414800 METAL6_3260400_414800 0.0052
R_VDD17_5641 METAL6_3260400_414800 METAL6_3243500_414800 0.0338
R_VDD17_5642 METAL6_3243500_414800 METAL6_3231500_414800 0.024
R_VDD17_5643 METAL6_3231500_414800 METAL5_3231500_414800 0.1
R_VDD17_5644 METAL5_3231500_414800 METAL5_3231500_413000 0.0072
R_VDD17_5645 METAL5_3231500_413000 METAL5_3231500_412000 0.004
R_VDD17_5646 METAL5_3231500_412000 METAL5_3231500_402800 0.0368
R_VDD17_5647 METAL5_3231500_402800 METAL5_3224500_402800 0.028
R_VDD17_5648 METAL5_3224500_402800 METAL5_3219500_402800 0.02
R_VDD17_5649 METAL5_3219500_402800 METAL5_3212500_402800 0.028
R_VDD17_5650 METAL5_3212500_402800 METAL5_3212000_402800 0.002
R_VDD17_5651 METAL5_3212000_402800 METAL5_3207500_402800 0.018
R_VDD17_5652 METAL5_3207500_402800 METAL5_3200500_402800 0.028
R_VDD17_5653 METAL5_3200500_402800 METAL5_3200000_402800 0.002
R_VDD17_5654 METAL5_3200000_402800 METAL5_3188000_402800 0.048
R_VDD17_5655 METAL5_3188000_402800 METAL5_3179500_402800 0.034
R_VDD17_5656 METAL5_3179500_402800 METAL5_3167500_402800 0.048
R_VDD17_5657 METAL5_3167500_402800 METAL5_3165900_402800 0.0064
R_VDD17_5658 METAL5_3165900_402800 METAL5_3155500_402800 0.0416
R_VDD17_5659 METAL5_3155500_402800 METAL5_3124000_402800 0.126
R_VDD17_5660 METAL5_3124000_402800 METAL5_3112000_402800 0.048
R_VDD17_5661 METAL5_3112000_402800 METAL5_3111200_402800 0.0032
R_VDD17_5662 METAL5_3111200_402800 METAL5_3110900_402800 0.0012
R_VDD17_5663 METAL5_3110900_402800 METAL5_3100000_402800 0.0436
R_VDD17_5664 METAL5_3100000_402800 METAL5_3099200_402800 0.0032
R_VDD17_5665 METAL5_3099200_402800 METAL5_3098900_402800 0.0012
R_VDD17_5666 METAL5_3098900_402800 METAL5_3088000_402800 0.0436
R_VDD17_5667 METAL5_3088000_402800 METAL6_3088000_402800 0.1
R_VDD17_5668 METAL6_3088000_402800 METAL6_3088000_412000 0.0184
R_VDD17_5669 METAL6_3088000_412000 METAL6_3088000_413000 0.002
R_VDD17_5670 METAL6_3088000_413000 METAL6_3087200_413000 0.0016
R_VDD17_5671 METAL6_3087200_413000 METAL6_3086900_413000 0.0006
R_VDD17_5672 METAL6_3086900_413000 METAL6_3076000_413000 0.0218
R_VDD17_5673 METAL6_3076000_413000 METAL6_3076000_414800 0.0036
R_VDD17_5674 METAL6_3076000_414800 METAL6_3076000_425000 0.0204
R_VDD17_5675 METAL6_3076000_425000 METAL6_3076000_437000 0.024
R_VDD17_5676 METAL6_3076000_437000 METAL6_3076000_449000 0.024
R_VDD17_5677 METAL6_3076000_449000 METAL6_3076000_453000 0.008
R_VDD17_5678 METAL6_3076000_453000 METAL6_3076000_456400 0.0068
R_VDD17_5679 METAL6_3076000_456400 METAL6_3076000_459000 0.0052
R_VDD17_5680 METAL6_3076000_459000 METAL6_3075200_459000 0.0016
R_VDD17_5681 METAL6_3075200_459000 METAL6_3068200_459000 0.014
R_VDD17_5682 METAL6_3068200_459000 METAL6_3064000_459000 0.0084
R_VDD17_5683 METAL6_3064000_459000 METAL6_3063200_459000 0.0016
R_VDD17_5684 METAL6_3063200_459000 METAL6_3060600_459000 0.0052
R_VDD17_5685 METAL6_3060600_459000 METAL6_3052000_459000 0.0172
R_VDD17_5686 METAL6_3052000_459000 METAL6_3035200_459000 0.0336
R_VDD17_5687 METAL6_3035200_459000 METAL6_3023200_459000 0.024
R_VDD17_5688 METAL6_3023200_459000 METAL6_3018200_459000 0.01
R_VDD17_5689 METAL6_3018200_459000 METAL6_3012000_459000 0.0124
R_VDD17_5690 METAL6_3012000_459000 METAL6_3012000_461000 0.004
R_VDD17_5691 METAL6_3012000_461000 METAL6_3012000_465000 0.008
R_VDD17_5692 METAL6_3012000_465000 METAL6_3012000_468400 0.0068
R_VDD17_5693 METAL6_3012000_468400 METAL6_3011200_468400 0.0016
R_VDD17_5694 METAL6_3011200_468400 METAL6_3006200_468400 0.01
R_VDD17_5695 METAL6_3006200_468400 METAL6_3000000_468400 0.0124
R_VDD17_5696 METAL6_3000000_468400 METAL6_2994200_468400 0.0116
R_VDD17_5697 METAL6_2994200_468400 METAL6_2993000_468400 0.0024
R_VDD17_5698 METAL6_2993000_468400 METAL6_2988000_468400 0.01
R_VDD17_5699 METAL6_2988000_468400 METAL6_2982200_468400 0.0116
R_VDD17_5700 METAL6_2982200_468400 METAL6_2975200_468400 0.014
R_VDD17_5701 METAL6_2975200_468400 METAL6_2970200_468400 0.01
R_VDD17_5702 METAL6_2970200_468400 METAL6_2965900_468400 0.0086
R_VDD17_5703 METAL6_2965900_468400 METAL6_2951900_468400 0.028
R_VDD17_5704 METAL6_2951900_468400 METAL6_2942200_468400 0.0194
R_VDD17_5705 METAL6_2942200_468400 METAL6_2930200_468400 0.024
R_VDD17_5706 METAL6_2930200_468400 METAL6_2925600_468400 0.0092
R_VDD17_5707 METAL6_2925600_468400 METAL6_2918200_468400 0.0148
R_VDD17_5708 METAL6_2918200_468400 METAL6_2913600_468400 0.0092
R_VDD17_5709 METAL6_2913600_468400 METAL6_2910900_468400 0.0054
R_VDD17_5710 METAL6_2910900_468400 METAL6_2901600_468400 0.0186
R_VDD17_5711 METAL6_2901600_468400 METAL6_2898900_468400 0.0054
R_VDD17_5712 METAL6_2898900_468400 METAL6_2898900_471000 0.0052
R_VDD17_5713 METAL6_2898900_471000 METAL6_2898900_473000 0.004
R_VDD17_5714 METAL6_2898900_473000 METAL6_2898900_477000 0.008
R_VDD17_5715 METAL6_2898900_477000 METAL6_2898900_480400 0.0068
R_VDD17_5716 METAL6_2898900_480400 METAL6_2898900_483000 0.0052
R_VDD17_5717 METAL6_2898900_483000 METAL6_2897100_483000 0.0036
R_VDD17_5718 METAL6_2897100_483000 METAL6_2886900_483000 0.0204
R_VDD17_5719 METAL6_2886900_483000 METAL6_2874800_483000 0.0242
R_VDD17_5720 METAL6_2874800_483000 METAL6_2862800_483000 0.024
R_VDD17_5721 METAL6_2862800_483000 METAL6_2860600_483000 0.0044
R_VDD17_5722 METAL6_2860600_483000 METAL6_2850800_483000 0.0196
R_VDD17_5723 METAL6_2850800_483000 METAL6_2846600_483000 0.0084
R_VDD17_5724 METAL6_2846600_483000 METAL6_2843800_483000 0.0056
R_VDD17_5725 METAL6_2843800_483000 METAL6_2812000_483000 0.0636
R_VDD17_5726 METAL6_2812000_483000 METAL6_2810800_483000 0.0024
R_VDD17_5727 METAL6_2810800_483000 METAL6_2805600_483000 0.0104
R_VDD17_5728 METAL6_2805600_483000 METAL6_2800000_483000 0.0112
R_VDD17_5729 METAL6_2800000_483000 METAL6_2798800_483000 0.0024
R_VDD17_5730 METAL6_2798800_483000 METAL6_2793600_483000 0.0104
R_VDD17_5731 METAL6_2793600_483000 METAL6_2788000_483000 0.0112
R_VDD17_5732 METAL6_2788000_483000 METAL6_2786800_483000 0.0024
R_VDD17_5733 METAL6_2786800_483000 METAL6_2781600_483000 0.0104
R_VDD17_5734 METAL6_2781600_483000 METAL6_2765900_483000 0.0314
R_VDD17_5735 METAL6_2765900_483000 METAL6_2751900_483000 0.028
R_VDD17_5736 METAL6_2751900_483000 METAL6_2728200_483000 0.0474
R_VDD17_5737 METAL6_2728200_483000 METAL6_2710900_483000 0.0346
R_VDD17_5738 METAL6_2710900_483000 METAL6_2698900_483000 0.024
R_VDD17_5739 METAL6_2698900_483000 METAL6_2686900_483000 0.024
R_VDD17_5740 METAL6_2686900_483000 METAL6_2683200_483000 0.0074
R_VDD17_5741 METAL6_2683200_483000 METAL6_2676200_483000 0.014
R_VDD17_5742 METAL6_2676200_483000 METAL6_2664200_483000 0.024
R_VDD17_5743 METAL6_2664200_483000 METAL6_2660600_483000 0.0072
R_VDD17_5744 METAL6_2660600_483000 METAL6_2652200_483000 0.0168
R_VDD17_5745 METAL6_2652200_483000 METAL6_2646600_483000 0.0112
R_VDD17_5746 METAL6_2646600_483000 METAL6_2604400_483000 0.0844
R_VDD17_5747 METAL6_2604400_483000 METAL6_2592400_483000 0.024
R_VDD17_5748 METAL6_2592400_483000 METAL6_2580400_483000 0.024
R_VDD17_5749 METAL6_2580400_483000 METAL6_2568400_483000 0.024
R_VDD17_5750 METAL6_2568400_483000 METAL6_2565900_483000 0.005
R_VDD17_5751 METAL6_2565900_483000 METAL6_2556400_483000 0.019
R_VDD17_5752 METAL6_2556400_483000 METAL6_2551900_483000 0.009
R_VDD17_5753 METAL6_2551900_483000 METAL6_2548000_483000 0.0078
R_VDD17_5754 METAL6_2548000_483000 METAL6_2537600_483000 0.0208
R_VDD17_5755 METAL6_2537600_483000 METAL6_2536000_483000 0.0032
R_VDD17_5756 METAL6_2536000_483000 METAL6_2535400_483000 0.0012
R_VDD17_5757 METAL6_2535400_483000 METAL6_2529000_483000 0.0128
R_VDD17_5758 METAL6_2529000_483000 METAL6_2528400_483000 0.0012
R_VDD17_5759 METAL6_2528400_483000 METAL6_2525600_483000 0.0056
R_VDD17_5760 METAL6_2525600_483000 METAL6_2524000_483000 0.0032
R_VDD17_5761 METAL6_2524000_483000 METAL6_2517000_483000 0.014
R_VDD17_5762 METAL6_2517000_483000 METAL6_2516400_483000 0.0012
R_VDD17_5763 METAL6_2516400_483000 METAL6_2513600_483000 0.0056
R_VDD17_5764 METAL6_2513600_483000 METAL6_2512000_483000 0.0032
R_VDD17_5765 METAL6_2512000_483000 METAL6_2510900_483000 0.0022
R_VDD17_5766 METAL6_2510900_483000 METAL6_2505000_483000 0.0118
R_VDD17_5767 METAL6_2505000_483000 METAL6_2504400_483000 0.0012
R_VDD17_5768 METAL6_2504400_483000 METAL6_2501600_483000 0.0056
R_VDD17_5769 METAL6_2501600_483000 METAL6_2500000_483000 0.0032
R_VDD17_5770 METAL6_2500000_483000 METAL6_2498900_483000 0.0022
R_VDD17_5771 METAL6_2498900_483000 METAL6_2496600_483000 0.0046
R_VDD17_5772 METAL6_2496600_483000 METAL6_2493000_483000 0.0072
R_VDD17_5773 METAL6_2493000_483000 METAL6_2493000_488000 0.01
R_VDD17_5774 METAL6_2493000_488000 METAL6_2493000_492400 0.0088
R_VDD17_5775 METAL6_2493000_492400 METAL6_2493000_495000 0.0052
R_VDD17_5776 METAL6_2493000_495000 METAL6_2493000_500000 0.01
R_VDD17_5777 METAL6_2493000_500000 METAL6_2493000_504000 0.008
R_VDD17_5778 METAL6_2493000_504000 METAL6_2493000_507000 0.006
R_VDD17_5779 METAL6_2493000_507000 METAL6_2493000_507800 0.0016
R_VDD17_5780 METAL6_2493000_507800 METAL6_2493000_512000 0.0084
R_VDD17_5781 METAL6_2493000_512000 METAL6_2493000_516000 0.008
R_VDD17_5782 METAL6_2493000_516000 METAL6_2493000_519000 0.006
R_VDD17_5783 METAL6_2493000_519000 METAL6_2493000_520200 0.0024
R_VDD17_5784 METAL6_2493000_520200 METAL6_2493000_528000 0.0156
R_VDD17_5785 METAL6_2493000_528000 METAL6_2493000_532200 0.0084
R_VDD17_5786 METAL6_2493000_532200 METAL6_2493000_535400 0.0064
R_VDD17_5787 METAL6_2493000_535400 METAL6_2493000_544200 0.0176
R_VDD17_5788 METAL6_2493000_544200 METAL6_2493000_547400 0.0064
R_VDD17_5789 METAL6_2493000_547400 METAL6_2493000_550400 0.006
R_VDD17_5790 METAL6_2493000_550400 METAL6_2492400_550400 0.0012
R_VDD17_5791 METAL6_2492400_550400 METAL6_2489600_550400 0.0056
R_VDD17_5792 METAL6_2489600_550400 METAL6_2489600_556200 0.0116
R_VDD17_5793 METAL6_2489600_556200 METAL6_2489600_559400 0.0064
R_VDD17_5794 METAL6_2489600_559400 METAL6_2488000_559400 0.0032
R_VDD17_5795 METAL6_2488000_559400 METAL6_2488000_561000 0.0032
R_VDD17_5796 METAL6_2488000_561000 METAL6_2488000_562400 0.0028
R_VDD17_5797 METAL6_2488000_562400 METAL6_2488000_573000 0.0212
R_VDD17_5798 METAL6_2488000_573000 METAL6_2488000_574400 0.0028
R_VDD17_5799 METAL6_2488000_574400 METAL6_2488000_579800 0.0108
R_VDD17_5800 METAL6_2488000_579800 METAL6_2488000_585000 0.0104
R_VDD17_5801 METAL6_2488000_585000 METAL6_2488000_586400 0.0028
R_VDD17_5802 METAL6_2488000_586400 METAL6_2488000_588000 0.0032
R_VDD17_5803 METAL6_2488000_588000 METAL6_2488000_597000 0.018
R_VDD17_5804 METAL6_2488000_597000 METAL6_2488000_598400 0.0028
R_VDD17_5805 METAL6_2488000_598400 METAL6_2488000_600000 0.0032
R_VDD17_5806 METAL6_2488000_600000 METAL6_2488000_605400 0.0108
R_VDD17_5807 METAL6_2488000_605400 METAL6_2488000_612000 0.0132
R_VDD17_5808 METAL6_2488000_612000 METAL6_2488000_617400 0.0108
R_VDD17_5809 METAL6_2488000_617400 METAL6_2488000_629400 0.024
R_VDD17_5810 METAL6_2488000_629400 METAL6_2488000_637800 0.0168
R_VDD17_5811 METAL6_2488000_637800 METAL6_2488000_641400 0.0072
R_VDD17_5812 METAL6_2488000_641400 METAL6_2488000_649800 0.0168
R_VDD17_5813 METAL6_2488000_649800 METAL6_2488000_653400 0.0072
R_VDD17_5814 METAL6_2488000_653400 METAL6_2488000_661800 0.0168
R_VDD17_5815 METAL6_2488000_661800 METAL6_2488000_665400 0.0072
R_VDD17_5816 METAL6_2488000_665400 METAL6_2488000_688000 0.0452
R_VDD17_5817 METAL6_2488000_688000 METAL6_2488000_697800 0.0196
R_VDD17_5818 METAL6_2488000_697800 METAL6_2486900_697800 0.0022
R_VDD17_5819 METAL6_2486900_697800 METAL6_2484600_697800 0.0046
R_VDD17_5820 METAL6_2484600_697800 METAL6_2481000_697800 0.0072
R_VDD17_5821 METAL6_2481000_697800 METAL6_2480400_697800 0.0012
R_VDD17_5822 METAL6_2480400_697800 METAL6_2477600_697800 0.0056
R_VDD17_5823 METAL6_2477600_697800 METAL6_2477600_700000 0.0044
R_VDD17_5824 METAL6_2477600_700000 METAL6_2477600_702800 0.0056
R_VDD17_5825 METAL6_2477600_702800 METAL6_2477600_709800 0.014
R_VDD17_5826 METAL6_2477600_709800 METAL6_2476000_709800 0.0032
R_VDD17_5827 METAL6_2476000_709800 METAL6_2472600_709800 0.0068
R_VDD17_5828 METAL6_2472600_709800 METAL6_2472600_712000 0.0044
R_VDD17_5829 METAL6_2472600_712000 METAL6_2472600_716800 0.0096
R_VDD17_5830 METAL6_2472600_716800 METAL6_2472600_721800 0.01
R_VDD17_5831 METAL6_2472600_721800 METAL6_2470600_721800 0.004
R_VDD17_5832 METAL6_2470600_721800 METAL6_2469000_721800 0.0032
R_VDD17_5833 METAL6_2469000_721800 METAL6_2468400_721800 0.0012
R_VDD17_5834 METAL6_2468400_721800 METAL6_2465600_721800 0.0056
R_VDD17_5835 METAL6_2465600_721800 METAL6_2464000_721800 0.0032
R_VDD17_5836 METAL6_2464000_721800 METAL6_2460600_721800 0.0068
R_VDD17_5837 METAL6_2460600_721800 METAL6_2458600_721800 0.004
R_VDD17_5838 METAL6_2458600_721800 METAL6_2457000_721800 0.0032
R_VDD17_5839 METAL6_2457000_721800 METAL6_2448600_721800 0.0168
R_VDD17_5840 METAL6_2448600_721800 METAL6_2446600_721800 0.004
R_VDD17_5841 METAL6_2446600_721800 METAL6_2436600_721800 0.02
R_VDD17_5842 METAL6_2436600_721800 METAL6_2434600_721800 0.004
R_VDD17_5843 METAL6_2434600_721800 METAL6_2424600_721800 0.02
R_VDD17_5844 METAL6_2424600_721800 METAL6_2422600_721800 0.004
R_VDD17_5845 METAL6_2422600_721800 METAL6_2419100_721800 0.007
R_VDD17_5846 METAL6_2419100_721800 METAL6_2407100_721800 0.024
R_VDD17_5847 METAL6_2407100_721800 METAL6_2405600_721800 0.003
R_VDD17_5848 METAL6_2405600_721800 METAL6_2402100_721800 0.007
R_VDD17_5849 METAL6_2402100_721800 METAL6_2395100_721800 0.014
R_VDD17_5850 METAL6_2395100_721800 METAL6_2393600_721800 0.003
R_VDD17_5851 METAL6_2393600_721800 METAL6_2383100_721800 0.021
R_VDD17_5852 METAL6_2383100_721800 METAL6_2381600_721800 0.003
R_VDD17_5853 METAL6_2381600_721800 METAL6_2371100_721800 0.021
R_VDD17_5854 METAL6_2371100_721800 METAL6_2369600_721800 0.003
R_VDD17_5855 METAL6_2369600_721800 METAL6_2365900_721800 0.0074
R_VDD17_5856 METAL6_2365900_721800 METAL6_2357600_721800 0.0166
R_VDD17_5857 METAL6_2357600_721800 METAL6_2351900_721800 0.0114
R_VDD17_5858 METAL6_2351900_721800 METAL6_2343700_721800 0.0164
R_VDD17_5859 METAL6_2343700_721800 METAL6_2322900_721800 0.0416
R_VDD17_5860 METAL6_2322900_721800 METAL6_2320600_721800 0.0046
R_VDD17_5861 METAL6_2320600_721800 METAL6_2310900_721800 0.0194
R_VDD17_5862 METAL6_2310900_721800 METAL6_2308600_721800 0.0046
R_VDD17_5863 METAL6_2308600_721800 METAL6_2298900_721800 0.0194
R_VDD17_5864 METAL6_2298900_721800 METAL6_2296600_721800 0.0046
R_VDD17_5865 METAL6_2296600_721800 METAL6_2286900_721800 0.0194
R_VDD17_5866 METAL6_2286900_721800 METAL6_2284600_721800 0.0046
R_VDD17_5867 METAL6_2284600_721800 METAL6_2284600_722400 0.0012
R_VDD17_5868 METAL6_2284600_722400 METAL6_2284600_733800 0.0228
R_VDD17_5869 METAL6_2284600_733800 METAL6_2284600_734400 0.0012
R_VDD17_5870 METAL6_2284600_734400 METAL6_2284600_735400 0.002
R_VDD17_5871 METAL6_2284600_735400 METAL6_2284600_742400 0.014
R_VDD17_5872 METAL6_2284600_742400 METAL6_2284600_745800 0.0068
R_VDD17_5873 METAL6_2284600_745800 METAL6_2284600_746400 0.0012
R_VDD17_5874 METAL6_2284600_746400 METAL6_2284600_754400 0.016
R_VDD17_5875 METAL6_2284600_754400 METAL6_2284400_754400 0.0004
R_VDD17_5876 METAL6_2284400_754400 METAL6_2274900_754400 0.019
R_VDD17_5877 METAL6_2274900_754400 METAL6_2272600_754400 0.0046
R_VDD17_5878 METAL6_2272600_754400 METAL6_2272400_754400 0.0004
R_VDD17_5879 METAL6_2272400_754400 METAL6_2260600_754400 0.0236
R_VDD17_5880 METAL6_2260600_754400 METAL6_2260600_757800 0.0068
R_VDD17_5881 METAL6_2260600_757800 METAL6_2260600_758400 0.0012
R_VDD17_5882 METAL6_2260600_758400 METAL6_2260400_758400 0.0004
R_VDD17_5883 METAL6_2260400_758400 METAL6_2258600_758400 0.0036
R_VDD17_5884 METAL6_2258600_758400 METAL6_2248700_758400 0.0198
R_VDD17_5885 METAL6_2248700_758400 METAL6_2248600_758400 0.0002
R_VDD17_5886 METAL6_2248600_758400 METAL6_2248400_758400 0.0004
R_VDD17_5887 METAL6_2248400_758400 METAL6_2246600_758400 0.0036
R_VDD17_5888 METAL6_2246600_758400 METAL6_2236700_758400 0.0198
R_VDD17_5889 METAL6_2236700_758400 METAL6_2236600_758400 0.0002
R_VDD17_5890 METAL6_2236600_758400 METAL6_2234600_758400 0.004
R_VDD17_5891 METAL6_2234600_758400 METAL6_2234600_760000 0.0032
R_VDD17_5892 METAL6_2234600_760000 METAL6_2234600_763000 0.006
R_VDD17_5893 METAL6_2234600_763000 METAL6_2234600_766400 0.0068
R_VDD17_5894 METAL6_2234600_766400 METAL6_2234600_769800 0.0068
R_VDD17_5895 METAL6_2234600_769800 METAL6_2233900_769800 0.0014
R_VDD17_5896 METAL6_2233900_769800 METAL6_2224700_769800 0.0184
R_VDD17_5897 METAL6_2224700_769800 METAL6_2224700_770400 0.0012
R_VDD17_5898 METAL6_2224700_770400 METAL6_2224700_772000 0.0032
R_VDD17_5899 METAL6_2224700_772000 METAL6_2224700_778400 0.0128
R_VDD17_5900 METAL6_2224700_778400 METAL6_2224700_779200 0.0016
R_VDD17_5901 METAL6_2224700_779200 METAL6_2224700_782400 0.0064
R_VDD17_5902 METAL6_2224700_782400 METAL6_2224700_784000 0.0032
R_VDD17_5903 METAL6_2224700_784000 METAL6_2224700_784500 0.001
R_VDD17_5904 METAL6_2224700_784500 METAL6_2224700_788000 0.007
R_VDD17_5905 METAL6_2224700_788000 METAL6_2224700_790400 0.0048
R_VDD17_5906 METAL6_2224700_790400 METAL6_2224700_791200 0.0016
R_VDD17_5907 METAL6_2224700_791200 METAL6_2224700_794400 0.0064
R_VDD17_5908 METAL6_2224700_794400 METAL6_2224700_794800 0.0008
R_VDD17_5909 METAL6_2224700_794800 METAL6_2224700_800000 0.0104
R_VDD17_5910 METAL6_2224700_800000 METAL6_2224700_802400 0.0048
R_VDD17_5911 METAL6_2224700_802400 METAL6_2224700_803200 0.0016
R_VDD17_5912 METAL6_2224700_803200 METAL6_2224700_806400 0.0064
R_VDD17_5913 METAL6_2224700_806400 METAL6_2224700_808000 0.0032
R_VDD17_5914 METAL6_2224700_808000 METAL6_2224700_812000 0.008
R_VDD17_5915 METAL6_2224700_812000 METAL6_2224700_814400 0.0048
R_VDD17_5916 METAL6_2224700_814400 METAL6_2224700_818400 0.008
R_VDD17_5917 METAL6_2224700_818400 METAL6_2224700_820000 0.0032
R_VDD17_5918 METAL6_2224700_820000 METAL6_2224700_828700 0.0174
R_VDD17_5919 METAL6_2224700_828700 METAL6_2224700_830400 0.0034
R_VDD17_5920 METAL6_2224700_830400 METAL6_2224700_832000 0.0032
R_VDD17_5921 METAL6_2224700_832000 METAL6_2224700_839500 0.015
R_VDD17_5922 METAL6_2224700_839500 METAL6_2224700_840700 0.0024
R_VDD17_5923 METAL6_2224700_840700 METAL6_2224700_842400 0.0034
R_VDD17_5924 METAL6_2224700_842400 METAL6_2224700_851500 0.0182
R_VDD17_5925 METAL6_2224700_851500 METAL6_2224700_852700 0.0024
R_VDD17_5926 METAL6_2224700_852700 METAL6_2224700_854400 0.0034
R_VDD17_5927 METAL6_2224700_854400 METAL6_2224700_858200 0.0076
R_VDD17_5928 METAL6_2224700_858200 METAL6_2224700_863500 0.0106
R_VDD17_5929 METAL6_2224700_863500 METAL6_2224700_875000 0.023
R_VDD17_5930 METAL6_2224700_875000 METAL6_2224700_887000 0.024
R_VDD17_5931 METAL6_2224700_887000 METAL6_2224700_888000 0.002
R_VDD17_5932 METAL6_2224700_888000 METAL6_2224700_899000 0.022
R_VDD17_5933 METAL6_2224700_899000 METAL6_2224700_900000 0.002
R_VDD17_5934 METAL6_2224700_900000 METAL6_2224700_900400 0.0008
R_VDD17_5935 METAL6_2224700_900400 METAL6_2224700_911000 0.0212
R_VDD17_5936 METAL6_2224700_911000 METAL6_2224700_912000 0.002
R_VDD17_5937 METAL6_2224700_912000 METAL6_2224700_923000 0.022
R_VDD17_5938 METAL6_2224700_923000 METAL6_2224700_927300 0.0086
R_VDD17_5939 METAL6_2224700_927300 METAL6_2224700_935000 0.0154
R_VDD17_5940 METAL6_2224700_935000 METAL6_2224700_947000 0.024
R_VDD17_5941 METAL6_2224700_947000 METAL6_2224700_959000 0.024
R_VDD17_5942 METAL6_2224700_959000 METAL6_2224700_971000 0.024
R_VDD17_5943 METAL6_2224700_971000 METAL6_2224600_971000 0.0002
R_VDD17_5944 METAL6_2224600_971000 METAL6_2222600_971000 0.004
R_VDD17_5945 METAL6_2222600_971000 METAL6_2221900_971000 0.0014
R_VDD17_5946 METAL6_2221900_971000 METAL6_2212700_971000 0.0184
R_VDD17_5947 METAL6_2212700_971000 METAL6_2210600_971000 0.0042
R_VDD17_5948 METAL6_2210600_971000 METAL6_2209900_971000 0.0014
R_VDD17_5949 METAL6_2209900_971000 METAL6_2200700_971000 0.0184
R_VDD17_5950 METAL6_2200700_971000 METAL6_2189900_971000 0.0216
R_VDD17_5951 METAL6_2189900_971000 METAL6_2188700_971000 0.0024
R_VDD17_5952 METAL6_2188700_971000 METAL6_2177900_971000 0.0216
R_VDD17_5953 METAL6_2177900_971000 METAL6_2176700_971000 0.0024
R_VDD17_5954 METAL6_2176700_971000 METAL6_2165900_971000 0.0216
R_VDD17_5955 METAL6_2165900_971000 METAL6_2165400_971000 0.001
R_VDD17_5956 METAL6_2165400_971000 METAL6_2153900_971000 0.023
R_VDD17_5957 METAL6_2153900_971000 METAL6_2153400_971000 0.001
R_VDD17_5958 METAL6_2153400_971000 METAL6_2151900_971000 0.003
R_VDD17_5959 METAL6_2151900_971000 METAL6_2141900_971000 0.02
R_VDD17_5960 METAL6_2141900_971000 METAL6_2141400_971000 0.001
R_VDD17_5961 METAL6_2141400_971000 METAL6_2129900_971000 0.023
R_VDD17_5962 METAL6_2129900_971000 METAL6_2129700_971000 0.0004
R_VDD17_5963 METAL6_2129700_971000 METAL6_2125600_971000 0.0082
R_VDD17_5964 METAL6_2125600_971000 METAL6_2121400_971000 0.0084
R_VDD17_5965 METAL6_2121400_971000 METAL6_2117900_971000 0.007
R_VDD17_5966 METAL6_2117900_971000 METAL6_2113900_971000 0.008
R_VDD17_5967 METAL6_2113900_971000 METAL6_2113600_971000 0.0006
R_VDD17_5968 METAL6_2113600_971000 METAL6_2105900_971000 0.0154
R_VDD17_5969 METAL6_2105900_971000 METAL6_2101900_971000 0.008
R_VDD17_5970 METAL6_2101900_971000 METAL6_2101600_971000 0.0006
R_VDD17_5971 METAL6_2101600_971000 METAL6_2089900_971000 0.0234
R_VDD17_5972 METAL6_2089900_971000 METAL6_2079700_971000 0.0204
R_VDD17_5973 METAL6_2079700_971000 METAL6_2077900_971000 0.0036
R_VDD17_5974 METAL6_2077900_971000 METAL6_2067700_971000 0.0204
R_VDD17_5975 METAL6_2067700_971000 METAL6_2060600_971000 0.0142
R_VDD17_5976 METAL6_2060600_971000 METAL6_2058800_971000 0.0036
R_VDD17_5977 METAL6_2058800_971000 METAL6_2055700_971000 0.0062
R_VDD17_5978 METAL6_2055700_971000 METAL6_2046800_971000 0.0178
R_VDD17_5979 METAL6_2046800_971000 METAL6_2046600_971000 0.0004
R_VDD17_5980 METAL6_2046600_971000 METAL6_2046400_971000 0.0004
R_VDD17_5981 METAL6_2046400_971000 METAL6_2043700_971000 0.0054
R_VDD17_5982 METAL6_2043700_971000 METAL6_2034800_971000 0.0178
R_VDD17_5983 METAL6_2034800_971000 METAL6_2031700_971000 0.0062
R_VDD17_5984 METAL6_2031700_971000 METAL6_2030900_971000 0.0016
R_VDD17_5985 METAL6_2030900_971000 METAL6_2026400_971000 0.009
R_VDD17_5986 METAL6_2026400_971000 METAL6_2021200_971000 0.0104
R_VDD17_5987 METAL6_2021200_971000 METAL6_2019700_971000 0.003
R_VDD17_5988 METAL6_2019700_971000 METAL6_2018900_971000 0.0016
R_VDD17_5989 METAL6_2018900_971000 METAL6_2014400_971000 0.009
R_VDD17_5990 METAL6_2014400_971000 METAL6_2012000_971000 0.0048
R_VDD17_5991 METAL6_2012000_971000 METAL6_2007700_971000 0.0086
R_VDD17_5992 METAL6_2007700_971000 METAL6_2006900_971000 0.0016
R_VDD17_5993 METAL6_2006900_971000 METAL6_2002400_971000 0.009
R_VDD17_5994 METAL6_2002400_971000 METAL6_2000000_971000 0.0048
R_VDD17_5995 METAL6_2000000_971000 METAL6_1988000_971000 0.024
R_VDD17_5996 METAL6_1988000_971000 METAL6_1963900_971000 0.0482
R_VDD17_5997 METAL6_1963900_971000 METAL6_1951900_971000 0.024
R_VDD17_5998 METAL6_1951900_971000 METAL6_1951800_971000 0.0002
R_VDD17_5999 METAL6_1951800_971000 METAL5_1951800_971000 0.1
R_VDD17_6000 METAL5_1951800_971000 METAL5_1939900_971000 0.0476
R_VDD17_6001 METAL5_1939900_971000 METAL5_1939800_971000 0.0004
R_VDD17_6002 METAL5_1939800_971000 METAL5_1937600_971000 0.0088
R_VDD17_6003 METAL5_1937600_971000 METAL5_1931200_971000 0.0256
R_VDD17_6004 METAL5_1931200_971000 METAL5_1927800_971000 0.0136
R_VDD17_6005 METAL5_1927800_971000 METAL5_1926200_971000 0.0064
R_VDD17_6006 METAL5_1926200_971000 METAL5_1925600_971000 0.0024
R_VDD17_6007 METAL5_1925600_971000 METAL5_1919200_971000 0.0256
R_VDD17_6008 METAL5_1919200_971000 METAL5_1913600_971000 0.0224
R_VDD17_6009 METAL5_1913600_971000 METAL5_1907400_971000 0.0248
R_VDD17_6010 METAL5_1907400_971000 METAL5_1907200_971000 0.0008
R_VDD17_6011 METAL5_1907200_971000 METAL5_1901600_971000 0.0224
R_VDD17_6012 METAL5_1901600_971000 METAL5_1900700_971000 0.0036
R_VDD17_6013 METAL5_1900700_971000 METAL5_1895200_971000 0.022
R_VDD17_6014 METAL5_1895200_971000 METAL5_1889600_971000 0.0224
R_VDD17_6015 METAL5_1889600_971000 METAL5_1889400_971000 0.0008
R_VDD17_6016 METAL5_1889400_971000 METAL5_1888700_971000 0.0028
R_VDD17_6017 METAL5_1888700_971000 METAL5_1883200_971000 0.022
R_VDD17_6018 METAL5_1883200_971000 METAL5_1877600_971000 0.0224
R_VDD17_6019 METAL5_1877600_971000 METAL5_1877400_971000 0.0008
R_VDD17_6020 METAL5_1877400_971000 METAL5_1876700_971000 0.0028
R_VDD17_6021 METAL5_1876700_971000 METAL5_1874700_971000 0.008
R_VDD17_6022 METAL5_1874700_971000 METAL5_1871200_971000 0.014
R_VDD17_6023 METAL5_1871200_971000 METAL5_1870600_971000 0.0024
R_VDD17_6024 METAL5_1870600_971000 METAL5_1865600_971000 0.02
R_VDD17_6025 METAL5_1865600_971000 METAL5_1865400_971000 0.0008
R_VDD17_6026 METAL5_1865400_971000 METAL5_1864700_971000 0.0028
R_VDD17_6027 METAL5_1864700_971000 METAL5_1859200_971000 0.022
R_VDD17_6028 METAL5_1859200_971000 METAL5_1858600_971000 0.0024
R_VDD17_6029 METAL5_1858600_971000 METAL5_1858400_971000 0.0008
R_VDD17_6030 METAL5_1858400_971000 METAL5_1853400_971000 0.02
R_VDD17_6031 METAL5_1853400_971000 METAL5_1852700_971000 0.0028
R_VDD17_6032 METAL5_1852700_971000 METAL5_1847200_971000 0.022
R_VDD17_6033 METAL5_1847200_971000 METAL5_1846800_971000 0.0016
R_VDD17_6034 METAL5_1846800_971000 METAL5_1846600_971000 0.0008
R_VDD17_6035 METAL5_1846600_971000 METAL5_1846400_971000 0.0008
R_VDD17_6036 METAL5_1846400_971000 METAL5_1844800_971000 0.0064
R_VDD17_6037 METAL5_1844800_971000 METAL5_1841400_971000 0.0136
R_VDD17_6038 METAL5_1841400_971000 METAL5_1834600_971000 0.0272
R_VDD17_6039 METAL5_1834600_971000 METAL5_1834400_971000 0.0008
R_VDD17_6040 METAL5_1834400_971000 METAL5_1832800_971000 0.0064
R_VDD17_6041 METAL5_1832800_971000 METAL5_1822600_971000 0.0408
R_VDD17_6042 METAL5_1822600_971000 METAL5_1822400_971000 0.0008
R_VDD17_6043 METAL5_1822400_971000 METAL5_1820800_971000 0.0064
R_VDD17_6044 METAL5_1820800_971000 METAL5_1812000_971000 0.0352
R_VDD17_6045 METAL5_1812000_971000 METAL5_1810600_971000 0.0056
R_VDD17_6046 METAL5_1810600_971000 METAL5_1800000_971000 0.0424
R_VDD17_6047 METAL5_1800000_971000 METAL5_1788000_971000 0.048
R_VDD17_6048 METAL5_1788000_971000 METAL5_1787400_971000 0.0024
R_VDD17_6049 METAL5_1787400_971000 METAL5_1775400_971000 0.048
R_VDD17_6050 METAL5_1775400_971000 METAL5_1768000_971000 0.0296
R_VDD17_6051 METAL5_1768000_971000 METAL5_1767700_971000 0.0012
R_VDD17_6052 METAL5_1767700_971000 METAL5_1763800_971000 0.0156
R_VDD17_6053 METAL5_1763800_971000 METAL5_1763400_971000 0.0016
R_VDD17_6054 METAL5_1763400_971000 METAL5_1756000_971000 0.0296
R_VDD17_6055 METAL5_1756000_971000 METAL5_1755700_971000 0.0012
R_VDD17_6056 METAL5_1755700_971000 METAL5_1753800_971000 0.0076
R_VDD17_6057 METAL5_1753800_971000 METAL5_1751800_971000 0.008
R_VDD17_6058 METAL5_1751800_971000 METAL5_1751400_971000 0.0016
R_VDD17_6059 METAL5_1751400_971000 METAL5_1744000_971000 0.0296
R_VDD17_6060 METAL5_1744000_971000 METAL5_1743700_971000 0.0012
R_VDD17_6061 METAL5_1743700_971000 METAL5_1741800_971000 0.0076
R_VDD17_6062 METAL5_1741800_971000 METAL5_1739800_971000 0.008
R_VDD17_6063 METAL5_1739800_971000 METAL5_1739400_971000 0.0016
R_VDD17_6064 METAL5_1739400_971000 METAL5_1732000_971000 0.0296
R_VDD17_6065 METAL5_1732000_971000 METAL5_1731700_971000 0.0012
R_VDD17_6066 METAL5_1731700_971000 METAL5_1729800_971000 0.0076
R_VDD17_6067 METAL5_1729800_971000 METAL5_1727800_971000 0.008
R_VDD17_6068 METAL5_1727800_971000 METAL5_1719700_971000 0.0324
R_VDD17_6069 METAL5_1719700_971000 METAL5_1717800_971000 0.0076
R_VDD17_6070 METAL5_1717800_971000 METAL5_1710800_971000 0.028
R_VDD17_6071 METAL5_1710800_971000 METAL5_1707700_971000 0.0124
R_VDD17_6072 METAL5_1707700_971000 METAL5_1699000_971000 0.0348
R_VDD17_6073 METAL5_1699000_971000 METAL5_1692000_971000 0.028
R_VDD17_6074 METAL5_1692000_971000 METAL5_1682800_971000 0.0368
R_VDD17_6075 METAL5_1682800_971000 METAL5_1680000_971000 0.0112
R_VDD17_6076 METAL5_1680000_971000 METAL5_1670800_971000 0.0368
R_VDD17_6077 METAL5_1670800_971000 METAL5_1668000_971000 0.0112
R_VDD17_6078 METAL5_1668000_971000 METAL5_1658800_971000 0.0368
R_VDD17_6079 METAL5_1658800_971000 METAL5_1646800_971000 0.048
R_VDD17_6080 METAL5_1646800_971000 METAL5_1636700_971000 0.0404
R_VDD17_6081 METAL5_1636700_971000 METAL5_1636000_971000 0.0028
R_VDD17_6082 METAL5_1636000_971000 METAL5_1634800_971000 0.0048
R_VDD17_6083 METAL5_1634800_971000 METAL5_1632800_971000 0.008
R_VDD17_6084 METAL5_1632800_971000 METAL5_1627800_971000 0.02
R_VDD17_6085 METAL5_1627800_971000 METAL5_1624700_971000 0.0124
R_VDD17_6086 METAL5_1624700_971000 METAL5_1624000_971000 0.0028
R_VDD17_6087 METAL5_1624000_971000 METAL5_1615800_971000 0.0328
R_VDD17_6088 METAL5_1615800_971000 METAL5_1612700_971000 0.0124
R_VDD17_6089 METAL5_1612700_971000 METAL5_1612000_971000 0.0028
R_VDD17_6090 METAL5_1612000_971000 METAL5_1607900_971000 0.0164
R_VDD17_6091 METAL5_1607900_971000 METAL5_1603800_971000 0.0164
R_VDD17_6092 METAL5_1603800_971000 METAL5_1600700_971000 0.0124
R_VDD17_6093 METAL5_1600700_971000 METAL5_1600000_971000 0.0028
R_VDD17_6094 METAL5_1600000_971000 METAL5_1591800_971000 0.0328
R_VDD17_6095 METAL5_1591800_971000 METAL5_1588700_971000 0.0124
R_VDD17_6096 METAL5_1588700_971000 METAL6_1588700_971000 0.1
R_VDD17_6097 METAL6_1588700_971000 METAL6_1588000_971000 0.0014
R_VDD17_6098 METAL6_1588000_971000 METAL6_1579800_971000 0.0164
R_VDD17_6099 METAL6_1579800_971000 METAL6_1576700_971000 0.0062
R_VDD17_6100 METAL6_1576700_971000 METAL6_1576000_971000 0.0014
R_VDD17_6101 METAL6_1576000_971000 METAL6_1574700_971000 0.0026
R_VDD17_6102 METAL6_1574700_971000 METAL6_1569000_971000 0.0114
R_VDD17_6103 METAL6_1569000_971000 METAL6_1567800_971000 0.0024
R_VDD17_6104 METAL6_1567800_971000 METAL6_1564000_971000 0.0076
R_VDD17_6105 METAL6_1564000_971000 METAL6_1557000_971000 0.014
R_VDD17_6106 METAL6_1557000_971000 METAL6_1555400_971000 0.0032
R_VDD17_6107 METAL6_1555400_971000 METAL6_1552000_971000 0.0068
R_VDD17_6108 METAL6_1552000_971000 METAL6_1551800_971000 0.0004
R_VDD17_6109 METAL6_1551800_971000 METAL6_1545000_971000 0.0136
R_VDD17_6110 METAL6_1545000_971000 METAL6_1540000_971000 0.01
R_VDD17_6111 METAL6_1540000_971000 METAL6_1539800_971000 0.0004
R_VDD17_6112 METAL6_1539800_971000 METAL6_1527800_971000 0.024
R_VDD17_6113 METAL6_1527800_971000 METAL6_1512000_971000 0.0316
R_VDD17_6114 METAL6_1512000_971000 METAL6_1510400_971000 0.0032
R_VDD17_6115 METAL6_1510400_971000 METAL6_1503400_971000 0.014
R_VDD17_6116 METAL6_1503400_971000 METAL6_1500000_971000 0.0068
R_VDD17_6117 METAL6_1500000_971000 METAL6_1498300_971000 0.0034
R_VDD17_6118 METAL6_1498300_971000 METAL6_1491400_971000 0.0138
R_VDD17_6119 METAL6_1491400_971000 METAL6_1488000_971000 0.0068
R_VDD17_6120 METAL6_1488000_971000 METAL6_1479400_971000 0.0172
R_VDD17_6121 METAL6_1479400_971000 METAL6_1444800_971000 0.0692
R_VDD17_6122 METAL6_1444800_971000 METAL6_1443700_971000 0.0022
R_VDD17_6123 METAL6_1443700_971000 METAL6_1432800_971000 0.0218
R_VDD17_6124 METAL6_1432800_971000 METAL6_1431700_971000 0.0022
R_VDD17_6125 METAL6_1431700_971000 METAL6_1424000_971000 0.0154
R_VDD17_6126 METAL6_1424000_971000 METAL6_1420800_971000 0.0064
R_VDD17_6127 METAL6_1420800_971000 METAL6_1419700_971000 0.0022
R_VDD17_6128 METAL6_1419700_971000 METAL6_1412000_971000 0.0154
R_VDD17_6129 METAL6_1412000_971000 METAL6_1408800_971000 0.0064
R_VDD17_6130 METAL6_1408800_971000 METAL6_1400000_971000 0.0176
R_VDD17_6131 METAL6_1400000_971000 METAL6_1396800_971000 0.0064
R_VDD17_6132 METAL6_1396800_971000 METAL6_1388000_971000 0.0176
R_VDD17_6133 METAL6_1388000_971000 METAL6_1349000_971000 0.078
R_VDD17_6134 METAL6_1349000_971000 METAL6_1348000_971000 0.002
R_VDD17_6135 METAL6_1348000_971000 METAL6_1337000_971000 0.022
R_VDD17_6136 METAL6_1337000_971000 METAL6_1336000_971000 0.002
R_VDD17_6137 METAL6_1336000_971000 METAL6_1325000_971000 0.022
R_VDD17_6138 METAL6_1325000_971000 METAL6_1324000_971000 0.002
R_VDD17_6139 METAL6_1324000_971000 METAL6_1323800_971000 0.0004
R_VDD17_6140 METAL6_1323800_971000 METAL6_1313000_971000 0.0216
R_VDD17_6141 METAL6_1313000_971000 METAL6_1312000_971000 0.002
R_VDD17_6142 METAL6_1312000_971000 METAL6_1311800_971000 0.0004
R_VDD17_6143 METAL6_1311800_971000 METAL6_1301000_971000 0.0216
R_VDD17_6144 METAL6_1301000_971000 METAL6_1300000_971000 0.002
R_VDD17_6145 METAL6_1300000_971000 METAL6_1299800_971000 0.0004
R_VDD17_6146 METAL6_1299800_971000 METAL6_1294300_971000 0.011
R_VDD17_6147 METAL6_1294300_971000 METAL6_1289000_971000 0.0106
R_VDD17_6148 METAL6_1289000_971000 METAL6_1288000_971000 0.002
R_VDD17_6149 METAL6_1288000_971000 METAL6_1287800_971000 0.0004
R_VDD17_6150 METAL6_1287800_971000 METAL6_1286700_971000 0.0022
R_VDD17_6151 METAL6_1286700_971000 METAL6_1282300_971000 0.0088
R_VDD17_6152 METAL6_1282300_971000 METAL6_1276000_971000 0.0126
R_VDD17_6153 METAL6_1276000_971000 METAL6_1274700_971000 0.0026
R_VDD17_6154 METAL6_1274700_971000 METAL6_1270300_971000 0.0088
R_VDD17_6155 METAL6_1270300_971000 METAL6_1266800_971000 0.007
R_VDD17_6156 METAL6_1266800_971000 METAL6_1262700_971000 0.0082
R_VDD17_6157 METAL6_1262700_971000 METAL6_1259800_971000 0.0058
R_VDD17_6158 METAL6_1259800_971000 METAL6_1258300_971000 0.003
R_VDD17_6159 METAL6_1258300_971000 METAL6_1254700_971000 0.0072
R_VDD17_6160 METAL6_1254700_971000 METAL6_1253300_971000 0.0028
R_VDD17_6161 METAL6_1253300_971000 METAL6_1248000_971000 0.0106
R_VDD17_6162 METAL6_1248000_971000 METAL6_1247800_971000 0.0004
R_VDD17_6163 METAL6_1247800_971000 METAL6_1246300_971000 0.003
R_VDD17_6164 METAL6_1246300_971000 METAL6_1242700_971000 0.0072
R_VDD17_6165 METAL6_1242700_971000 METAL6_1236000_971000 0.0134
R_VDD17_6166 METAL6_1236000_971000 METAL6_1235800_971000 0.0004
R_VDD17_6167 METAL6_1235800_971000 METAL6_1234300_971000 0.003
R_VDD17_6168 METAL6_1234300_971000 METAL6_1230700_971000 0.0072
R_VDD17_6169 METAL6_1230700_971000 METAL6_1224000_971000 0.0134
R_VDD17_6170 METAL6_1224000_971000 METAL6_1223800_971000 0.0004
R_VDD17_6171 METAL6_1223800_971000 METAL6_1222300_971000 0.003
R_VDD17_6172 METAL6_1222300_971000 METAL6_1218700_971000 0.0072
R_VDD17_6173 METAL6_1218700_971000 METAL5_1218700_971000 0.1
R_VDD17_6174 METAL5_1218700_971000 METAL5_1218700_959000 0.048
R_VDD17_6175 METAL5_1218700_959000 METAL5_1216400_959000 0.0092
R_VDD17_6176 METAL5_1216400_959000 METAL5_1212000_959000 0.0176
R_VDD17_6177 METAL5_1212000_959000 METAL5_1211800_959000 0.0008
R_VDD17_6178 METAL5_1211800_959000 METAL5_1210300_959000 0.006
R_VDD17_6179 METAL5_1210300_959000 METAL5_1206700_959000 0.0144
R_VDD17_6180 METAL5_1206700_959000 METAL5_1204400_959000 0.0092
R_VDD17_6181 METAL5_1204400_959000 METAL5_1200000_959000 0.0176
R_VDD17_6182 METAL5_1200000_959000 METAL5_1199800_959000 0.0008
R_VDD17_6183 METAL5_1199800_959000 METAL5_1198300_959000 0.006
R_VDD17_6184 METAL5_1198300_959000 METAL5_1194700_959000 0.0144
R_VDD17_6185 METAL5_1194700_959000 METAL5_1192400_959000 0.0092
R_VDD17_6186 METAL5_1192400_959000 METAL5_1188000_959000 0.0176
R_VDD17_6187 METAL5_1188000_959000 METAL5_1187800_959000 0.0008
R_VDD17_6188 METAL5_1187800_959000 METAL5_1186300_959000 0.006
R_VDD17_6189 METAL5_1186300_959000 METAL5_1182700_959000 0.0144
R_VDD17_6190 METAL5_1182700_959000 METAL5_1180400_959000 0.0092
R_VDD17_6191 METAL5_1180400_959000 METAL5_1176000_959000 0.0176
R_VDD17_6192 METAL5_1176000_959000 METAL5_1174300_959000 0.0068
R_VDD17_6193 METAL5_1174300_959000 METAL5_1173700_959000 0.0024
R_VDD17_6194 METAL5_1173700_959000 METAL5_1166700_959000 0.028
R_VDD17_6195 METAL5_1166700_959000 METAL5_1162300_959000 0.0176
R_VDD17_6196 METAL5_1162300_959000 METAL5_1154700_959000 0.0304
R_VDD17_6197 METAL5_1154700_959000 METAL5_1154700_971000 0.048
R_VDD17_6198 METAL5_1154700_971000 METAL5_1154700_976000 0.02
R_VDD17_6199 METAL5_1154700_976000 METAL5_1154700_983000 0.028
R_VDD17_6200 METAL5_1154700_983000 METAL5_1154700_988000 0.02
R_VDD17_6201 METAL5_1154700_988000 METAL5_1154700_995000 0.028
R_VDD17_6202 METAL5_1154700_995000 METAL5_1154700_1000000 0.02
R_VDD17_6203 METAL5_1154700_1000000 METAL6_1154700_1000000 0.1
R_VDD17_6204 METAL6_1154700_1000000 METAL6_1154700_1007000 0.014
R_VDD17_6205 METAL6_1154700_1007000 METAL6_1154700_1012000 0.01
R_VDD17_6206 METAL6_1154700_1012000 METAL6_1154700_1014000 0.004
R_VDD17_6207 METAL6_1154700_1014000 METAL6_1154700_1019000 0.01
R_VDD17_6208 METAL6_1154700_1019000 METAL6_1154700_1023700 0.0094
R_VDD17_6209 METAL6_1154700_1023700 METAL6_1154700_1025400 0.0034
R_VDD17_6210 METAL6_1154700_1025400 METAL6_1154700_1026000 0.0012
R_VDD17_6211 METAL6_1166700_1026000 METAL6_1154700_1026000 0.024
I_VDD17_23 METAL6_1166700_1026000 gnd 0.001

V_VDD18_10 METAL5_3500000_500000 gnd 1
R_VDD18_6212 METAL5_3500000_500000 METAL5_3490500_500000 0.038
R_VDD18_6213 METAL5_3490500_500000 METAL6_3490500_500000 0.1
R_VDD18_6214 METAL6_3490500_500000 METAL6_3478500_500000 0.024
R_VDD18_6215 METAL6_3478500_500000 METAL6_3478500_504000 0.008
R_VDD18_6216 METAL6_3478500_504000 METAL6_3478500_507000 0.006
R_VDD18_6217 METAL6_3478500_507000 METAL6_3477000_507000 0.003
R_VDD18_6218 METAL6_3477000_507000 METAL6_3466500_507000 0.021
R_VDD18_6219 METAL6_3466500_507000 METAL6_3465000_507000 0.003
R_VDD18_6220 METAL6_3465000_507000 METAL6_3453000_507000 0.024
R_VDD18_6221 METAL6_3453000_507000 METAL6_3336400_507000 0.2332
R_VDD18_6222 METAL6_3336400_507000 METAL6_3324400_507000 0.024
R_VDD18_6223 METAL6_3324400_507000 METAL6_3324400_507800 0.0016
R_VDD18_6224 METAL6_3324400_507800 METAL6_3324400_512000 0.0084
R_VDD18_6225 METAL6_3324400_512000 METAL6_3324400_516000 0.008
R_VDD18_6226 METAL6_3324400_516000 METAL6_3324400_528000 0.024
R_VDD18_6227 METAL6_3324400_528000 METAL6_3324400_535400 0.0148
R_VDD18_6228 METAL6_3324400_535400 METAL6_3324400_544200 0.0176
R_VDD18_6229 METAL6_3324400_544200 METAL6_3324400_547400 0.0064
R_VDD18_6230 METAL6_3324400_547400 METAL6_3324400_559400 0.024
R_VDD18_6231 METAL6_3324400_559400 METAL6_3324400_573000 0.0272
R_VDD18_6232 METAL6_3324400_573000 METAL6_3324400_579800 0.0136
R_VDD18_6233 METAL6_3324400_579800 METAL6_3324400_586400 0.0132
R_VDD18_6234 METAL6_3324400_586400 METAL6_3324400_588000 0.0032
R_VDD18_6235 METAL6_3324400_588000 METAL6_3324400_600000 0.024
R_VDD18_6236 METAL6_3324400_600000 METAL6_3324400_612000 0.024
R_VDD18_6237 METAL6_3324400_612000 METAL6_3324400_637800 0.0516
R_VDD18_6238 METAL6_3324400_637800 METAL6_3324400_641400 0.0072
R_VDD18_6239 METAL6_3324400_641400 METAL6_3324400_649800 0.0168
R_VDD18_6240 METAL6_3324400_649800 METAL6_3324400_653400 0.0072
R_VDD18_6241 METAL6_3324400_653400 METAL6_3324400_661800 0.0168
R_VDD18_6242 METAL6_3324400_661800 METAL6_3324400_665400 0.0072
R_VDD18_6243 METAL6_3324400_665400 METAL6_3324400_688000 0.0452
R_VDD18_6244 METAL6_3324400_688000 METAL6_3324400_700000 0.024
R_VDD18_6245 METAL6_3324400_700000 METAL6_3324400_702800 0.0056
R_VDD18_6246 METAL6_3324400_702800 METAL6_3324400_709800 0.014
R_VDD18_6247 METAL6_3324400_709800 METAL6_3324400_712000 0.0044
R_VDD18_6248 METAL6_3324400_712000 METAL6_3324400_716800 0.0096
R_VDD18_6249 METAL6_3324400_716800 METAL6_3324400_721800 0.01
R_VDD18_6250 METAL6_3324400_721800 METAL6_3324400_733800 0.024
R_VDD18_6251 METAL6_3324400_733800 METAL6_3324400_735400 0.0032
R_VDD18_6252 METAL6_3324400_735400 METAL6_3324400_758400 0.046
R_VDD18_6253 METAL6_3324400_758400 METAL6_3324400_763000 0.0092
R_VDD18_6254 METAL6_3324400_763000 METAL6_3324400_770400 0.0148
R_VDD18_6255 METAL6_3324400_770400 METAL6_3324400_772000 0.0032
R_VDD18_6256 METAL6_3324400_772000 METAL6_3324400_778400 0.0128
R_VDD18_6257 METAL6_3324400_778400 METAL6_3324400_779200 0.0016
R_VDD18_6258 METAL6_3324400_779200 METAL6_3324400_782400 0.0064
R_VDD18_6259 METAL6_3324400_782400 METAL6_3324400_784500 0.0042
R_VDD18_6260 METAL6_3324400_784500 METAL6_3324400_788000 0.007
R_VDD18_6261 METAL6_3324400_788000 METAL6_3324400_790400 0.0048
R_VDD18_6262 METAL6_3324400_790400 METAL6_3324400_791200 0.0016
R_VDD18_6263 METAL6_3324400_791200 METAL6_3324400_794400 0.0064
R_VDD18_6264 METAL6_3324400_794400 METAL6_3324400_794800 0.0008
R_VDD18_6265 METAL6_3324400_794800 METAL6_3324400_800000 0.0104
R_VDD18_6266 METAL6_3324400_800000 METAL6_3324400_802400 0.0048
R_VDD18_6267 METAL6_3324400_802400 METAL6_3324400_803200 0.0016
R_VDD18_6268 METAL6_3324400_803200 METAL6_3324400_806400 0.0064
R_VDD18_6269 METAL6_3324400_806400 METAL6_3324400_808000 0.0032
R_VDD18_6270 METAL6_3324400_808000 METAL6_3324400_812000 0.008
R_VDD18_6271 METAL6_3324400_812000 METAL6_3324400_814400 0.0048
R_VDD18_6272 METAL6_3324400_814400 METAL6_3324400_818400 0.008
R_VDD18_6273 METAL6_3324400_818400 METAL6_3324400_820000 0.0032
R_VDD18_6274 METAL6_3324400_820000 METAL6_3324400_830400 0.0208
R_VDD18_6275 METAL6_3324400_830400 METAL6_3324400_832000 0.0032
R_VDD18_6276 METAL6_3324400_832000 METAL6_3324400_839500 0.015
R_VDD18_6277 METAL6_3324400_839500 METAL6_3324400_840700 0.0024
R_VDD18_6278 METAL6_3324400_840700 METAL6_3324400_851500 0.0216
R_VDD18_6279 METAL6_3324400_851500 METAL6_3324400_858200 0.0134
R_VDD18_6280 METAL6_3324400_858200 METAL6_3324400_863500 0.0106
R_VDD18_6281 METAL6_3324400_863500 METAL6_3324400_887000 0.047
R_VDD18_6282 METAL6_3324400_887000 METAL6_3324400_888000 0.002
R_VDD18_6283 METAL6_3324400_888000 METAL6_3324400_900000 0.024
R_VDD18_6284 METAL6_3324400_900000 METAL6_3324400_900400 0.0008
R_VDD18_6285 METAL6_3324400_900400 METAL6_3324400_912000 0.0232
R_VDD18_6286 METAL6_3324400_912000 METAL6_3324400_927300 0.0306
R_VDD18_6287 METAL6_3324400_927300 METAL6_3324400_947000 0.0394
R_VDD18_6288 METAL6_3324400_947000 METAL6_3324400_959000 0.024
R_VDD18_6289 METAL6_3324400_959000 METAL6_3324400_971000 0.024
R_VDD18_6290 METAL6_3324400_971000 METAL6_3324400_976000 0.01
R_VDD18_6291 METAL6_3324400_976000 METAL6_3324400_988000 0.024
R_VDD18_6292 METAL6_3324400_988000 METAL6_3324400_995000 0.014
R_VDD18_6293 METAL6_3324400_995000 METAL6_3324400_1000000 0.01
R_VDD18_6294 METAL6_3324400_1000000 METAL6_3324400_1007000 0.014
R_VDD18_6295 METAL6_3324400_1007000 METAL6_3324400_1012000 0.01
R_VDD18_6296 METAL6_3324400_1012000 METAL6_3324400_1014000 0.004
R_VDD18_6297 METAL6_3324400_1014000 METAL6_3324400_1019000 0.01
R_VDD18_6298 METAL6_3324400_1019000 METAL6_3324400_1026000 0.014
R_VDD18_6299 METAL6_3324400_1026000 METAL6_3324400_1029800 0.0076
R_VDD18_6300 METAL6_3324400_1029800 METAL6_3324400_1031000 0.0024
R_VDD18_6301 METAL6_3324400_1031000 METAL6_3324400_1035700 0.0094
R_VDD18_6302 METAL6_3324400_1035700 METAL6_3324400_1037400 0.0034
R_VDD18_6303 METAL6_3324400_1037400 METAL6_3324400_1038000 0.0012
R_VDD18_6304 METAL6_3324400_1038000 METAL6_3324400_1041800 0.0076
R_VDD18_6305 METAL6_3312400_1041800 METAL6_3324400_1041800 0.024
R_VDD18_6306 METAL6_1246300_2713700 METAL6_1234300_2713700 0.024
R_VDD18_6307 METAL6_3324400_1041800 METAL6_3324400_1042700 0.0018
R_VDD18_6308 METAL6_3324400_1042700 METAL6_3324400_1049400 0.0134
R_VDD18_6309 METAL6_3324400_1049400 METAL6_3324400_1049800 0.0008
R_VDD18_6310 METAL6_3324400_1049800 METAL6_3324400_1053800 0.008
R_VDD18_6311 METAL6_3324400_1053800 METAL6_3324400_1054700 0.0018
R_VDD18_6312 METAL6_3324400_1054700 METAL6_3324400_1061400 0.0134
R_VDD18_6313 METAL6_3324400_1061400 METAL6_3324400_1061800 0.0008
R_VDD18_6314 METAL6_3324400_1061800 METAL6_3324400_1066700 0.0098
R_VDD18_6315 METAL6_3324400_1066700 METAL6_3324400_1073800 0.0142
R_VDD18_6316 METAL6_3324400_1073800 METAL6_3324400_1086000 0.0244
R_VDD18_6317 METAL6_3324400_1086000 METAL6_3324400_1086300 0.0006
R_VDD18_6318 METAL6_3324400_1086300 METAL6_3324400_1088000 0.0034
R_VDD18_6319 METAL6_3324400_1088000 METAL6_3324400_1098300 0.0206
R_VDD18_6320 METAL6_3324400_1098300 METAL6_3324400_1098500 0.0004
R_VDD18_6321 METAL6_3324400_1098500 METAL6_3324400_1100000 0.003
R_VDD18_6322 METAL6_3324400_1100000 METAL6_3324400_1108800 0.0176
R_VDD18_6323 METAL6_3324400_1108800 METAL6_3312400_1108800 0.024
R_VDD18_6324 METAL6_3312400_1108800 METAL6_3312400_1110300 0.003
R_VDD18_6325 METAL6_3312400_1110300 METAL6_3312400_1112000 0.0034
R_VDD18_6326 METAL6_3312400_1112000 METAL6_3312400_1122300 0.0206
R_VDD18_6327 METAL6_3312400_1122300 METAL6_3312400_1129300 0.014
R_VDD18_6328 METAL6_3312400_1129300 METAL6_3312400_1134300 0.01
R_VDD18_6329 METAL6_3312400_1134300 METAL6_3312400_1141300 0.014
R_VDD18_6330 METAL6_3312400_1141300 METAL6_3312400_1153300 0.024
R_VDD18_6331 METAL6_3312400_1153300 METAL6_3312400_1160600 0.0146
R_VDD18_6332 METAL6_3312400_1160600 METAL6_3312400_1172600 0.024
R_VDD18_6333 METAL6_3312400_1172600 METAL6_3312400_1184600 0.024
R_VDD18_6334 METAL6_3312400_1184600 METAL6_3312400_1191600 0.014
R_VDD18_6335 METAL6_3312400_1191600 METAL6_3312400_1193800 0.0044
R_VDD18_6336 METAL6_3312400_1193800 METAL6_3312400_1217700 0.0478
R_VDD18_6337 METAL6_3312400_1217700 METAL6_3312000_1217700 0.0008
R_VDD18_6338 METAL6_3312000_1217700 METAL6_3305400_1217700 0.0132
R_VDD18_6339 METAL6_3305400_1217700 METAL6_3300400_1217700 0.01
R_VDD18_6340 METAL6_3300400_1217700 METAL6_3300000_1217700 0.0008
R_VDD18_6341 METAL6_3300000_1217700 METAL6_3288000_1217700 0.024
R_VDD18_6342 METAL6_3288000_1217700 METAL6_3287000_1217700 0.002
R_VDD18_6343 METAL6_3287000_1217700 METAL6_3275000_1217700 0.024
R_VDD18_6344 METAL6_3275000_1217700 METAL6_3263000_1217700 0.024
R_VDD18_6345 METAL6_3263000_1217700 METAL6_3260400_1217700 0.0052
R_VDD18_6346 METAL6_3260400_1217700 METAL6_3243500_1217700 0.0338
R_VDD18_6347 METAL6_3243500_1217700 METAL6_3231500_1217700 0.024
R_VDD18_6348 METAL6_3231500_1217700 METAL6_3219500_1217700 0.024
R_VDD18_6349 METAL6_3219500_1217700 METAL6_3212500_1217700 0.014
R_VDD18_6350 METAL6_3212500_1217700 METAL6_3212000_1217700 0.001
R_VDD18_6351 METAL6_3212000_1217700 METAL6_3200000_1217700 0.024
R_VDD18_6352 METAL6_3200000_1217700 METAL6_3188000_1217700 0.024
R_VDD18_6353 METAL6_3188000_1217700 METAL6_3167500_1217700 0.041
R_VDD18_6354 METAL6_3167500_1217700 METAL6_3165900_1217700 0.0032
R_VDD18_6355 METAL6_3165900_1217700 METAL6_3112000_1217700 0.1078
R_VDD18_6356 METAL6_3112000_1217700 METAL6_3110900_1217700 0.0022
R_VDD18_6357 METAL6_3110900_1217700 METAL6_3100000_1217700 0.0218
R_VDD18_6358 METAL6_3100000_1217700 METAL6_3099200_1217700 0.0016
R_VDD18_6359 METAL6_3099200_1217700 METAL6_3098900_1217700 0.0006
R_VDD18_6360 METAL6_3098900_1217700 METAL6_3088000_1217700 0.0218
R_VDD18_6361 METAL6_3088000_1217700 METAL6_3087200_1217700 0.0016
R_VDD18_6362 METAL6_3087200_1217700 METAL6_3086900_1217700 0.0006
R_VDD18_6363 METAL6_3086900_1217700 METAL6_3075200_1217700 0.0234
R_VDD18_6364 METAL6_3075200_1217700 METAL6_3068200_1217700 0.014
R_VDD18_6365 METAL6_3068200_1217700 METAL6_3060600_1217700 0.0152
R_VDD18_6366 METAL6_3060600_1217700 METAL6_3023200_1217700 0.0748
R_VDD18_6367 METAL6_3023200_1217700 METAL6_3012000_1217700 0.0224
R_VDD18_6368 METAL6_3012000_1217700 METAL6_3006200_1217700 0.0116
R_VDD18_6369 METAL6_3006200_1217700 METAL6_3000000_1217700 0.0124
R_VDD18_6370 METAL6_3000000_1217700 METAL6_2994200_1217700 0.0116
R_VDD18_6371 METAL6_2994200_1217700 METAL6_2993000_1217700 0.0024
R_VDD18_6372 METAL6_2993000_1217700 METAL6_2988000_1217700 0.01
R_VDD18_6373 METAL6_2988000_1217700 METAL6_2982200_1217700 0.0116
R_VDD18_6374 METAL6_2982200_1217700 METAL6_2975200_1217700 0.014
R_VDD18_6375 METAL6_2975200_1217700 METAL6_2965900_1217700 0.0186
R_VDD18_6376 METAL6_2965900_1217700 METAL6_2951900_1217700 0.028
R_VDD18_6377 METAL6_2951900_1217700 METAL6_2930200_1217700 0.0434
R_VDD18_6378 METAL6_2930200_1217700 METAL6_2925600_1217700 0.0092
R_VDD18_6379 METAL6_2925600_1217700 METAL6_2913600_1217700 0.024
R_VDD18_6380 METAL6_2913600_1217700 METAL6_2910900_1217700 0.0054
R_VDD18_6381 METAL6_2910900_1217700 METAL6_2901600_1217700 0.0186
R_VDD18_6382 METAL6_2901600_1217700 METAL6_2898900_1217700 0.0054
R_VDD18_6383 METAL6_2898900_1217700 METAL6_2897100_1217700 0.0036
R_VDD18_6384 METAL6_2897100_1217700 METAL6_2886900_1217700 0.0204
R_VDD18_6385 METAL6_2886900_1217700 METAL6_2874800_1217700 0.0242
R_VDD18_6386 METAL6_2874800_1217700 METAL6_2862800_1217700 0.024
R_VDD18_6387 METAL6_2862800_1217700 METAL6_2860600_1217700 0.0044
R_VDD18_6388 METAL6_2860600_1217700 METAL6_2850800_1217700 0.0196
R_VDD18_6389 METAL6_2850800_1217700 METAL6_2846600_1217700 0.0084
R_VDD18_6390 METAL6_2846600_1217700 METAL6_2843800_1217700 0.0056
R_VDD18_6391 METAL6_2843800_1217700 METAL6_2812000_1217700 0.0636
R_VDD18_6392 METAL6_2812000_1217700 METAL6_2805600_1217700 0.0128
R_VDD18_6393 METAL6_2805600_1217700 METAL6_2800000_1217700 0.0112
R_VDD18_6394 METAL6_2800000_1217700 METAL6_2798800_1217700 0.0024
R_VDD18_6395 METAL6_2798800_1217700 METAL6_2793600_1217700 0.0104
R_VDD18_6396 METAL6_2793600_1217700 METAL6_2788000_1217700 0.0112
R_VDD18_6397 METAL6_2788000_1217700 METAL6_2781600_1217700 0.0128
R_VDD18_6398 METAL6_2781600_1217700 METAL6_2765900_1217700 0.0314
R_VDD18_6399 METAL6_2765900_1217700 METAL6_2751900_1217700 0.028
R_VDD18_6400 METAL6_2751900_1217700 METAL6_2728200_1217700 0.0474
R_VDD18_6401 METAL6_2728200_1217700 METAL6_2710900_1217700 0.0346
R_VDD18_6402 METAL6_2710900_1217700 METAL6_2698900_1217700 0.024
R_VDD18_6403 METAL6_2698900_1217700 METAL6_2686900_1217700 0.024
R_VDD18_6404 METAL6_2686900_1217700 METAL6_2683200_1217700 0.0074
R_VDD18_6405 METAL6_2683200_1217700 METAL6_2676200_1217700 0.014
R_VDD18_6406 METAL6_2676200_1217700 METAL6_2664200_1217700 0.024
R_VDD18_6407 METAL6_2664200_1217700 METAL6_2660600_1217700 0.0072
R_VDD18_6408 METAL6_2660600_1217700 METAL6_2652200_1217700 0.0168
R_VDD18_6409 METAL6_2652200_1217700 METAL6_2646600_1217700 0.0112
R_VDD18_6410 METAL6_2646600_1217700 METAL6_2580400_1217700 0.1324
R_VDD18_6411 METAL6_2580400_1217700 METAL6_2565900_1217700 0.029
R_VDD18_6412 METAL6_2565900_1217700 METAL6_2551900_1217700 0.028
R_VDD18_6413 METAL6_2551900_1217700 METAL6_2535400_1217700 0.033
R_VDD18_6414 METAL6_2535400_1217700 METAL6_2528400_1217700 0.014
R_VDD18_6415 METAL6_2528400_1217700 METAL6_2525600_1217700 0.0056
R_VDD18_6416 METAL6_2525600_1217700 METAL6_2516400_1217700 0.0184
R_VDD18_6417 METAL6_2516400_1217700 METAL6_2513600_1217700 0.0056
R_VDD18_6418 METAL6_2513600_1217700 METAL6_2512000_1217700 0.0032
R_VDD18_6419 METAL6_2512000_1217700 METAL6_2510900_1217700 0.0022
R_VDD18_6420 METAL6_2510900_1217700 METAL6_2505000_1217700 0.0118
R_VDD18_6421 METAL6_2505000_1217700 METAL6_2504400_1217700 0.0012
R_VDD18_6422 METAL6_2504400_1217700 METAL6_2501600_1217700 0.0056
R_VDD18_6423 METAL6_2501600_1217700 METAL6_2500000_1217700 0.0032
R_VDD18_6424 METAL6_2500000_1217700 METAL6_2498900_1217700 0.0022
R_VDD18_6425 METAL6_2498900_1217700 METAL6_2493000_1217700 0.0118
R_VDD18_6426 METAL6_2493000_1217700 METAL6_2493000_1238000 0.0406
R_VDD18_6427 METAL6_2493000_1238000 METAL6_2493000_1247700 0.0194
R_VDD18_6428 METAL6_2493000_1247700 METAL6_2488000_1247700 0.01
R_VDD18_6429 METAL6_2488000_1247700 METAL6_2486900_1247700 0.0022
R_VDD18_6430 METAL6_2486900_1247700 METAL6_2481000_1247700 0.0118
R_VDD18_6431 METAL6_2481000_1247700 METAL6_2476000_1247700 0.01
R_VDD18_6432 METAL6_2476000_1247700 METAL6_2472600_1247700 0.0068
R_VDD18_6433 METAL6_2472600_1247700 METAL6_2460600_1247700 0.024
R_VDD18_6434 METAL6_2460600_1247700 METAL6_2448600_1247700 0.024
R_VDD18_6435 METAL6_2448600_1247700 METAL6_2448600_1250000 0.0046
R_VDD18_6436 METAL6_2448600_1250000 METAL6_2448600_1259700 0.0194
R_VDD18_6437 METAL6_2448600_1259700 METAL6_2448600_1262000 0.0046
R_VDD18_6438 METAL6_2448600_1262000 METAL6_2448600_1271700 0.0194
R_VDD18_6439 METAL6_2448600_1271700 METAL6_2446600_1271700 0.004
R_VDD18_6440 METAL6_2446600_1271700 METAL6_2407100_1271700 0.079
R_VDD18_6441 METAL6_2407100_1271700 METAL6_2405600_1271700 0.003
R_VDD18_6442 METAL6_2405600_1271700 METAL6_2402100_1271700 0.007
R_VDD18_6443 METAL6_2402100_1271700 METAL6_2395100_1271700 0.014
R_VDD18_6444 METAL6_2395100_1271700 METAL6_2393600_1271700 0.003
R_VDD18_6445 METAL6_2393600_1271700 METAL6_2383100_1271700 0.021
R_VDD18_6446 METAL6_2383100_1271700 METAL6_2381600_1271700 0.003
R_VDD18_6447 METAL6_2381600_1271700 METAL6_2371100_1271700 0.021
R_VDD18_6448 METAL6_2371100_1271700 METAL6_2369600_1271700 0.003
R_VDD18_6449 METAL6_2369600_1271700 METAL6_2365900_1271700 0.0074
R_VDD18_6450 METAL6_2365900_1271700 METAL6_2357600_1271700 0.0166
R_VDD18_6451 METAL6_2357600_1271700 METAL6_2351900_1271700 0.0114
R_VDD18_6452 METAL6_2351900_1271700 METAL6_2343700_1271700 0.0164
R_VDD18_6453 METAL6_2343700_1271700 METAL6_2310900_1271700 0.0656
R_VDD18_6454 METAL6_2310900_1271700 METAL6_2298900_1271700 0.024
R_VDD18_6455 METAL6_2298900_1271700 METAL6_2286900_1271700 0.024
R_VDD18_6456 METAL6_2286900_1271700 METAL6_2272400_1271700 0.029
R_VDD18_6457 METAL6_2272400_1271700 METAL6_2260600_1271700 0.0236
R_VDD18_6458 METAL6_2260600_1271700 METAL6_2260600_1273000 0.0026
R_VDD18_6459 METAL6_2260600_1273000 METAL6_2260600_1326000 0.106
R_VDD18_6460 METAL6_2260600_1326000 METAL6_2260600_1338000 0.024
R_VDD18_6461 METAL6_2260600_1338000 METAL6_2260600_1350000 0.024
R_VDD18_6462 METAL6_2260600_1350000 METAL6_2260600_1362000 0.024
R_VDD18_6463 METAL6_2260600_1362000 METAL6_2260600_1369000 0.014
R_VDD18_6464 METAL6_2260600_1369000 METAL6_2260600_1374000 0.01
R_VDD18_6465 METAL6_2260600_1374000 METAL6_2260600_1381000 0.014
R_VDD18_6466 METAL6_2260600_1381000 METAL6_2260600_1386600 0.0112
R_VDD18_6467 METAL6_2260600_1386600 METAL6_2260600_1393000 0.0128
R_VDD18_6468 METAL6_2260600_1393000 METAL6_2260600_1405000 0.024
R_VDD18_6469 METAL6_2260600_1405000 METAL6_2260600_1437700 0.0654
R_VDD18_6470 METAL6_2260600_1437700 METAL6_2260600_1449700 0.024
R_VDD18_6471 METAL6_2260600_1449700 METAL6_2260600_1461700 0.024
R_VDD18_6472 METAL6_2260600_1461700 METAL6_2260600_1492300 0.0612
R_VDD18_6473 METAL6_2260600_1492300 METAL6_2260600_1504300 0.024
R_VDD18_6474 METAL6_2260600_1504300 METAL6_2260600_1516300 0.024
R_VDD18_6475 METAL6_2260600_1516300 METAL6_2260600_1528300 0.024
R_VDD18_6476 METAL6_2260600_1528300 METAL6_2260400_1528300 0.0004
R_VDD18_6477 METAL6_2260400_1528300 METAL6_2258600_1528300 0.0036
R_VDD18_6478 METAL6_2258600_1528300 METAL6_2248700_1528300 0.0198
R_VDD18_6479 METAL6_2248700_1528300 METAL6_2248400_1528300 0.0006
R_VDD18_6480 METAL6_2248400_1528300 METAL6_2246600_1528300 0.0036
R_VDD18_6481 METAL6_2246600_1528300 METAL6_2236700_1528300 0.0198
R_VDD18_6482 METAL6_2236700_1528300 METAL6_2234600_1528300 0.0042
R_VDD18_6483 METAL6_2234600_1528300 METAL5_2234600_1528300 0.1
R_VDD18_6484 METAL5_2234600_1528300 METAL5_2234600_1540300 0.048
R_VDD18_6485 METAL5_2234600_1540300 METAL5_2234600_1552300 0.048
R_VDD18_6486 METAL5_2234600_1552300 METAL5_2234600_1554500 0.0088
R_VDD18_6487 METAL5_2234600_1554500 METAL5_2234600_1564300 0.0392
R_VDD18_6488 METAL5_2234600_1564300 METAL6_2234600_1564300 0.1
R_VDD18_6489 METAL6_2234600_1564300 METAL6_2224700_1564300 0.0198
R_VDD18_6490 METAL6_2224700_1564300 METAL6_2224700_1571300 0.014
R_VDD18_6491 METAL6_2224700_1571300 METAL6_2224700_1576300 0.01
R_VDD18_6492 METAL6_2224700_1576300 METAL6_2224700_1714500 0.2764
R_VDD18_6493 METAL6_2224700_1714500 METAL6_2224700_1720500 0.012
R_VDD18_6494 METAL6_2224700_1720500 METAL6_2224700_1726500 0.012
R_VDD18_6495 METAL6_2224700_1726500 METAL6_2224700_1731700 0.0104
R_VDD18_6496 METAL6_2224700_1731700 METAL6_2224700_1738500 0.0136
R_VDD18_6497 METAL6_2224700_1738500 METAL6_2224700_1750500 0.024
R_VDD18_6498 METAL6_2224700_1750500 METAL6_2224700_1762500 0.024
R_VDD18_6499 METAL6_2224700_1762500 METAL6_2224700_1774500 0.024
R_VDD18_6500 METAL6_2224700_1774500 METAL6_2224700_1802500 0.056
R_VDD18_6501 METAL6_2224700_1802500 METAL6_2224700_1814500 0.024
R_VDD18_6502 METAL6_2224700_1814500 METAL6_2224700_1826500 0.024
R_VDD18_6503 METAL6_2224700_1826500 METAL6_2224700_1838500 0.024
R_VDD18_6504 METAL6_2224700_1838500 METAL6_2224700_1852300 0.0276
R_VDD18_6505 METAL6_2224700_1852300 METAL6_2224700_1866300 0.028
R_VDD18_6506 METAL6_2224700_1866300 METAL6_2224700_1914500 0.0964
R_VDD18_6507 METAL6_2224700_1914500 METAL6_2224700_1926500 0.024
R_VDD18_6508 METAL6_2224700_1926500 METAL6_2224700_1938500 0.024
R_VDD18_6509 METAL6_2224700_1938500 METAL6_2221900_1938500 0.0056
R_VDD18_6510 METAL6_2221900_1938500 METAL6_2212700_1938500 0.0184
R_VDD18_6511 METAL6_2212700_1938500 METAL6_2212700_1940500 0.004
R_VDD18_6512 METAL6_2212700_1940500 METAL6_2212700_1950500 0.02
R_VDD18_6513 METAL6_2212700_1950500 METAL6_2212700_1951000 0.001
R_VDD18_6514 METAL6_2212700_1951000 METAL6_2212700_1952500 0.003
R_VDD18_6515 METAL6_2212700_1952500 METAL6_2212700_1963000 0.021
R_VDD18_6516 METAL6_2212700_1963000 METAL6_2212700_1964500 0.003
R_VDD18_6517 METAL6_2212700_1964500 METAL6_2212700_1975000 0.021
R_VDD18_6518 METAL6_2212700_1975000 METAL6_2212700_1976500 0.003
R_VDD18_6519 METAL6_2212700_1976500 METAL6_2212700_1987000 0.021
R_VDD18_6520 METAL6_2212700_1987000 METAL6_2212700_2014500 0.055
R_VDD18_6521 METAL6_2212700_2014500 METAL6_2212700_2026500 0.024
R_VDD18_6522 METAL6_2212700_2026500 METAL6_2212700_2038500 0.024
R_VDD18_6523 METAL6_2212700_2038500 METAL6_2212700_2114500 0.152
R_VDD18_6524 METAL6_2212700_2114500 METAL6_2212700_2126500 0.024
R_VDD18_6525 METAL6_2212700_2126500 METAL6_2212700_2138500 0.024
R_VDD18_6526 METAL6_2212700_2138500 METAL6_2212700_2147300 0.0176
R_VDD18_6527 METAL6_2212700_2147300 METAL6_2212700_2154300 0.014
R_VDD18_6528 METAL6_2212700_2154300 METAL6_2212700_2163000 0.0174
R_VDD18_6529 METAL6_2212700_2163000 METAL6_2212700_2166300 0.0066
R_VDD18_6530 METAL6_2212700_2166300 METAL6_2212700_2175000 0.0174
R_VDD18_6531 METAL6_2212700_2175000 METAL6_2212700_2178300 0.0066
R_VDD18_6532 METAL6_2212700_2178300 METAL6_2212700_2187000 0.0174
R_VDD18_6533 METAL6_2212700_2187000 METAL6_2212700_2190300 0.0066
R_VDD18_6534 METAL6_2212700_2190300 METAL6_2212700_2222500 0.0644
R_VDD18_6535 METAL6_2212700_2222500 METAL6_2212700_2234500 0.024
R_VDD18_6536 METAL6_2212700_2234500 METAL6_2200700_2234500 0.024
R_VDD18_6537 METAL6_2200700_2234500 METAL6_2200700_2246500 0.024
R_VDD18_6538 METAL6_2200700_2246500 METAL6_2200700_2268500 0.044
R_VDD18_6539 METAL6_2200700_2268500 METAL6_2200700_2288000 0.039
R_VDD18_6540 METAL6_2200700_2288000 METAL6_2200700_2300000 0.024
R_VDD18_6541 METAL6_2200700_2300000 METAL6_2200700_2312000 0.024
R_VDD18_6542 METAL6_2200700_2312000 METAL6_2200700_2338000 0.052
R_VDD18_6543 METAL6_2200700_2338000 METAL6_2200700_2350000 0.024
R_VDD18_6544 METAL6_2200700_2350000 METAL6_2200700_2362000 0.024
R_VDD18_6545 METAL6_2200700_2362000 METAL6_2200700_2376000 0.028
R_VDD18_6546 METAL6_2200700_2376000 METAL6_2189900_2376000 0.0216
R_VDD18_6547 METAL6_2189900_2376000 METAL6_2188700_2376000 0.0024
R_VDD18_6548 METAL6_2188700_2376000 METAL6_2177900_2376000 0.0216
R_VDD18_6549 METAL6_2177900_2376000 METAL5_2177900_2376000 0.1
R_VDD18_6550 METAL5_2177900_2376000 METAL5_2176700_2376000 0.0048
R_VDD18_6551 METAL5_2176700_2376000 METAL5_2165900_2376000 0.0432
R_VDD18_6552 METAL5_2165900_2376000 METAL5_2165400_2376000 0.002
R_VDD18_6553 METAL5_2165400_2376000 METAL5_2153900_2376000 0.046
R_VDD18_6554 METAL5_2153900_2376000 METAL5_2153400_2376000 0.002
R_VDD18_6555 METAL5_2153400_2376000 METAL5_2151900_2376000 0.006
R_VDD18_6556 METAL5_2151900_2376000 METAL5_2141900_2376000 0.04
R_VDD18_6557 METAL5_2141900_2376000 METAL6_2141900_2376000 0.1
R_VDD18_6558 METAL6_2141900_2376000 METAL6_2141900_2377000 0.002
R_VDD18_6559 METAL6_2141900_2377000 METAL6_2141400_2377000 0.001
R_VDD18_6560 METAL6_2141400_2377000 METAL6_2129700_2377000 0.0234
R_VDD18_6561 METAL6_2129700_2377000 METAL6_2125600_2377000 0.0082
R_VDD18_6562 METAL6_2125600_2377000 METAL6_2121400_2377000 0.0084
R_VDD18_6563 METAL6_2121400_2377000 METAL6_2113600_2377000 0.0156
R_VDD18_6564 METAL6_2113600_2377000 METAL6_2101900_2377000 0.0234
R_VDD18_6565 METAL6_2101900_2377000 METAL6_2101600_2377000 0.0006
R_VDD18_6566 METAL6_2101600_2377000 METAL6_2089900_2377000 0.0234
R_VDD18_6567 METAL6_2089900_2377000 METAL6_2079700_2377000 0.0204
R_VDD18_6568 METAL6_2079700_2377000 METAL6_2077900_2377000 0.0036
R_VDD18_6569 METAL6_2077900_2377000 METAL6_2067700_2377000 0.0204
R_VDD18_6570 METAL6_2067700_2377000 METAL6_2060600_2377000 0.0142
R_VDD18_6571 METAL6_2060600_2377000 METAL6_2055700_2377000 0.0098
R_VDD18_6572 METAL6_2055700_2377000 METAL6_2046800_2377000 0.0178
R_VDD18_6573 METAL6_2046800_2377000 METAL6_2046600_2377000 0.0004
R_VDD18_6574 METAL6_2046600_2377000 METAL6_2046400_2377000 0.0004
R_VDD18_6575 METAL6_2046400_2377000 METAL6_2043700_2377000 0.0054
R_VDD18_6576 METAL6_2043700_2377000 METAL6_2031700_2377000 0.024
R_VDD18_6577 METAL6_2031700_2377000 METAL6_2030900_2377000 0.0016
R_VDD18_6578 METAL6_2030900_2377000 METAL6_2026400_2377000 0.009
R_VDD18_6579 METAL6_2026400_2377000 METAL6_2021200_2377000 0.0104
R_VDD18_6580 METAL6_2021200_2377000 METAL6_2019700_2377000 0.003
R_VDD18_6581 METAL6_2019700_2377000 METAL6_2018900_2377000 0.0016
R_VDD18_6582 METAL6_2018900_2377000 METAL6_2014400_2377000 0.009
R_VDD18_6583 METAL6_2014400_2377000 METAL6_2012000_2377000 0.0048
R_VDD18_6584 METAL6_2012000_2377000 METAL6_2006900_2377000 0.0102
R_VDD18_6585 METAL6_2006900_2377000 METAL6_2002400_2377000 0.009
R_VDD18_6586 METAL6_2002400_2377000 METAL6_2000000_2377000 0.0048
R_VDD18_6587 METAL6_2000000_2377000 METAL6_1988000_2377000 0.024
R_VDD18_6588 METAL6_1988000_2377000 METAL6_1951900_2377000 0.0722
R_VDD18_6589 METAL6_1951900_2377000 METAL6_1951800_2377000 0.0002
R_VDD18_6590 METAL6_1951800_2377000 METAL6_1939800_2377000 0.024
R_VDD18_6591 METAL6_1939800_2377000 METAL6_1927800_2377000 0.024
R_VDD18_6592 METAL6_1927800_2377000 METAL6_1926200_2377000 0.0032
R_VDD18_6593 METAL6_1926200_2377000 METAL6_1925600_2377000 0.0012
R_VDD18_6594 METAL6_1925600_2377000 METAL6_1919200_2377000 0.0128
R_VDD18_6595 METAL6_1919200_2377000 METAL6_1913600_2377000 0.0112
R_VDD18_6596 METAL6_1913600_2377000 METAL6_1907400_2377000 0.0124
R_VDD18_6597 METAL6_1907400_2377000 METAL6_1907200_2377000 0.0004
R_VDD18_6598 METAL6_1907200_2377000 METAL6_1901600_2377000 0.0112
R_VDD18_6599 METAL6_1901600_2377000 METAL6_1900700_2377000 0.0018
R_VDD18_6600 METAL6_1900700_2377000 METAL6_1895200_2377000 0.011
R_VDD18_6601 METAL6_1895200_2377000 METAL6_1888700_2377000 0.013
R_VDD18_6602 METAL6_1888700_2377000 METAL6_1877400_2377000 0.0226
R_VDD18_6603 METAL6_1877400_2377000 METAL6_1876700_2377000 0.0014
R_VDD18_6604 METAL6_1876700_2377000 METAL6_1874700_2377000 0.004
R_VDD18_6605 METAL6_1874700_2377000 METAL6_1870600_2377000 0.0082
R_VDD18_6606 METAL6_1870600_2377000 METAL6_1865400_2377000 0.0104
R_VDD18_6607 METAL6_1865400_2377000 METAL6_1864700_2377000 0.0014
R_VDD18_6608 METAL6_1864700_2377000 METAL6_1858600_2377000 0.0122
R_VDD18_6609 METAL6_1858600_2377000 METAL6_1858400_2377000 0.0004
R_VDD18_6610 METAL6_1858400_2377000 METAL6_1853400_2377000 0.01
R_VDD18_6611 METAL6_1853400_2377000 METAL6_1852700_2377000 0.0014
R_VDD18_6612 METAL6_1852700_2377000 METAL6_1846800_2377000 0.0118
R_VDD18_6613 METAL6_1846800_2377000 METAL6_1846600_2377000 0.0004
R_VDD18_6614 METAL6_1846600_2377000 METAL6_1846400_2377000 0.0004
R_VDD18_6615 METAL6_1846400_2377000 METAL6_1844800_2377000 0.0032
R_VDD18_6616 METAL6_1844800_2377000 METAL6_1834600_2377000 0.0204
R_VDD18_6617 METAL6_1834600_2377000 METAL6_1834400_2377000 0.0004
R_VDD18_6618 METAL6_1834400_2377000 METAL6_1832800_2377000 0.0032
R_VDD18_6619 METAL6_1832800_2377000 METAL6_1822600_2377000 0.0204
R_VDD18_6620 METAL6_1822600_2377000 METAL6_1820800_2377000 0.0036
R_VDD18_6621 METAL6_1820800_2377000 METAL6_1812000_2377000 0.0176
R_VDD18_6622 METAL6_1812000_2377000 METAL6_1800000_2377000 0.024
R_VDD18_6623 METAL6_1800000_2377000 METAL6_1788000_2377000 0.024
R_VDD18_6624 METAL6_1788000_2377000 METAL6_1755700_2377000 0.0646
R_VDD18_6625 METAL6_1755700_2377000 METAL6_1751800_2377000 0.0078
R_VDD18_6626 METAL6_1751800_2377000 METAL6_1751400_2377000 0.0008
R_VDD18_6627 METAL6_1751400_2377000 METAL6_1744000_2377000 0.0148
R_VDD18_6628 METAL6_1744000_2377000 METAL6_1743700_2377000 0.0006
R_VDD18_6629 METAL6_1743700_2377000 METAL6_1741800_2377000 0.0038
R_VDD18_6630 METAL6_1741800_2377000 METAL6_1739800_2377000 0.004
R_VDD18_6631 METAL6_1739800_2377000 METAL6_1731700_2377000 0.0162
R_VDD18_6632 METAL6_1731700_2377000 METAL6_1729800_2377000 0.0038
R_VDD18_6633 METAL6_1729800_2377000 METAL6_1727800_2377000 0.004
R_VDD18_6634 METAL6_1727800_2377000 METAL6_1719700_2377000 0.0162
R_VDD18_6635 METAL6_1719700_2377000 METAL6_1717800_2377000 0.0038
R_VDD18_6636 METAL6_1717800_2377000 METAL6_1710800_2377000 0.014
R_VDD18_6637 METAL6_1710800_2377000 METAL6_1707700_2377000 0.0062
R_VDD18_6638 METAL6_1707700_2377000 METAL6_1699000_2377000 0.0174
R_VDD18_6639 METAL6_1699000_2377000 METAL6_1692000_2377000 0.014
R_VDD18_6640 METAL6_1692000_2377000 METAL6_1680000_2377000 0.024
R_VDD18_6641 METAL6_1680000_2377000 METAL6_1670800_2377000 0.0184
R_VDD18_6642 METAL6_1670800_2377000 METAL6_1668000_2377000 0.0056
R_VDD18_6643 METAL6_1668000_2377000 METAL6_1658800_2377000 0.0184
R_VDD18_6644 METAL6_1658800_2377000 METAL6_1646800_2377000 0.024
R_VDD18_6645 METAL6_1646800_2377000 METAL6_1634800_2377000 0.024
R_VDD18_6646 METAL6_1634800_2377000 METAL6_1632800_2377000 0.004
R_VDD18_6647 METAL6_1632800_2377000 METAL6_1615800_2377000 0.034
R_VDD18_6648 METAL6_1615800_2377000 METAL5_1615800_2377000 0.1
R_VDD18_6649 METAL5_1615800_2377000 METAL5_1615800_2388000 0.044
R_VDD18_6650 METAL5_1615800_2388000 METAL5_1615800_2389000 0.004
R_VDD18_6651 METAL5_1615800_2389000 METAL5_1615800_2400000 0.044
R_VDD18_6652 METAL5_1615800_2400000 METAL5_1615800_2401000 0.004
R_VDD18_6653 METAL5_1615800_2401000 METAL6_1615800_2401000 0.1
R_VDD18_6654 METAL6_1615800_2401000 METAL6_1615800_2407000 0.012
R_VDD18_6655 METAL6_1615800_2407000 METAL6_1615800_2412000 0.01
R_VDD18_6656 METAL6_1615800_2412000 METAL6_1615800_2438000 0.052
R_VDD18_6657 METAL6_1615800_2438000 METAL6_1615800_2444000 0.012
R_VDD18_6658 METAL6_1615800_2444000 METAL6_1615800_2450000 0.012
R_VDD18_6659 METAL6_1615800_2450000 METAL6_1615800_2456000 0.012
R_VDD18_6660 METAL6_1615800_2456000 METAL6_1615800_2462000 0.012
R_VDD18_6661 METAL6_1615800_2462000 METAL6_1615800_2468000 0.012
R_VDD18_6662 METAL6_1615800_2468000 METAL6_1615800_2481000 0.026
R_VDD18_6663 METAL6_1615800_2481000 METAL6_1615800_2493000 0.024
R_VDD18_6664 METAL6_1615800_2493000 METAL6_1615800_2505000 0.024
R_VDD18_6665 METAL6_1615800_2505000 METAL6_1615800_2512000 0.014
R_VDD18_6666 METAL6_1615800_2512000 METAL6_1615800_2524000 0.024
R_VDD18_6667 METAL6_1615800_2524000 METAL6_1615800_2536000 0.024
R_VDD18_6668 METAL6_1615800_2536000 METAL6_1615800_2541700 0.0114
R_VDD18_6669 METAL6_1615800_2541700 METAL6_1612700_2541700 0.0062
R_VDD18_6670 METAL6_1612700_2541700 METAL6_1612000_2541700 0.0014
R_VDD18_6671 METAL6_1612000_2541700 METAL6_1607900_2541700 0.0082
R_VDD18_6672 METAL6_1607900_2541700 METAL6_1600700_2541700 0.0144
R_VDD18_6673 METAL6_1600700_2541700 METAL6_1600000_2541700 0.0014
R_VDD18_6674 METAL6_1600000_2541700 METAL6_1588700_2541700 0.0226
R_VDD18_6675 METAL6_1588700_2541700 METAL6_1588000_2541700 0.0014
R_VDD18_6676 METAL6_1588000_2541700 METAL6_1576700_2541700 0.0226
R_VDD18_6677 METAL6_1576700_2541700 METAL6_1576000_2541700 0.0014
R_VDD18_6678 METAL6_1576000_2541700 METAL6_1574700_2541700 0.0026
R_VDD18_6679 METAL6_1574700_2541700 METAL6_1557000_2541700 0.0354
R_VDD18_6680 METAL6_1557000_2541700 METAL6_1555400_2541700 0.0032
R_VDD18_6681 METAL6_1555400_2541700 METAL6_1551800_2541700 0.0072
R_VDD18_6682 METAL6_1551800_2541700 METAL6_1539800_2541700 0.024
R_VDD18_6683 METAL6_1539800_2541700 METAL6_1527800_2541700 0.024
R_VDD18_6684 METAL6_1527800_2541700 METAL6_1512000_2541700 0.0316
R_VDD18_6685 METAL6_1512000_2541700 METAL6_1510400_2541700 0.0032
R_VDD18_6686 METAL6_1510400_2541700 METAL6_1503400_2541700 0.014
R_VDD18_6687 METAL6_1503400_2541700 METAL6_1500000_2541700 0.0068
R_VDD18_6688 METAL6_1500000_2541700 METAL6_1498300_2541700 0.0034
R_VDD18_6689 METAL6_1498300_2541700 METAL6_1491400_2541700 0.0138
R_VDD18_6690 METAL6_1491400_2541700 METAL6_1488000_2541700 0.0068
R_VDD18_6691 METAL6_1488000_2541700 METAL6_1479400_2541700 0.0172
R_VDD18_6692 METAL6_1479400_2541700 METAL6_1443700_2541700 0.0714
R_VDD18_6693 METAL6_1443700_2541700 METAL6_1432800_2541700 0.0218
R_VDD18_6694 METAL6_1432800_2541700 METAL6_1431700_2541700 0.0022
R_VDD18_6695 METAL6_1431700_2541700 METAL6_1424000_2541700 0.0154
R_VDD18_6696 METAL6_1424000_2541700 METAL6_1419700_2541700 0.0086
R_VDD18_6697 METAL6_1419700_2541700 METAL6_1412000_2541700 0.0154
R_VDD18_6698 METAL6_1412000_2541700 METAL6_1400000_2541700 0.024
R_VDD18_6699 METAL6_1400000_2541700 METAL6_1388000_2541700 0.024
R_VDD18_6700 METAL6_1388000_2541700 METAL6_1337000_2541700 0.102
R_VDD18_6701 METAL6_1337000_2541700 METAL6_1325000_2541700 0.024
R_VDD18_6702 METAL6_1325000_2541700 METAL6_1324000_2541700 0.002
R_VDD18_6703 METAL6_1324000_2541700 METAL6_1323800_2541700 0.0004
R_VDD18_6704 METAL6_1323800_2541700 METAL6_1313000_2541700 0.0216
R_VDD18_6705 METAL6_1313000_2541700 METAL6_1312000_2541700 0.002
R_VDD18_6706 METAL6_1312000_2541700 METAL6_1311800_2541700 0.0004
R_VDD18_6707 METAL6_1311800_2541700 METAL6_1301000_2541700 0.0216
R_VDD18_6708 METAL6_1301000_2541700 METAL6_1300000_2541700 0.002
R_VDD18_6709 METAL6_1300000_2541700 METAL6_1299800_2541700 0.0004
R_VDD18_6710 METAL6_1299800_2541700 METAL6_1288000_2541700 0.0236
R_VDD18_6711 METAL6_1288000_2541700 METAL6_1274700_2541700 0.0266
R_VDD18_6712 METAL6_1274700_2541700 METAL6_1266800_2541700 0.0158
R_VDD18_6713 METAL6_1266800_2541700 METAL6_1259800_2541700 0.014
R_VDD18_6714 METAL6_1259800_2541700 METAL6_1258300_2541700 0.003
R_VDD18_6715 METAL6_1258300_2541700 METAL6_1253300_2541700 0.01
R_VDD18_6716 METAL6_1253300_2541700 METAL6_1247800_2541700 0.011
R_VDD18_6717 METAL6_1247800_2541700 METAL6_1246300_2541700 0.003
R_VDD18_6718 METAL6_1246300_2541700 METAL6_1235800_2541700 0.021
R_VDD18_6719 METAL6_1235800_2541700 METAL6_1234300_2541700 0.003
R_VDD18_6720 METAL6_1234300_2541700 METAL6_1234300_2548000 0.0126
R_VDD18_6721 METAL6_1234300_2548000 METAL6_1234300_2589000 0.082
R_VDD18_6722 METAL6_1234300_2589000 METAL6_1234300_2603000 0.028
R_VDD18_6723 METAL6_1234300_2603000 METAL6_1234300_2644000 0.082
R_VDD18_6724 METAL6_1234300_2644000 METAL6_1234300_2656000 0.024
R_VDD18_6725 METAL6_1234300_2656000 METAL6_1234300_2665700 0.0194
R_VDD18_6726 METAL6_1234300_2665700 METAL6_1234300_2668000 0.0046
R_VDD18_6727 METAL6_1234300_2668000 METAL6_1234300_2701700 0.0674
R_VDD18_6728 METAL6_1234300_2701700 METAL6_1234300_2713000 0.0226
R_VDD18_6729 METAL6_1234300_2713000 METAL6_1234300_2713700 0.0014
I_VDD18_24 METAL6_3312400_1041800 gnd 0.001
I_VDD18_25 METAL6_1246300_2713700 gnd 0.0022

V_VDD19_11 METAL5_3500000_600000 gnd 1
R_VDD19_6730 METAL5_3500000_600000 METAL5_3490500_600000 0.038
R_VDD19_6731 METAL5_3490500_600000 METAL6_3490500_600000 0.1
R_VDD19_6732 METAL6_3490500_600000 METAL6_3478500_600000 0.024
R_VDD19_6733 METAL6_3478500_600000 METAL6_3478500_598400 0.0032
R_VDD19_6734 METAL6_3478500_598400 METAL6_3477000_598400 0.003
R_VDD19_6735 METAL6_3477000_598400 METAL6_3466500_598400 0.021
R_VDD19_6736 METAL6_3466500_598400 METAL6_3465000_598400 0.003
R_VDD19_6737 METAL6_3465000_598400 METAL6_3454500_598400 0.021
R_VDD19_6738 METAL6_3454500_598400 METAL6_3453000_598400 0.003
R_VDD19_6739 METAL6_3453000_598400 METAL6_3442500_598400 0.021
R_VDD19_6740 METAL6_3442500_598400 METAL6_3372400_598400 0.1402
R_VDD19_6741 METAL6_3372400_598400 METAL6_3360400_598400 0.024
R_VDD19_6742 METAL6_3360400_598400 METAL6_3348400_598400 0.024
R_VDD19_6743 METAL6_3348400_598400 METAL6_3336400_598400 0.024
R_VDD19_6744 METAL6_3336400_598400 METAL5_3336400_598400 0.1
R_VDD19_6745 METAL5_3336400_598400 METAL5_3324400_598400 0.048
R_VDD19_6746 METAL5_3324400_598400 METAL5_3312400_598400 0.048
R_VDD19_6747 METAL5_3312400_598400 METAL6_3312400_598400 0.1
R_VDD19_6748 METAL6_3312400_598400 METAL6_3312400_597000 0.0028
R_VDD19_6749 METAL6_3312400_597000 METAL6_3312400_588000 0.018
R_VDD19_6750 METAL6_3312400_588000 METAL6_3312400_586400 0.0032
R_VDD19_6751 METAL6_3312400_586400 METAL6_3312400_585000 0.0028
R_VDD19_6752 METAL6_3312400_585000 METAL6_3312400_579800 0.0104
R_VDD19_6753 METAL6_3312400_579800 METAL6_3312400_574400 0.0108
R_VDD19_6754 METAL6_3312400_574400 METAL6_3312400_573000 0.0028
R_VDD19_6755 METAL6_3312400_573000 METAL6_3312400_571400 0.0032
R_VDD19_6756 METAL6_3312400_571400 METAL6_3312400_568200 0.0064
R_VDD19_6757 METAL6_3312400_568200 METAL6_3312400_562400 0.0116
R_VDD19_6758 METAL6_3312400_562400 METAL6_3312400_561000 0.0028
R_VDD19_6759 METAL6_3312400_561000 METAL6_3312400_559400 0.0032
R_VDD19_6760 METAL6_3312400_559400 METAL6_3312400_556200 0.0064
R_VDD19_6761 METAL6_3312400_556200 METAL6_3312400_550400 0.0116
R_VDD19_6762 METAL6_3312400_550400 METAL6_3312400_547400 0.006
R_VDD19_6763 METAL6_3312400_547400 METAL6_3312400_544200 0.0064
R_VDD19_6764 METAL6_3312400_544200 METAL6_3312400_538400 0.0116
R_VDD19_6765 METAL6_3312400_538400 METAL6_3312400_535400 0.006
R_VDD19_6766 METAL6_3312400_535400 METAL6_3312400_532200 0.0064
R_VDD19_6767 METAL6_3312400_532200 METAL6_3312400_528000 0.0084
R_VDD19_6768 METAL6_3312400_528000 METAL6_3312400_520200 0.0156
R_VDD19_6769 METAL6_3312400_520200 METAL6_3312400_519000 0.0024
R_VDD19_6770 METAL6_3312400_519000 METAL6_3312400_516000 0.006
R_VDD19_6771 METAL6_3312400_516000 METAL6_3312400_512000 0.008
R_VDD19_6772 METAL6_3312400_512000 METAL6_3312400_507800 0.0084
R_VDD19_6773 METAL6_3312400_507800 METAL6_3312400_507000 0.0016
R_VDD19_6774 METAL6_3312400_507000 METAL6_3312400_504400 0.0052
R_VDD19_6775 METAL6_3312400_504400 METAL6_3312000_504400 0.0008
R_VDD19_6776 METAL6_3312000_504400 METAL6_3305400_504400 0.0132
R_VDD19_6777 METAL6_3305400_504400 METAL6_3300400_504400 0.01
R_VDD19_6778 METAL6_3300400_504400 METAL6_3300400_504000 0.0008
R_VDD19_6779 METAL6_3300400_504000 METAL6_3300400_500000 0.008
R_VDD19_6780 METAL6_3300400_500000 METAL6_3300400_495000 0.01
R_VDD19_6781 METAL6_3300400_495000 METAL6_3300400_492400 0.0052
R_VDD19_6782 METAL6_3300400_492400 METAL6_3300400_488000 0.0088
R_VDD19_6783 METAL6_3300400_488000 METAL6_3300400_483000 0.01
R_VDD19_6784 METAL6_3300400_483000 METAL6_3300400_480400 0.0052
R_VDD19_6785 METAL6_3300400_480400 METAL6_3300400_477000 0.0068
R_VDD19_6786 METAL6_3300400_477000 METAL6_3300400_473000 0.008
R_VDD19_6787 METAL6_3300400_473000 METAL6_3300400_471000 0.004
R_VDD19_6788 METAL6_3300400_471000 METAL6_3300400_468400 0.0052
R_VDD19_6789 METAL6_3300400_468400 METAL6_3300400_465000 0.0068
R_VDD19_6790 METAL6_3300400_465000 METAL6_3300400_461000 0.008
R_VDD19_6791 METAL6_3300400_461000 METAL6_3300400_459000 0.004
R_VDD19_6792 METAL6_3300400_459000 METAL6_3300400_456400 0.0052
R_VDD19_6793 METAL6_3300400_456400 METAL6_3300400_453000 0.0068
R_VDD19_6794 METAL6_3300400_453000 METAL6_3300400_449000 0.008
R_VDD19_6795 METAL6_3300400_449000 METAL6_3300400_447000 0.004
R_VDD19_6796 METAL6_3300400_447000 METAL6_3300400_444400 0.0052
R_VDD19_6797 METAL6_3300400_444400 METAL6_3300400_437000 0.0148
R_VDD19_6798 METAL6_3300400_437000 METAL6_3300400_426800 0.0204
R_VDD19_6799 METAL6_3300400_426800 METAL6_3300000_426800 0.0008
R_VDD19_6800 METAL6_3300000_426800 METAL6_3299000_426800 0.002
R_VDD19_6801 METAL6_3299000_426800 METAL6_3288400_426800 0.0212
R_VDD19_6802 METAL6_3288400_426800 METAL6_3288000_426800 0.0008
R_VDD19_6803 METAL6_3288000_426800 METAL6_3287000_426800 0.002
R_VDD19_6804 METAL6_3287000_426800 METAL6_3276400_426800 0.0212
R_VDD19_6805 METAL6_3276400_426800 METAL6_3275000_426800 0.0028
R_VDD19_6806 METAL6_3275000_426800 METAL6_3263000_426800 0.024
R_VDD19_6807 METAL6_3263000_426800 METAL6_3260400_426800 0.0052
R_VDD19_6808 METAL6_3260400_426800 METAL6_3243500_426800 0.0338
R_VDD19_6809 METAL6_3243500_426800 METAL5_3243500_426800 0.1
R_VDD19_6810 METAL5_3243500_426800 METAL5_3243500_425000 0.0072
R_VDD19_6811 METAL5_3243500_425000 METAL5_3243500_424000 0.004
R_VDD19_6812 METAL5_3243500_424000 METAL5_3243500_414800 0.0368
R_VDD19_6813 METAL5_3243500_414800 METAL5_3243500_413000 0.0072
R_VDD19_6814 METAL5_3243500_413000 METAL5_3243500_412000 0.004
R_VDD19_6815 METAL5_3243500_412000 METAL5_3243500_402800 0.0368
R_VDD19_6816 METAL5_3243500_402800 METAL5_3243500_401000 0.0072
R_VDD19_6817 METAL5_3243500_401000 METAL5_3243500_400000 0.004
R_VDD19_6818 METAL5_3243500_400000 METAL5_3243500_390800 0.0368
R_VDD19_6819 METAL5_3243500_390800 METAL5_3231500_390800 0.048
R_VDD19_6820 METAL5_3231500_390800 METAL5_3224500_390800 0.028
R_VDD19_6821 METAL5_3224500_390800 METAL5_3219500_390800 0.02
R_VDD19_6822 METAL5_3219500_390800 METAL5_3212500_390800 0.028
R_VDD19_6823 METAL5_3212500_390800 METAL5_3212000_390800 0.002
R_VDD19_6824 METAL5_3212000_390800 METAL5_3207500_390800 0.018
R_VDD19_6825 METAL5_3207500_390800 METAL5_3200500_390800 0.028
R_VDD19_6826 METAL5_3200500_390800 METAL5_3200000_390800 0.002
R_VDD19_6827 METAL5_3200000_390800 METAL5_3188000_390800 0.048
R_VDD19_6828 METAL5_3188000_390800 METAL5_3179500_390800 0.034
R_VDD19_6829 METAL5_3179500_390800 METAL5_3167500_390800 0.048
R_VDD19_6830 METAL5_3167500_390800 METAL5_3165900_390800 0.0064
R_VDD19_6831 METAL5_3165900_390800 METAL5_3155500_390800 0.0416
R_VDD19_6832 METAL5_3155500_390800 METAL5_3124000_390800 0.126
R_VDD19_6833 METAL5_3124000_390800 METAL5_3123200_390800 0.0032
R_VDD19_6834 METAL5_3123200_390800 METAL5_3112000_390800 0.0448
R_VDD19_6835 METAL5_3112000_390800 METAL5_3111200_390800 0.0032
R_VDD19_6836 METAL5_3111200_390800 METAL5_3110900_390800 0.0012
R_VDD19_6837 METAL5_3110900_390800 METAL5_3100000_390800 0.0436
R_VDD19_6838 METAL5_3100000_390800 METAL5_3099200_390800 0.0032
R_VDD19_6839 METAL5_3099200_390800 METAL5_3098900_390800 0.0012
R_VDD19_6840 METAL5_3098900_390800 METAL5_3088000_390800 0.0436
R_VDD19_6841 METAL5_3088000_390800 METAL6_3088000_390800 0.1
R_VDD19_6842 METAL6_3088000_390800 METAL6_3087200_390800 0.0016
R_VDD19_6843 METAL6_3087200_390800 METAL6_3086900_390800 0.0006
R_VDD19_6844 METAL6_3086900_390800 METAL6_3076000_390800 0.0218
R_VDD19_6845 METAL6_3076000_390800 METAL6_3076000_400000 0.0184
R_VDD19_6846 METAL6_3076000_400000 METAL6_3076000_401000 0.002
R_VDD19_6847 METAL6_3076000_401000 METAL6_3075200_401000 0.0016
R_VDD19_6848 METAL6_3075200_401000 METAL6_3072600_401000 0.0052
R_VDD19_6849 METAL6_3072600_401000 METAL6_3068200_401000 0.0088
R_VDD19_6850 METAL6_3068200_401000 METAL6_3064000_401000 0.0084
R_VDD19_6851 METAL6_3064000_401000 METAL6_3064000_402800 0.0036
R_VDD19_6852 METAL6_3064000_402800 METAL6_3064000_412000 0.0184
R_VDD19_6853 METAL6_3064000_412000 METAL6_3064000_413000 0.002
R_VDD19_6854 METAL6_3064000_413000 METAL6_3064000_414800 0.0036
R_VDD19_6855 METAL6_3064000_414800 METAL6_3064000_424000 0.0184
R_VDD19_6856 METAL6_3064000_424000 METAL6_3064000_425000 0.002
R_VDD19_6857 METAL6_3064000_425000 METAL6_3064000_426800 0.0036
R_VDD19_6858 METAL6_3064000_426800 METAL6_3064000_437000 0.0204
R_VDD19_6859 METAL6_3064000_437000 METAL6_3063200_437000 0.0016
R_VDD19_6860 METAL6_3063200_437000 METAL6_3060600_437000 0.0052
R_VDD19_6861 METAL6_3060600_437000 METAL6_3052000_437000 0.0172
R_VDD19_6862 METAL6_3052000_437000 METAL6_3048600_437000 0.0068
R_VDD19_6863 METAL6_3048600_437000 METAL6_3035200_437000 0.0268
R_VDD19_6864 METAL6_3035200_437000 METAL6_3024000_437000 0.0224
R_VDD19_6865 METAL6_3024000_437000 METAL6_3023200_437000 0.0016
R_VDD19_6866 METAL6_3023200_437000 METAL6_3018200_437000 0.01
R_VDD19_6867 METAL6_3018200_437000 METAL6_3012000_437000 0.0124
R_VDD19_6868 METAL6_3012000_437000 METAL6_3011200_437000 0.0016
R_VDD19_6869 METAL6_3011200_437000 METAL6_3006200_437000 0.01
R_VDD19_6870 METAL6_3006200_437000 METAL6_3000000_437000 0.0124
R_VDD19_6871 METAL6_3000000_437000 METAL6_2994200_437000 0.0116
R_VDD19_6872 METAL6_2994200_437000 METAL6_2993000_437000 0.0024
R_VDD19_6873 METAL6_2993000_437000 METAL6_2988000_437000 0.01
R_VDD19_6874 METAL6_2988000_437000 METAL6_2987200_437000 0.0016
R_VDD19_6875 METAL6_2987200_437000 METAL6_2982200_437000 0.01
R_VDD19_6876 METAL6_2982200_437000 METAL6_2976000_437000 0.0124
R_VDD19_6877 METAL6_2976000_437000 METAL6_2975200_437000 0.0016
R_VDD19_6878 METAL6_2975200_437000 METAL6_2970200_437000 0.01
R_VDD19_6879 METAL6_2970200_437000 METAL6_2965900_437000 0.0086
R_VDD19_6880 METAL6_2965900_437000 METAL6_2963200_437000 0.0054
R_VDD19_6881 METAL6_2963200_437000 METAL6_2958200_437000 0.01
R_VDD19_6882 METAL6_2958200_437000 METAL6_2951900_437000 0.0126
R_VDD19_6883 METAL6_2951900_437000 METAL6_2942200_437000 0.0194
R_VDD19_6884 METAL6_2942200_437000 METAL6_2930200_437000 0.024
R_VDD19_6885 METAL6_2930200_437000 METAL6_2925600_437000 0.0092
R_VDD19_6886 METAL6_2925600_437000 METAL6_2918200_437000 0.0148
R_VDD19_6887 METAL6_2918200_437000 METAL6_2913600_437000 0.0092
R_VDD19_6888 METAL6_2913600_437000 METAL6_2910900_437000 0.0054
R_VDD19_6889 METAL6_2910900_437000 METAL6_2901600_437000 0.0186
R_VDD19_6890 METAL6_2901600_437000 METAL6_2898900_437000 0.0054
R_VDD19_6891 METAL6_2898900_437000 METAL6_2897100_437000 0.0036
R_VDD19_6892 METAL6_2897100_437000 METAL6_2886900_437000 0.0204
R_VDD19_6893 METAL6_2886900_437000 METAL6_2886800_437000 0.0002
R_VDD19_6894 METAL6_2886800_437000 METAL6_2874900_437000 0.0238
R_VDD19_6895 METAL6_2874900_437000 METAL6_2874800_437000 0.0002
R_VDD19_6896 METAL6_2874800_437000 METAL6_2862800_437000 0.024
R_VDD19_6897 METAL6_2862800_437000 METAL6_2860600_437000 0.0044
R_VDD19_6898 METAL6_2860600_437000 METAL6_2850800_437000 0.0196
R_VDD19_6899 METAL6_2850800_437000 METAL6_2846600_437000 0.0084
R_VDD19_6900 METAL6_2846600_437000 METAL6_2843800_437000 0.0056
R_VDD19_6901 METAL6_2843800_437000 METAL6_2824000_437000 0.0396
R_VDD19_6902 METAL6_2824000_437000 METAL6_2817600_437000 0.0128
R_VDD19_6903 METAL6_2817600_437000 METAL6_2812000_437000 0.0112
R_VDD19_6904 METAL6_2812000_437000 METAL6_2810800_437000 0.0024
R_VDD19_6905 METAL6_2810800_437000 METAL6_2805600_437000 0.0104
R_VDD19_6906 METAL6_2805600_437000 METAL6_2800000_437000 0.0112
R_VDD19_6907 METAL6_2800000_437000 METAL6_2798800_437000 0.0024
R_VDD19_6908 METAL6_2798800_437000 METAL6_2793600_437000 0.0104
R_VDD19_6909 METAL6_2793600_437000 METAL6_2788000_437000 0.0112
R_VDD19_6910 METAL6_2788000_437000 METAL6_2786800_437000 0.0024
R_VDD19_6911 METAL6_2786800_437000 METAL6_2781600_437000 0.0104
R_VDD19_6912 METAL6_2781600_437000 METAL6_2769600_437000 0.024
R_VDD19_6913 METAL6_2769600_437000 METAL6_2765900_437000 0.0074
R_VDD19_6914 METAL6_2765900_437000 METAL6_2751900_437000 0.028
R_VDD19_6915 METAL6_2751900_437000 METAL6_2728200_437000 0.0474
R_VDD19_6916 METAL6_2728200_437000 METAL6_2710900_437000 0.0346
R_VDD19_6917 METAL6_2710900_437000 METAL6_2698900_437000 0.024
R_VDD19_6918 METAL6_2698900_437000 METAL6_2686900_437000 0.024
R_VDD19_6919 METAL6_2686900_437000 METAL6_2683200_437000 0.0074
R_VDD19_6920 METAL6_2683200_437000 METAL6_2676200_437000 0.014
R_VDD19_6921 METAL6_2676200_437000 METAL6_2664200_437000 0.024
R_VDD19_6922 METAL6_2664200_437000 METAL6_2660600_437000 0.0072
R_VDD19_6923 METAL6_2660600_437000 METAL6_2652200_437000 0.0168
R_VDD19_6924 METAL6_2652200_437000 METAL6_2646600_437000 0.0112
R_VDD19_6925 METAL6_2646600_437000 METAL6_2604400_437000 0.0844
R_VDD19_6926 METAL6_2604400_437000 METAL6_2592400_437000 0.024
R_VDD19_6927 METAL6_2592400_437000 METAL6_2580400_437000 0.024
R_VDD19_6928 METAL6_2580400_437000 METAL6_2568400_437000 0.024
R_VDD19_6929 METAL6_2568400_437000 METAL6_2565900_437000 0.005
R_VDD19_6930 METAL6_2565900_437000 METAL6_2556400_437000 0.019
R_VDD19_6931 METAL6_2556400_437000 METAL6_2551900_437000 0.009
R_VDD19_6932 METAL6_2551900_437000 METAL6_2548000_437000 0.0078
R_VDD19_6933 METAL6_2548000_437000 METAL6_2537600_437000 0.0208
R_VDD19_6934 METAL6_2537600_437000 METAL6_2536000_437000 0.0032
R_VDD19_6935 METAL6_2536000_437000 METAL6_2535400_437000 0.0012
R_VDD19_6936 METAL6_2535400_437000 METAL6_2529000_437000 0.0128
R_VDD19_6937 METAL6_2529000_437000 METAL6_2528400_437000 0.0012
R_VDD19_6938 METAL6_2528400_437000 METAL6_2525600_437000 0.0056
R_VDD19_6939 METAL6_2525600_437000 METAL6_2524000_437000 0.0032
R_VDD19_6940 METAL6_2524000_437000 METAL6_2517000_437000 0.014
R_VDD19_6941 METAL6_2517000_437000 METAL6_2516400_437000 0.0012
R_VDD19_6942 METAL6_2516400_437000 METAL6_2513600_437000 0.0056
R_VDD19_6943 METAL6_2513600_437000 METAL6_2512000_437000 0.0032
R_VDD19_6944 METAL6_2512000_437000 METAL6_2510900_437000 0.0022
R_VDD19_6945 METAL6_2510900_437000 METAL6_2505000_437000 0.0118
R_VDD19_6946 METAL6_2505000_437000 METAL6_2504400_437000 0.0012
R_VDD19_6947 METAL6_2504400_437000 METAL6_2501600_437000 0.0056
R_VDD19_6948 METAL6_2501600_437000 METAL6_2500000_437000 0.0032
R_VDD19_6949 METAL6_2500000_437000 METAL6_2498900_437000 0.0022
R_VDD19_6950 METAL6_2498900_437000 METAL6_2496600_437000 0.0046
R_VDD19_6951 METAL6_2496600_437000 METAL6_2493000_437000 0.0072
R_VDD19_6952 METAL6_2493000_437000 METAL6_2492400_437000 0.0012
R_VDD19_6953 METAL6_2492400_437000 METAL6_2489600_437000 0.0056
R_VDD19_6954 METAL6_2489600_437000 METAL6_2488000_437000 0.0032
R_VDD19_6955 METAL6_2488000_437000 METAL6_2486900_437000 0.0022
R_VDD19_6956 METAL6_2486900_437000 METAL6_2484600_437000 0.0046
R_VDD19_6957 METAL6_2484600_437000 METAL6_2482600_437000 0.004
R_VDD19_6958 METAL6_2482600_437000 METAL6_2481000_437000 0.0032
R_VDD19_6959 METAL6_2481000_437000 METAL6_2480400_437000 0.0012
R_VDD19_6960 METAL6_2480400_437000 METAL6_2477600_437000 0.0056
R_VDD19_6961 METAL6_2477600_437000 METAL6_2476000_437000 0.0032
R_VDD19_6962 METAL6_2476000_437000 METAL6_2474900_437000 0.0022
R_VDD19_6963 METAL6_2474900_437000 METAL6_2472600_437000 0.0046
R_VDD19_6964 METAL6_2472600_437000 METAL6_2470600_437000 0.004
R_VDD19_6965 METAL6_2470600_437000 METAL6_2469000_437000 0.0032
R_VDD19_6966 METAL6_2469000_437000 METAL6_2468400_437000 0.0012
R_VDD19_6967 METAL6_2468400_437000 METAL6_2465600_437000 0.0056
R_VDD19_6968 METAL6_2465600_437000 METAL6_2464000_437000 0.0032
R_VDD19_6969 METAL6_2464000_437000 METAL6_2460600_437000 0.0068
R_VDD19_6970 METAL6_2460600_437000 METAL6_2458600_437000 0.004
R_VDD19_6971 METAL6_2458600_437000 METAL6_2457000_437000 0.0032
R_VDD19_6972 METAL6_2457000_437000 METAL6_2452000_437000 0.01
R_VDD19_6973 METAL6_2452000_437000 METAL6_2448600_437000 0.0068
R_VDD19_6974 METAL6_2448600_437000 METAL6_2446600_437000 0.004
R_VDD19_6975 METAL6_2446600_437000 METAL6_2440000_437000 0.0132
R_VDD19_6976 METAL6_2440000_437000 METAL6_2436600_437000 0.0068
R_VDD19_6977 METAL6_2436600_437000 METAL6_2434600_437000 0.004
R_VDD19_6978 METAL6_2434600_437000 METAL6_2424600_437000 0.02
R_VDD19_6979 METAL6_2424600_437000 METAL6_2422600_437000 0.004
R_VDD19_6980 METAL6_2422600_437000 METAL6_2419100_437000 0.007
R_VDD19_6981 METAL6_2419100_437000 METAL6_2407100_437000 0.024
R_VDD19_6982 METAL6_2407100_437000 METAL6_2405600_437000 0.003
R_VDD19_6983 METAL6_2405600_437000 METAL6_2402100_437000 0.007
R_VDD19_6984 METAL6_2402100_437000 METAL6_2395100_437000 0.014
R_VDD19_6985 METAL6_2395100_437000 METAL6_2393600_437000 0.003
R_VDD19_6986 METAL6_2393600_437000 METAL6_2383100_437000 0.021
R_VDD19_6987 METAL6_2383100_437000 METAL6_2381600_437000 0.003
R_VDD19_6988 METAL6_2381600_437000 METAL6_2371100_437000 0.021
R_VDD19_6989 METAL6_2371100_437000 METAL6_2369600_437000 0.003
R_VDD19_6990 METAL6_2369600_437000 METAL6_2365900_437000 0.0074
R_VDD19_6991 METAL6_2365900_437000 METAL6_2357600_437000 0.0166
R_VDD19_6992 METAL6_2357600_437000 METAL6_2351900_437000 0.0114
R_VDD19_6993 METAL6_2351900_437000 METAL6_2343700_437000 0.0164
R_VDD19_6994 METAL6_2343700_437000 METAL6_2332600_437000 0.0222
R_VDD19_6995 METAL6_2332600_437000 METAL6_2322900_437000 0.0194
R_VDD19_6996 METAL6_2322900_437000 METAL6_2320600_437000 0.0046
R_VDD19_6997 METAL6_2320600_437000 METAL6_2310900_437000 0.0194
R_VDD19_6998 METAL6_2310900_437000 METAL6_2308600_437000 0.0046
R_VDD19_6999 METAL6_2308600_437000 METAL6_2298900_437000 0.0194
R_VDD19_7000 METAL6_2298900_437000 METAL6_2296600_437000 0.0046
R_VDD19_7001 METAL6_2296600_437000 METAL6_2286900_437000 0.0194
R_VDD19_7002 METAL6_2286900_437000 METAL6_2284600_437000 0.0046
R_VDD19_7003 METAL6_2284600_437000 METAL6_2284400_437000 0.0004
R_VDD19_7004 METAL6_2284400_437000 METAL6_2274900_437000 0.019
R_VDD19_7005 METAL6_2274900_437000 METAL6_2272600_437000 0.0046
R_VDD19_7006 METAL6_2272600_437000 METAL6_2272400_437000 0.0004
R_VDD19_7007 METAL6_2272400_437000 METAL6_2260600_437000 0.0236
R_VDD19_7008 METAL6_2260600_437000 METAL6_2260400_437000 0.0004
R_VDD19_7009 METAL6_2260400_437000 METAL6_2258600_437000 0.0036
R_VDD19_7010 METAL6_2258600_437000 METAL6_2248700_437000 0.0198
R_VDD19_7011 METAL6_2248700_437000 METAL6_2248600_437000 0.0002
R_VDD19_7012 METAL6_2248600_437000 METAL6_2248400_437000 0.0004
R_VDD19_7013 METAL6_2248400_437000 METAL6_2246600_437000 0.0036
R_VDD19_7014 METAL6_2246600_437000 METAL6_2245900_437000 0.0014
R_VDD19_7015 METAL6_2245900_437000 METAL6_2236700_437000 0.0184
R_VDD19_7016 METAL6_2236700_437000 METAL6_2236600_437000 0.0002
R_VDD19_7017 METAL6_2236600_437000 METAL6_2234600_437000 0.004
R_VDD19_7018 METAL6_2234600_437000 METAL6_2233900_437000 0.0014
R_VDD19_7019 METAL6_2233900_437000 METAL6_2224700_437000 0.0184
R_VDD19_7020 METAL6_2224700_437000 METAL6_2224600_437000 0.0002
R_VDD19_7021 METAL6_2224600_437000 METAL6_2222600_437000 0.004
R_VDD19_7022 METAL6_2222600_437000 METAL6_2221900_437000 0.0014
R_VDD19_7023 METAL6_2221900_437000 METAL6_2212700_437000 0.0184
R_VDD19_7024 METAL6_2212700_437000 METAL6_2212600_437000 0.0002
R_VDD19_7025 METAL6_2212600_437000 METAL6_2210600_437000 0.004
R_VDD19_7026 METAL6_2210600_437000 METAL6_2209900_437000 0.0014
R_VDD19_7027 METAL6_2209900_437000 METAL6_2200700_437000 0.0184
R_VDD19_7028 METAL6_2200700_437000 METAL6_2189900_437000 0.0216
R_VDD19_7029 METAL6_2189900_437000 METAL6_2188700_437000 0.0024
R_VDD19_7030 METAL6_2188700_437000 METAL6_2177900_437000 0.0216
R_VDD19_7031 METAL6_2177900_437000 METAL6_2176700_437000 0.0024
R_VDD19_7032 METAL6_2176700_437000 METAL6_2165900_437000 0.0216
R_VDD19_7033 METAL6_2165900_437000 METAL6_2165400_437000 0.001
R_VDD19_7034 METAL6_2165400_437000 METAL6_2153900_437000 0.023
R_VDD19_7035 METAL6_2153900_437000 METAL6_2153400_437000 0.001
R_VDD19_7036 METAL6_2153400_437000 METAL6_2151900_437000 0.003
R_VDD19_7037 METAL6_2151900_437000 METAL6_2141900_437000 0.02
R_VDD19_7038 METAL6_2141900_437000 METAL6_2141400_437000 0.001
R_VDD19_7039 METAL6_2141400_437000 METAL6_2129900_437000 0.023
R_VDD19_7040 METAL6_2129900_437000 METAL6_2129700_437000 0.0004
R_VDD19_7041 METAL6_2129700_437000 METAL6_2125600_437000 0.0082
R_VDD19_7042 METAL6_2125600_437000 METAL6_2121400_437000 0.0084
R_VDD19_7043 METAL6_2121400_437000 METAL6_2117900_437000 0.007
R_VDD19_7044 METAL6_2117900_437000 METAL6_2113900_437000 0.008
R_VDD19_7045 METAL6_2113900_437000 METAL6_2113600_437000 0.0006
R_VDD19_7046 METAL6_2113600_437000 METAL6_2105900_437000 0.0154
R_VDD19_7047 METAL6_2105900_437000 METAL6_2101900_437000 0.008
R_VDD19_7048 METAL6_2101900_437000 METAL6_2101600_437000 0.0006
R_VDD19_7049 METAL6_2101600_437000 METAL6_2091700_437000 0.0198
R_VDD19_7050 METAL6_2091700_437000 METAL6_2089900_437000 0.0036
R_VDD19_7051 METAL6_2089900_437000 METAL6_2079700_437000 0.0204
R_VDD19_7052 METAL6_2079700_437000 METAL6_2077900_437000 0.0036
R_VDD19_7053 METAL6_2077900_437000 METAL6_2067700_437000 0.0204
R_VDD19_7054 METAL6_2067700_437000 METAL6_2060600_437000 0.0142
R_VDD19_7055 METAL6_2060600_437000 METAL6_2058800_437000 0.0036
R_VDD19_7056 METAL6_2058800_437000 METAL6_2055700_437000 0.0062
R_VDD19_7057 METAL6_2055700_437000 METAL6_2046800_437000 0.0178
R_VDD19_7058 METAL6_2046800_437000 METAL6_2046600_437000 0.0004
R_VDD19_7059 METAL6_2046600_437000 METAL6_2046400_437000 0.0004
R_VDD19_7060 METAL6_2046400_437000 METAL6_2043700_437000 0.0054
R_VDD19_7061 METAL6_2043700_437000 METAL6_2034800_437000 0.0178
R_VDD19_7062 METAL6_2034800_437000 METAL6_2031700_437000 0.0062
R_VDD19_7063 METAL6_2031700_437000 METAL6_2030900_437000 0.0016
R_VDD19_7064 METAL6_2030900_437000 METAL6_2026400_437000 0.009
R_VDD19_7065 METAL6_2026400_437000 METAL6_2021200_437000 0.0104
R_VDD19_7066 METAL6_2021200_437000 METAL6_2019700_437000 0.003
R_VDD19_7067 METAL6_2019700_437000 METAL6_2018900_437000 0.0016
R_VDD19_7068 METAL6_2018900_437000 METAL6_2014400_437000 0.009
R_VDD19_7069 METAL6_2014400_437000 METAL6_2012000_437000 0.0048
R_VDD19_7070 METAL6_2012000_437000 METAL6_2007700_437000 0.0086
R_VDD19_7071 METAL6_2007700_437000 METAL6_2006900_437000 0.0016
R_VDD19_7072 METAL6_2006900_437000 METAL6_2002400_437000 0.009
R_VDD19_7073 METAL6_2002400_437000 METAL6_2000000_437000 0.0048
R_VDD19_7074 METAL6_2000000_437000 METAL6_1988000_437000 0.024
R_VDD19_7075 METAL6_1988000_437000 METAL6_1975900_437000 0.0242
R_VDD19_7076 METAL6_1975900_437000 METAL6_1963900_437000 0.024
R_VDD19_7077 METAL6_1963900_437000 METAL6_1963800_437000 0.0002
R_VDD19_7078 METAL6_1963800_437000 METAL6_1951900_437000 0.0238
R_VDD19_7079 METAL6_1951900_437000 METAL6_1951800_437000 0.0002
R_VDD19_7080 METAL6_1951800_437000 METAL6_1939900_437000 0.0238
R_VDD19_7081 METAL6_1939900_437000 METAL6_1939800_437000 0.0002
R_VDD19_7082 METAL6_1939800_437000 METAL6_1937600_437000 0.0044
R_VDD19_7083 METAL6_1937600_437000 METAL6_1931200_437000 0.0128
R_VDD19_7084 METAL6_1931200_437000 METAL6_1927800_437000 0.0068
R_VDD19_7085 METAL6_1927800_437000 METAL6_1926200_437000 0.0032
R_VDD19_7086 METAL6_1926200_437000 METAL6_1925600_437000 0.0012
R_VDD19_7087 METAL6_1925600_437000 METAL6_1919200_437000 0.0128
R_VDD19_7088 METAL6_1919200_437000 METAL6_1913600_437000 0.0112
R_VDD19_7089 METAL6_1913600_437000 METAL6_1907400_437000 0.0124
R_VDD19_7090 METAL6_1907400_437000 METAL6_1907200_437000 0.0004
R_VDD19_7091 METAL6_1907200_437000 METAL6_1901600_437000 0.0112
R_VDD19_7092 METAL6_1901600_437000 METAL6_1901400_437000 0.0004
R_VDD19_7093 METAL6_1901400_437000 METAL6_1900700_437000 0.0014
R_VDD19_7094 METAL6_1900700_437000 METAL6_1895200_437000 0.011
R_VDD19_7095 METAL6_1895200_437000 METAL6_1889600_437000 0.0112
R_VDD19_7096 METAL6_1889600_437000 METAL6_1889400_437000 0.0004
R_VDD19_7097 METAL6_1889400_437000 METAL6_1888700_437000 0.0014
R_VDD19_7098 METAL6_1888700_437000 METAL5_1888700_437000 0.1
R_VDD19_7099 METAL5_1888700_437000 METAL5_1883200_437000 0.022
R_VDD19_7100 METAL5_1883200_437000 METAL5_1877600_437000 0.0224
R_VDD19_7101 METAL5_1877600_437000 METAL5_1877400_437000 0.0008
R_VDD19_7102 METAL5_1877400_437000 METAL5_1876700_437000 0.0028
R_VDD19_7103 METAL5_1876700_437000 METAL5_1874700_437000 0.008
R_VDD19_7104 METAL5_1874700_437000 METAL5_1871200_437000 0.014
R_VDD19_7105 METAL5_1871200_437000 METAL5_1870600_437000 0.0024
R_VDD19_7106 METAL5_1870600_437000 METAL5_1865600_437000 0.02
R_VDD19_7107 METAL5_1865600_437000 METAL5_1865400_437000 0.0008
R_VDD19_7108 METAL5_1865400_437000 METAL5_1864700_437000 0.0028
R_VDD19_7109 METAL5_1864700_437000 METAL5_1859200_437000 0.022
R_VDD19_7110 METAL5_1859200_437000 METAL5_1858600_437000 0.0024
R_VDD19_7111 METAL5_1858600_437000 METAL5_1858400_437000 0.0008
R_VDD19_7112 METAL5_1858400_437000 METAL5_1853400_437000 0.02
R_VDD19_7113 METAL5_1853400_437000 METAL5_1852700_437000 0.0028
R_VDD19_7114 METAL5_1852700_437000 METAL5_1847200_437000 0.022
R_VDD19_7115 METAL5_1847200_437000 METAL5_1846800_437000 0.0016
R_VDD19_7116 METAL5_1846800_437000 METAL5_1846600_437000 0.0008
R_VDD19_7117 METAL5_1846600_437000 METAL5_1846400_437000 0.0008
R_VDD19_7118 METAL5_1846400_437000 METAL5_1844800_437000 0.0064
R_VDD19_7119 METAL5_1844800_437000 METAL5_1841400_437000 0.0136
R_VDD19_7120 METAL5_1841400_437000 METAL5_1834600_437000 0.0272
R_VDD19_7121 METAL5_1834600_437000 METAL5_1834400_437000 0.0008
R_VDD19_7122 METAL5_1834400_437000 METAL5_1832800_437000 0.0064
R_VDD19_7123 METAL5_1832800_437000 METAL5_1822600_437000 0.0408
R_VDD19_7124 METAL5_1822600_437000 METAL5_1822400_437000 0.0008
R_VDD19_7125 METAL5_1822400_437000 METAL5_1820800_437000 0.0064
R_VDD19_7126 METAL5_1820800_437000 METAL5_1812000_437000 0.0352
R_VDD19_7127 METAL5_1812000_437000 METAL5_1810600_437000 0.0056
R_VDD19_7128 METAL5_1810600_437000 METAL5_1800000_437000 0.0424
R_VDD19_7129 METAL5_1800000_437000 METAL5_1788000_437000 0.048
R_VDD19_7130 METAL5_1788000_437000 METAL5_1787400_437000 0.0024
R_VDD19_7131 METAL5_1787400_437000 METAL5_1775400_437000 0.048
R_VDD19_7132 METAL5_1775400_437000 METAL5_1768000_437000 0.0296
R_VDD19_7133 METAL5_1768000_437000 METAL5_1767700_437000 0.0012
R_VDD19_7134 METAL5_1767700_437000 METAL5_1763800_437000 0.0156
R_VDD19_7135 METAL5_1763800_437000 METAL5_1763400_437000 0.0016
R_VDD19_7136 METAL5_1763400_437000 METAL5_1756000_437000 0.0296
R_VDD19_7137 METAL5_1756000_437000 METAL5_1755700_437000 0.0012
R_VDD19_7138 METAL5_1755700_437000 METAL5_1753800_437000 0.0076
R_VDD19_7139 METAL5_1753800_437000 METAL5_1751800_437000 0.008
R_VDD19_7140 METAL5_1751800_437000 METAL5_1751400_437000 0.0016
R_VDD19_7141 METAL5_1751400_437000 METAL5_1744000_437000 0.0296
R_VDD19_7142 METAL5_1744000_437000 METAL5_1743700_437000 0.0012
R_VDD19_7143 METAL5_1743700_437000 METAL5_1741800_437000 0.0076
R_VDD19_7144 METAL5_1741800_437000 METAL5_1739800_437000 0.008
R_VDD19_7145 METAL5_1739800_437000 METAL5_1739400_437000 0.0016
R_VDD19_7146 METAL5_1739400_437000 METAL5_1732000_437000 0.0296
R_VDD19_7147 METAL5_1732000_437000 METAL5_1731700_437000 0.0012
R_VDD19_7148 METAL5_1731700_437000 METAL5_1729800_437000 0.0076
R_VDD19_7149 METAL5_1729800_437000 METAL5_1727800_437000 0.008
R_VDD19_7150 METAL5_1727800_437000 METAL5_1719700_437000 0.0324
R_VDD19_7151 METAL5_1719700_437000 METAL5_1717800_437000 0.0076
R_VDD19_7152 METAL5_1717800_437000 METAL5_1710800_437000 0.028
R_VDD19_7153 METAL5_1710800_437000 METAL5_1707700_437000 0.0124
R_VDD19_7154 METAL5_1707700_437000 METAL5_1699000_437000 0.0348
R_VDD19_7155 METAL5_1699000_437000 METAL5_1692000_437000 0.028
R_VDD19_7156 METAL5_1692000_437000 METAL5_1682800_437000 0.0368
R_VDD19_7157 METAL5_1682800_437000 METAL5_1680000_437000 0.0112
R_VDD19_7158 METAL5_1680000_437000 METAL5_1670800_437000 0.0368
R_VDD19_7159 METAL5_1670800_437000 METAL5_1668000_437000 0.0112
R_VDD19_7160 METAL5_1668000_437000 METAL5_1660700_437000 0.0292
R_VDD19_7161 METAL5_1660700_437000 METAL5_1658800_437000 0.0076
R_VDD19_7162 METAL5_1658800_437000 METAL5_1648700_437000 0.0404
R_VDD19_7163 METAL5_1648700_437000 METAL5_1648700_444400 0.0296
R_VDD19_7164 METAL5_1648700_444400 METAL5_1648000_444400 0.0028
R_VDD19_7165 METAL5_1648000_444400 METAL5_1646800_444400 0.0048
R_VDD19_7166 METAL5_1646800_444400 METAL5_1636700_444400 0.0404
R_VDD19_7167 METAL5_1636700_444400 METAL5_1636700_447000 0.0104
R_VDD19_7168 METAL5_1636700_447000 METAL5_1636700_449000 0.008
R_VDD19_7169 METAL5_1636700_449000 METAL5_1636700_453000 0.016
R_VDD19_7170 METAL5_1636700_453000 METAL5_1636700_456400 0.0136
R_VDD19_7171 METAL5_1636700_456400 METAL5_1636700_459000 0.0104
R_VDD19_7172 METAL5_1636700_459000 METAL5_1636700_461000 0.008
R_VDD19_7173 METAL5_1636700_461000 METAL6_1636700_461000 0.1
R_VDD19_7174 METAL6_1636700_461000 METAL6_1646800_461000 0.0202
R_VDD19_7175 METAL6_1646800_461000 METAL6_1646800_465000 0.008
R_VDD19_7176 METAL6_1646800_465000 METAL6_1646800_468400 0.0068
R_VDD19_7177 METAL6_1646800_468400 METAL6_1646800_471000 0.0052
R_VDD19_7178 METAL6_1646800_471000 METAL6_1646800_473000 0.004
R_VDD19_7179 METAL6_1646800_473000 METAL6_1646800_477000 0.008
R_VDD19_7180 METAL6_1646800_477000 METAL6_1646800_480400 0.0068
R_VDD19_7181 METAL6_1646800_480400 METAL6_1646800_483000 0.0052
R_VDD19_7182 METAL6_1646800_483000 METAL6_1646800_488000 0.01
R_VDD19_7183 METAL6_1646800_488000 METAL6_1646800_492400 0.0088
R_VDD19_7184 METAL6_1646800_492400 METAL6_1646800_495000 0.0052
R_VDD19_7185 METAL6_1646800_495000 METAL6_1646800_500000 0.01
R_VDD19_7186 METAL6_1646800_500000 METAL6_1646800_504000 0.008
R_VDD19_7187 METAL6_1646800_504000 METAL6_1648000_504000 0.0024
R_VDD19_7188 METAL6_1648000_504000 METAL6_1648700_504000 0.0014
R_VDD19_7189 METAL6_1648700_504000 METAL6_1658800_504000 0.0202
R_VDD19_7190 METAL6_1658800_504000 METAL6_1660700_504000 0.0038
R_VDD19_7191 METAL6_1660700_504000 METAL6_1668000_504000 0.0146
R_VDD19_7192 METAL6_1668000_504000 METAL6_1670800_504000 0.0056
R_VDD19_7193 METAL6_1670800_504000 METAL6_1680000_504000 0.0184
R_VDD19_7194 METAL6_1680000_504000 METAL6_1680000_504400 0.0008
R_VDD19_7195 METAL6_1680000_504400 METAL6_1680000_507000 0.0052
R_VDD19_7196 METAL6_1680000_507000 METAL6_1680000_507800 0.0016
R_VDD19_7197 METAL6_1680000_507800 METAL6_1680000_512000 0.0084
R_VDD19_7198 METAL6_1680000_512000 METAL6_1680000_516000 0.008
R_VDD19_7199 METAL6_1692000_516000 METAL6_1680000_516000 0.024
I_VDD19_26 METAL6_1692000_516000 gnd 0.001

V_VDD2_12 METAL6_1300000_0 gnd 2
R_VDD2_7200 METAL6_1300000_0 METAL6_1300000_9500 0.019
R_VDD2_7201 METAL6_1300000_9500 METAL6_1300000_16600 0.0142
R_VDD2_7202 METAL6_1300000_16600 METAL6_1300000_21500 0.0098
R_VDD2_7203 METAL6_1300000_21500 METAL6_1300000_28600 0.0142
R_VDD2_7204 METAL6_1300000_28600 METAL6_1300000_33500 0.0098
R_VDD2_7205 METAL6_1300000_33500 METAL6_1300000_40000 0.013
R_VDD2_7206 METAL6_1300000_40000 METAL6_1301000_40000 0.002
R_VDD2_7207 METAL6_1301000_40000 METAL6_1311800_40000 0.0216
R_VDD2_7208 METAL6_1311800_40000 METAL6_1311800_40600 0.0012
R_VDD2_7209 METAL6_1311800_40600 METAL6_1311800_52000 0.0228
R_VDD2_7210 METAL6_1311800_52000 METAL6_1311800_52600 0.0012
R_VDD2_7211 METAL6_1311800_52600 METAL6_1311800_64000 0.0228
R_VDD2_7212 METAL6_1311800_64000 METAL6_1311800_64600 0.0012
R_VDD2_7213 METAL6_1311800_64600 METAL6_1311800_71600 0.014
R_VDD2_7214 METAL6_1311800_71600 METAL6_1311800_76000 0.0088
R_VDD2_7215 METAL6_1311800_76000 METAL6_1311800_76600 0.0012
R_VDD2_7216 METAL6_1311800_76600 METAL6_1311800_83600 0.014
R_VDD2_7217 METAL6_1311800_83600 METAL6_1311800_88000 0.0088
R_VDD2_7218 METAL6_1311800_88000 METAL6_1311800_88600 0.0012
R_VDD2_7219 METAL6_1311800_88600 METAL6_1311800_95600 0.014
R_VDD2_7220 METAL6_1311800_95600 METAL6_1311800_100000 0.0088
R_VDD2_7221 METAL6_1311800_100000 METAL6_1311800_100600 0.0012
R_VDD2_7222 METAL6_1311800_100600 METAL6_1311800_112000 0.0228
R_VDD2_7223 METAL6_1311800_112000 METAL6_1311800_147600 0.0712
R_VDD2_7224 METAL6_1311800_147600 METAL6_1311800_159600 0.024
R_VDD2_7225 METAL6_1311800_159600 METAL6_1311800_164000 0.0088
R_VDD2_7226 METAL6_1311800_164000 METAL6_1311800_166600 0.0052
R_VDD2_7227 METAL6_1311800_166600 METAL6_1311800_171600 0.01
R_VDD2_7228 METAL6_1311800_171600 METAL6_1311800_176000 0.0088
R_VDD2_7229 METAL6_1311800_176000 METAL6_1311800_178600 0.0052
R_VDD2_7230 METAL6_1311800_178600 METAL6_1311800_188000 0.0188
R_VDD2_7231 METAL6_1311800_188000 METAL6_1311800_190600 0.0052
R_VDD2_7232 METAL6_1311800_190600 METAL6_1311800_200000 0.0188
R_VDD2_7233 METAL6_1311800_200000 METAL6_1311800_202600 0.0052
R_VDD2_7234 METAL6_1311800_202600 METAL6_1311800_212000 0.0188
R_VDD2_7235 METAL6_1311800_212000 METAL6_1311800_236300 0.0486
R_VDD2_7236 METAL6_1311800_236300 METAL6_1311800_248300 0.024
R_VDD2_7237 METAL6_1311800_248300 METAL6_1311800_251000 0.0054
R_VDD2_7238 METAL6_1311800_251000 METAL6_1311800_260300 0.0186
R_VDD2_7239 METAL6_1311800_260300 METAL6_1311800_263000 0.0054
R_VDD2_7240 METAL6_1311800_263000 METAL6_1311800_272300 0.0186
R_VDD2_7241 METAL6_1311800_272300 METAL6_1311800_275000 0.0054
R_VDD2_7242 METAL6_1311800_275000 METAL6_1311800_279300 0.0086
R_VDD2_7243 METAL6_1311800_279300 METAL6_1311800_287000 0.0154
R_VDD2_7244 METAL6_1311800_287000 METAL6_1311800_288000 0.002
R_VDD2_7245 METAL6_1311800_288000 METAL6_1311800_299000 0.022
R_VDD2_7246 METAL6_1311800_299000 METAL6_1311800_300000 0.002
R_VDD2_7247 METAL6_1311800_300000 METAL6_1311800_311000 0.022
R_VDD2_7248 METAL6_1311800_311000 METAL6_1311800_312000 0.002
R_VDD2_7249 METAL6_1311800_312000 METAL6_1311800_355300 0.0866
R_VDD2_7250 METAL6_1311800_355300 METAL6_1311800_362300 0.014
R_VDD2_7251 METAL6_1311800_362300 METAL6_1311800_366800 0.009
R_VDD2_7252 METAL6_1311800_366800 METAL6_1311800_374300 0.015
R_VDD2_7253 METAL6_1311800_374300 METAL6_1311800_378800 0.009
R_VDD2_7254 METAL6_1311800_378800 METAL6_1311800_386300 0.015
R_VDD2_7255 METAL6_1311800_386300 METAL6_1311800_388000 0.0034
R_VDD2_7256 METAL6_1311800_388000 METAL6_1311800_390800 0.0056
R_VDD2_7257 METAL6_1311800_390800 METAL6_1311800_400000 0.0184
R_VDD2_7258 METAL6_1311800_400000 METAL6_1311800_401000 0.002
R_VDD2_7259 METAL6_1311800_401000 METAL6_1311800_402800 0.0036
R_VDD2_7260 METAL6_1311800_402800 METAL6_1311800_412000 0.0184
R_VDD2_7261 METAL6_1311800_412000 METAL6_1311800_413000 0.002
R_VDD2_7262 METAL6_1311800_413000 METAL6_1312000_413000 0.0004
R_VDD2_7263 METAL6_1312000_413000 METAL6_1313000_413000 0.002
R_VDD2_7264 METAL6_1313000_413000 METAL6_1323800_413000 0.0216
R_VDD2_7265 METAL6_1323800_413000 METAL6_1324000_413000 0.0004
R_VDD2_7266 METAL6_1324000_413000 METAL6_1325000_413000 0.002
R_VDD2_7267 METAL6_1325000_413000 METAL6_1336000_413000 0.022
R_VDD2_7268 METAL6_1336000_413000 METAL6_1337000_413000 0.002
R_VDD2_7269 METAL6_1337000_413000 METAL6_1348000_413000 0.022
R_VDD2_7270 METAL6_1348000_413000 METAL6_1349000_413000 0.002
R_VDD2_7271 METAL6_1349000_413000 METAL6_1388000_413000 0.078
R_VDD2_7272 METAL6_1388000_413000 METAL6_1396800_413000 0.0176
R_VDD2_7273 METAL6_1396800_413000 METAL6_1400000_413000 0.0064
R_VDD2_7274 METAL6_1400000_413000 METAL6_1408800_413000 0.0176
R_VDD2_7275 METAL6_1408800_413000 METAL6_1412000_413000 0.0064
R_VDD2_7276 METAL6_1412000_413000 METAL6_1419700_413000 0.0154
R_VDD2_7277 METAL6_1419700_413000 METAL6_1420800_413000 0.0022
R_VDD2_7278 METAL6_1420800_413000 METAL6_1424000_413000 0.0064
R_VDD2_7279 METAL6_1424000_413000 METAL6_1431700_413000 0.0154
R_VDD2_7280 METAL6_1431700_413000 METAL6_1432800_413000 0.0022
R_VDD2_7281 METAL6_1432800_413000 METAL6_1443700_413000 0.0218
R_VDD2_7282 METAL6_1443700_413000 METAL6_1444800_413000 0.0022
R_VDD2_7283 METAL6_1444800_413000 METAL6_1479400_413000 0.0692
R_VDD2_7284 METAL6_1479400_413000 METAL6_1488000_413000 0.0172
R_VDD2_7285 METAL6_1488000_413000 METAL6_1491400_413000 0.0068
R_VDD2_7286 METAL6_1491400_413000 METAL6_1498300_413000 0.0138
R_VDD2_7287 METAL6_1498300_413000 METAL6_1500000_413000 0.0034
R_VDD2_7288 METAL6_1500000_413000 METAL6_1503400_413000 0.0068
R_VDD2_7289 METAL6_1503400_413000 METAL6_1510400_413000 0.014
R_VDD2_7290 METAL6_1510400_413000 METAL6_1512000_413000 0.0032
R_VDD2_7291 METAL6_1512000_413000 METAL6_1527800_413000 0.0316
R_VDD2_7292 METAL6_1527800_413000 METAL6_1539800_413000 0.024
R_VDD2_7293 METAL6_1539800_413000 METAL6_1540000_413000 0.0004
R_VDD2_7294 METAL6_1540000_413000 METAL5_1540000_413000 0.1
R_VDD2_7295 METAL5_1540000_413000 METAL5_1545000_413000 0.02
R_VDD2_7296 METAL5_1545000_413000 METAL5_1551800_413000 0.0272
R_VDD2_7297 METAL5_1551800_413000 METAL5_1552000_413000 0.0008
R_VDD2_7298 METAL5_1552000_413000 METAL5_1555400_413000 0.0136
R_VDD2_7299 METAL5_1555400_413000 METAL5_1557000_413000 0.0064
R_VDD2_7300 METAL5_1557000_413000 METAL5_1564000_413000 0.028
R_VDD2_7301 METAL5_1564000_413000 METAL5_1567800_413000 0.0152
R_VDD2_7302 METAL5_1567800_413000 METAL5_1569000_413000 0.0048
R_VDD2_7303 METAL5_1569000_413000 METAL5_1574700_413000 0.0228
R_VDD2_7304 METAL5_1574700_413000 METAL5_1576000_413000 0.0052
R_VDD2_7305 METAL5_1576000_413000 METAL5_1576700_413000 0.0028
R_VDD2_7306 METAL5_1576700_413000 METAL5_1579800_413000 0.0124
R_VDD2_7307 METAL5_1579800_413000 METAL5_1588000_413000 0.0328
R_VDD2_7308 METAL5_1588000_413000 METAL5_1588700_413000 0.0028
R_VDD2_7309 METAL5_1588700_413000 METAL5_1591800_413000 0.0124
R_VDD2_7310 METAL5_1591800_413000 METAL5_1600000_413000 0.0328
R_VDD2_7311 METAL5_1600000_413000 METAL5_1600700_413000 0.0028
R_VDD2_7312 METAL5_1600700_413000 METAL5_1603800_413000 0.0124
R_VDD2_7313 METAL5_1603800_413000 METAL5_1607900_413000 0.0164
R_VDD2_7314 METAL5_1607900_413000 METAL5_1612000_413000 0.0164
R_VDD2_7315 METAL5_1612000_413000 METAL5_1612700_413000 0.0028
R_VDD2_7316 METAL5_1612700_413000 METAL5_1615800_413000 0.0124
R_VDD2_7317 METAL5_1615800_413000 METAL5_1624000_413000 0.0328
R_VDD2_7318 METAL5_1624000_413000 METAL6_1624000_413000 0.1
R_VDD2_7319 METAL6_1624000_413000 METAL6_1624700_413000 0.0014
R_VDD2_7320 METAL6_1624700_413000 METAL6_1627800_413000 0.0062
R_VDD2_7321 METAL6_1627800_413000 METAL6_1632800_413000 0.01
R_VDD2_7322 METAL6_1632800_413000 METAL6_1634800_413000 0.004
R_VDD2_7323 METAL6_1634800_413000 METAL6_1636000_413000 0.0024
R_VDD2_7324 METAL6_1636000_413000 METAL6_1636000_414800 0.0036
R_VDD2_7325 METAL6_1636000_414800 METAL6_1636000_424000 0.0184
R_VDD2_7326 METAL6_1636000_424000 METAL6_1636000_425000 0.002
R_VDD2_7327 METAL6_1636000_425000 METAL6_1636700_425000 0.0014
R_VDD2_7328 METAL6_1636700_425000 METAL6_1646800_425000 0.0202
R_VDD2_7329 METAL6_1646800_425000 METAL6_1648700_425000 0.0038
R_VDD2_7330 METAL6_1648700_425000 METAL6_1658800_425000 0.0202
R_VDD2_7331 METAL6_1658800_425000 METAL6_1668000_425000 0.0184
R_VDD2_7332 METAL6_1668000_425000 METAL6_1670800_425000 0.0056
R_VDD2_7333 METAL6_1670800_425000 METAL6_1680000_425000 0.0184
R_VDD2_7334 METAL6_1680000_425000 METAL6_1682800_425000 0.0056
R_VDD2_7335 METAL6_1682800_425000 METAL6_1692000_425000 0.0184
R_VDD2_7336 METAL6_1692000_425000 METAL6_1699000_425000 0.014
R_VDD2_7337 METAL6_1699000_425000 METAL6_1707700_425000 0.0174
R_VDD2_7338 METAL6_1707700_425000 METAL6_1710800_425000 0.0062
R_VDD2_7339 METAL6_1710800_425000 METAL6_1717800_425000 0.014
R_VDD2_7340 METAL6_1717800_425000 METAL6_1719700_425000 0.0038
R_VDD2_7341 METAL6_1719700_425000 METAL6_1727800_425000 0.0162
R_VDD2_7342 METAL6_1727800_425000 METAL6_1729800_425000 0.004
R_VDD2_7343 METAL6_1729800_425000 METAL6_1731700_425000 0.0038
R_VDD2_7344 METAL6_1731700_425000 METAL6_1732000_425000 0.0006
R_VDD2_7345 METAL6_1732000_425000 METAL6_1739400_425000 0.0148
R_VDD2_7346 METAL6_1739400_425000 METAL6_1739800_425000 0.0008
R_VDD2_7347 METAL6_1739800_425000 METAL5_1739800_425000 0.1
R_VDD2_7348 METAL5_1739800_425000 METAL5_1741800_425000 0.008
R_VDD2_7349 METAL5_1741800_425000 METAL5_1743700_425000 0.0076
R_VDD2_7350 METAL5_1743700_425000 METAL5_1744000_425000 0.0012
R_VDD2_7351 METAL5_1744000_425000 METAL5_1751400_425000 0.0296
R_VDD2_7352 METAL5_1751400_425000 METAL5_1751800_425000 0.0016
R_VDD2_7353 METAL5_1751800_425000 METAL5_1753800_425000 0.008
R_VDD2_7354 METAL5_1753800_425000 METAL5_1755700_425000 0.0076
R_VDD2_7355 METAL5_1755700_425000 METAL5_1756000_425000 0.0012
R_VDD2_7356 METAL5_1756000_425000 METAL5_1763400_425000 0.0296
R_VDD2_7357 METAL5_1763400_425000 METAL5_1763800_425000 0.0016
R_VDD2_7358 METAL5_1763800_425000 METAL5_1767700_425000 0.0156
R_VDD2_7359 METAL5_1767700_425000 METAL5_1768000_425000 0.0012
R_VDD2_7360 METAL5_1768000_425000 METAL5_1775400_425000 0.0296
R_VDD2_7361 METAL5_1775400_425000 METAL5_1787400_425000 0.048
R_VDD2_7362 METAL5_1787400_425000 METAL5_1788000_425000 0.0024
R_VDD2_7363 METAL5_1788000_425000 METAL5_1800000_425000 0.048
R_VDD2_7364 METAL5_1800000_425000 METAL5_1810600_425000 0.0424
R_VDD2_7365 METAL5_1810600_425000 METAL5_1812000_425000 0.0056
R_VDD2_7366 METAL5_1812000_425000 METAL5_1820800_425000 0.0352
R_VDD2_7367 METAL5_1820800_425000 METAL5_1822400_425000 0.0064
R_VDD2_7368 METAL5_1822400_425000 METAL5_1822600_425000 0.0008
R_VDD2_7369 METAL5_1822600_425000 METAL5_1832800_425000 0.0408
R_VDD2_7370 METAL5_1832800_425000 METAL5_1834400_425000 0.0064
R_VDD2_7371 METAL5_1834400_425000 METAL5_1834600_425000 0.0008
R_VDD2_7372 METAL5_1834600_425000 METAL5_1841400_425000 0.0272
R_VDD2_7373 METAL5_1841400_425000 METAL5_1844800_425000 0.0136
R_VDD2_7374 METAL5_1844800_425000 METAL5_1846400_425000 0.0064
R_VDD2_7375 METAL5_1846400_425000 METAL5_1846600_425000 0.0008
R_VDD2_7376 METAL5_1846600_425000 METAL5_1846800_425000 0.0008
R_VDD2_7377 METAL5_1846800_425000 METAL5_1847200_425000 0.0016
R_VDD2_7378 METAL5_1847200_425000 METAL5_1852700_425000 0.022
R_VDD2_7379 METAL5_1852700_425000 METAL5_1853400_425000 0.0028
R_VDD2_7380 METAL5_1853400_425000 METAL5_1858400_425000 0.02
R_VDD2_7381 METAL5_1858400_425000 METAL5_1858600_425000 0.0008
R_VDD2_7382 METAL5_1858600_425000 METAL5_1859200_425000 0.0024
R_VDD2_7383 METAL5_1859200_425000 METAL5_1864700_425000 0.022
R_VDD2_7384 METAL5_1864700_425000 METAL5_1865400_425000 0.0028
R_VDD2_7385 METAL5_1865400_425000 METAL5_1865600_425000 0.0008
R_VDD2_7386 METAL5_1865600_425000 METAL5_1870600_425000 0.02
R_VDD2_7387 METAL5_1870600_425000 METAL5_1871200_425000 0.0024
R_VDD2_7388 METAL5_1871200_425000 METAL5_1874700_425000 0.014
R_VDD2_7389 METAL5_1874700_425000 METAL5_1876700_425000 0.008
R_VDD2_7390 METAL5_1876700_425000 METAL6_1876700_425000 0.1
R_VDD2_7391 METAL6_1876700_425000 METAL6_1876700_426800 0.0036
R_VDD2_7392 METAL6_1876700_426800 METAL6_1876700_437000 0.0204
R_VDD2_7393 METAL6_1876700_437000 METAL6_1876700_447000 0.02
R_VDD2_7394 METAL6_1876700_447000 METAL6_1876700_449000 0.004
R_VDD2_7395 METAL6_1876700_449000 METAL6_1876700_453000 0.008
R_VDD2_7396 METAL6_1876700_453000 METAL6_1876700_456400 0.0068
R_VDD2_7397 METAL6_1876700_456400 METAL6_1876700_459000 0.0052
R_VDD2_7398 METAL6_1876700_459000 METAL6_1876700_461000 0.004
R_VDD2_7399 METAL6_1876700_461000 METAL6_1876700_465000 0.008
R_VDD2_7400 METAL6_1876700_465000 METAL6_1876700_468400 0.0068
R_VDD2_7401 METAL6_1876700_468400 METAL6_1876700_471000 0.0052
R_VDD2_7402 METAL6_1876700_471000 METAL6_1876700_473000 0.004
R_VDD2_7403 METAL6_1876700_473000 METAL6_1876700_477000 0.008
R_VDD2_7404 METAL6_1876700_477000 METAL6_1876700_480400 0.0068
R_VDD2_7405 METAL6_1876700_480400 METAL6_1876700_483000 0.0052
R_VDD2_7406 METAL6_1876700_483000 METAL6_1876700_488000 0.01
R_VDD2_7407 METAL6_1876700_488000 METAL6_1876700_492400 0.0088
R_VDD2_7408 METAL6_1876700_492400 METAL6_1876700_495000 0.0052
R_VDD2_7409 METAL6_1876700_495000 METAL6_1876700_500000 0.01
R_VDD2_7410 METAL6_1876700_500000 METAL6_1876700_504000 0.008
R_VDD2_7411 METAL6_1876700_504000 METAL6_1876700_507000 0.006
R_VDD2_7412 METAL6_1876700_507000 METAL6_1876700_507800 0.0016
R_VDD2_7413 METAL6_1876700_507800 METAL6_1876700_512000 0.0084
R_VDD2_7414 METAL6_1876700_512000 METAL6_1876700_516000 0.008
R_VDD2_7415 METAL6_1876700_516000 METAL6_1876700_519000 0.006
R_VDD2_7416 METAL6_1876700_519000 METAL6_1876700_520200 0.0024
R_VDD2_7417 METAL6_1876700_520200 METAL6_1876700_528000 0.0156
R_VDD2_7418 METAL6_1876700_528000 METAL6_1876700_532200 0.0084
R_VDD2_7419 METAL6_1876700_532200 METAL6_1876700_535400 0.0064
R_VDD2_7420 METAL6_1876700_535400 METAL6_1876700_538400 0.006
R_VDD2_7421 METAL6_1876700_538400 METAL6_1876700_544200 0.0116
R_VDD2_7422 METAL6_1876700_544200 METAL6_1876700_547400 0.0064
R_VDD2_7423 METAL6_1876700_547400 METAL6_1876700_550400 0.006
R_VDD2_7424 METAL6_1876700_550400 METAL6_1876700_556200 0.0116
R_VDD2_7425 METAL6_1876700_556200 METAL6_1876700_559400 0.0064
R_VDD2_7426 METAL6_1876700_559400 METAL6_1876700_561000 0.0032
R_VDD2_7427 METAL6_1876700_561000 METAL6_1876700_562400 0.0028
R_VDD2_7428 METAL6_1876700_562400 METAL6_1876700_571400 0.018
R_VDD2_7429 METAL6_1876700_571400 METAL6_1876700_573000 0.0032
R_VDD2_7430 METAL6_1876700_573000 METAL6_1876700_574400 0.0028
R_VDD2_7431 METAL6_1876700_574400 METAL6_1876700_579800 0.0108
R_VDD2_7432 METAL6_1876700_579800 METAL6_1876700_585000 0.0104
R_VDD2_7433 METAL6_1876700_585000 METAL6_1876700_586400 0.0028
R_VDD2_7434 METAL6_1876700_586400 METAL6_1876700_588000 0.0032
R_VDD2_7435 METAL6_1876700_588000 METAL6_1876700_597000 0.018
R_VDD2_7436 METAL6_1876700_597000 METAL6_1876700_598400 0.0028
R_VDD2_7437 METAL6_1876700_598400 METAL6_1876700_600000 0.0032
R_VDD2_7438 METAL6_1876700_600000 METAL6_1876700_605400 0.0108
R_VDD2_7439 METAL6_1876700_605400 METAL6_1876700_612000 0.0132
R_VDD2_7440 METAL6_1876700_612000 METAL6_1876700_617400 0.0108
R_VDD2_7441 METAL6_1876700_617400 METAL6_1876700_629400 0.024
R_VDD2_7442 METAL6_1876700_629400 METAL6_1876700_637800 0.0168
R_VDD2_7443 METAL6_1876700_637800 METAL6_1876700_641400 0.0072
R_VDD2_7444 METAL6_1876700_641400 METAL6_1876700_649800 0.0168
R_VDD2_7445 METAL6_1876700_649800 METAL6_1876700_653400 0.0072
R_VDD2_7446 METAL6_1876700_653400 METAL6_1876700_661800 0.0168
R_VDD2_7447 METAL6_1876700_661800 METAL6_1876700_665400 0.0072
R_VDD2_7448 METAL6_1876700_665400 METAL6_1876700_685800 0.0408
R_VDD2_7449 METAL6_1876700_685800 METAL6_1876700_688000 0.0044
R_VDD2_7450 METAL6_1876700_688000 METAL6_1876700_697800 0.0196
R_VDD2_7451 METAL6_1876700_697800 METAL6_1876700_700000 0.0044
R_VDD2_7452 METAL6_1876700_700000 METAL6_1876700_702800 0.0056
R_VDD2_7453 METAL6_1876700_702800 METAL6_1876700_709800 0.014
R_VDD2_7454 METAL6_1876700_709800 METAL6_1876700_712000 0.0044
R_VDD2_7455 METAL6_1876700_712000 METAL6_1876700_716800 0.0096
R_VDD2_7456 METAL6_1876700_716800 METAL6_1876700_721800 0.01
R_VDD2_7457 METAL6_1876700_721800 METAL6_1877400_721800 0.0014
R_VDD2_7458 METAL6_1877400_721800 METAL6_1877400_722400 0.0012
R_VDD2_7459 METAL6_1877400_722400 METAL6_1877400_733800 0.0228
R_VDD2_7460 METAL6_1877400_733800 METAL6_1877400_734400 0.0012
R_VDD2_7461 METAL6_1877400_734400 METAL6_1877400_735400 0.002
R_VDD2_7462 METAL6_1877400_735400 METAL6_1877400_742400 0.014
R_VDD2_7463 METAL6_1877400_742400 METAL6_1877400_745800 0.0068
R_VDD2_7464 METAL6_1877400_745800 METAL6_1877400_746400 0.0012
R_VDD2_7465 METAL6_1877400_746400 METAL6_1877600_746400 0.0004
R_VDD2_7466 METAL6_1877600_746400 METAL6_1883200_746400 0.0112
R_VDD2_7467 METAL6_1883200_746400 METAL6_1888700_746400 0.011
R_VDD2_7468 METAL6_1888700_746400 METAL6_1888700_754400 0.016
R_VDD2_7469 METAL6_1888700_754400 METAL6_1888700_757800 0.0068
R_VDD2_7470 METAL6_1888700_757800 METAL6_1889400_757800 0.0014
R_VDD2_7471 METAL6_1889400_757800 METAL6_1889400_758400 0.0012
R_VDD2_7472 METAL6_1889400_758400 METAL6_1889400_760000 0.0032
R_VDD2_7473 METAL6_1889400_760000 METAL6_1889400_763000 0.006
R_VDD2_7474 METAL6_1889400_763000 METAL6_1889400_766400 0.0068
R_VDD2_7475 METAL6_1889400_766400 METAL6_1889400_769800 0.0068
R_VDD2_7476 METAL6_1889400_769800 METAL6_1889400_770400 0.0012
R_VDD2_7477 METAL6_1889400_770400 METAL6_1889600_770400 0.0004
R_VDD2_7478 METAL6_1889600_770400 METAL6_1895200_770400 0.0112
R_VDD2_7479 METAL6_1895200_770400 METAL6_1900700_770400 0.011
R_VDD2_7480 METAL6_1900700_770400 METAL6_1901600_770400 0.0018
R_VDD2_7481 METAL6_1901600_770400 METAL6_1907200_770400 0.0112
R_VDD2_7482 METAL6_1907200_770400 METAL6_1907400_770400 0.0004
R_VDD2_7483 METAL6_1907400_770400 METAL6_1913600_770400 0.0124
R_VDD2_7484 METAL6_1913600_770400 METAL6_1919200_770400 0.0112
R_VDD2_7485 METAL6_1919200_770400 METAL6_1925600_770400 0.0128
R_VDD2_7486 METAL6_1925600_770400 METAL6_1926200_770400 0.0012
R_VDD2_7487 METAL6_1926200_770400 METAL6_1927800_770400 0.0032
R_VDD2_7488 METAL6_1927800_770400 METAL6_1931200_770400 0.0068
R_VDD2_7489 METAL6_1931200_770400 METAL6_1937600_770400 0.0128
R_VDD2_7490 METAL6_1937600_770400 METAL6_1939800_770400 0.0044
R_VDD2_7491 METAL6_1939800_770400 METAL6_1939800_772000 0.0032
R_VDD2_7492 METAL6_1939800_772000 METAL6_1939800_778400 0.0128
R_VDD2_7493 METAL6_1939800_778400 METAL6_1939800_779200 0.0016
R_VDD2_7494 METAL6_1939800_779200 METAL6_1939800_781800 0.0052
R_VDD2_7495 METAL6_1939800_781800 METAL6_1939800_782400 0.0012
R_VDD2_7496 METAL6_1939800_782400 METAL6_1939900_782400 0.0002
R_VDD2_7497 METAL6_1939900_782400 METAL6_1951800_782400 0.0238
R_VDD2_7498 METAL6_1951800_782400 METAL6_1951800_784000 0.0032
R_VDD2_7499 METAL6_1951800_784000 METAL6_1951800_784500 0.001
R_VDD2_7500 METAL6_1951800_784500 METAL6_1951800_788000 0.007
R_VDD2_7501 METAL6_1951800_788000 METAL6_1951800_790400 0.0048
R_VDD2_7502 METAL6_1951800_790400 METAL6_1951800_791200 0.0016
R_VDD2_7503 METAL6_1951800_791200 METAL6_1951800_794400 0.0064
R_VDD2_7504 METAL6_1951800_794400 METAL6_1951800_794800 0.0008
R_VDD2_7505 METAL6_1951800_794800 METAL6_1951800_800000 0.0104
R_VDD2_7506 METAL6_1951800_800000 METAL6_1951800_802400 0.0048
R_VDD2_7507 METAL6_1951800_802400 METAL6_1951800_803200 0.0016
R_VDD2_7508 METAL6_1951800_803200 METAL6_1951800_806400 0.0064
R_VDD2_7509 METAL6_1951800_806400 METAL6_1951800_808000 0.0032
R_VDD2_7510 METAL6_1951800_808000 METAL6_1951800_812000 0.008
R_VDD2_7511 METAL6_1951800_812000 METAL6_1951800_814400 0.0048
R_VDD2_7512 METAL6_1951800_814400 METAL6_1951800_818400 0.008
R_VDD2_7513 METAL6_1951800_818400 METAL6_1951800_820000 0.0032
R_VDD2_7514 METAL6_1951800_820000 METAL6_1951800_828700 0.0174
R_VDD2_7515 METAL6_1951800_828700 METAL6_1951800_830400 0.0034
R_VDD2_7516 METAL6_1951800_830400 METAL6_1951800_832000 0.0032
R_VDD2_7517 METAL6_1951800_832000 METAL6_1951800_839500 0.015
R_VDD2_7518 METAL6_1951800_839500 METAL6_1951800_840700 0.0024
R_VDD2_7519 METAL6_1951800_840700 METAL6_1951800_842400 0.0034
R_VDD2_7520 METAL6_1951800_842400 METAL6_1951800_851500 0.0182
R_VDD2_7521 METAL6_1951800_851500 METAL6_1951800_852700 0.0024
R_VDD2_7522 METAL6_1951800_852700 METAL6_1951800_854400 0.0034
R_VDD2_7523 METAL6_1951800_854400 METAL6_1951800_858200 0.0076
R_VDD2_7524 METAL6_1951800_858200 METAL6_1951800_863500 0.0106
R_VDD2_7525 METAL6_1951800_863500 METAL6_1951800_875000 0.023
R_VDD2_7526 METAL6_1951800_875000 METAL6_1951800_887000 0.024
R_VDD2_7527 METAL6_1951800_887000 METAL6_1951800_888000 0.002
R_VDD2_7528 METAL6_1951800_888000 METAL6_1951800_888400 0.0008
R_VDD2_7529 METAL6_1951800_888400 METAL6_1951800_899000 0.0212
R_VDD2_7530 METAL6_1951800_899000 METAL6_1951800_900000 0.002
R_VDD2_7531 METAL6_1951800_900000 METAL6_1951800_900400 0.0008
R_VDD2_7532 METAL6_1951800_900400 METAL6_1951800_911000 0.0212
R_VDD2_7533 METAL6_1951800_911000 METAL6_1951800_912000 0.002
R_VDD2_7534 METAL6_1951800_912000 METAL6_1951800_912400 0.0008
R_VDD2_7535 METAL6_1951800_912400 METAL6_1951800_923000 0.0212
R_VDD2_7536 METAL6_1951800_923000 METAL6_1951800_924000 0.002
R_VDD2_7537 METAL6_1951800_924000 METAL6_1951800_927300 0.0066
R_VDD2_7538 METAL6_1951800_927300 METAL6_1951800_935000 0.0154
R_VDD2_7539 METAL6_1951800_935000 METAL6_1951800_947000 0.024
R_VDD2_7540 METAL6_1951800_947000 METAL6_1951800_959000 0.024
R_VDD2_7541 METAL6_1951800_959000 METAL6_1951900_959000 0.0002
R_VDD2_7542 METAL6_1951900_959000 METAL6_1963800_959000 0.0238
R_VDD2_7543 METAL6_1963800_959000 METAL6_1963900_959000 0.0002
R_VDD2_7544 METAL6_1963900_959000 METAL6_1975900_959000 0.024
R_VDD2_7545 METAL6_1975900_959000 METAL6_1988000_959000 0.0242
R_VDD2_7546 METAL6_1988000_959000 METAL6_2000000_959000 0.024
R_VDD2_7547 METAL6_2000000_959000 METAL6_2002400_959000 0.0048
R_VDD2_7548 METAL6_2002400_959000 METAL6_2006900_959000 0.009
R_VDD2_7549 METAL6_2006900_959000 METAL6_2007700_959000 0.0016
R_VDD2_7550 METAL6_2007700_959000 METAL6_2012000_959000 0.0086
R_VDD2_7551 METAL6_2012000_959000 METAL6_2014400_959000 0.0048
R_VDD2_7552 METAL6_2014400_959000 METAL6_2018900_959000 0.009
R_VDD2_7553 METAL6_2018900_959000 METAL6_2019700_959000 0.0016
R_VDD2_7554 METAL6_2019700_959000 METAL6_2021200_959000 0.003
R_VDD2_7555 METAL6_2021200_959000 METAL6_2026400_959000 0.0104
R_VDD2_7556 METAL6_2026400_959000 METAL6_2030900_959000 0.009
R_VDD2_7557 METAL6_2030900_959000 METAL6_2031700_959000 0.0016
R_VDD2_7558 METAL6_2031700_959000 METAL6_2034800_959000 0.0062
R_VDD2_7559 METAL6_2034800_959000 METAL6_2043700_959000 0.0178
R_VDD2_7560 METAL6_2043700_959000 METAL6_2046400_959000 0.0054
R_VDD2_7561 METAL6_2046400_959000 METAL6_2046600_959000 0.0004
R_VDD2_7562 METAL6_2046600_959000 METAL6_2046800_959000 0.0004
R_VDD2_7563 METAL6_2046800_959000 METAL6_2055700_959000 0.0178
R_VDD2_7564 METAL6_2055700_959000 METAL6_2058800_959000 0.0062
R_VDD2_7565 METAL6_2058800_959000 METAL6_2060600_959000 0.0036
R_VDD2_7566 METAL6_2060600_959000 METAL6_2067700_959000 0.0142
R_VDD2_7567 METAL6_2067700_959000 METAL6_2077900_959000 0.0204
R_VDD2_7568 METAL6_2077900_959000 METAL6_2079700_959000 0.0036
R_VDD2_7569 METAL6_2079700_959000 METAL6_2089900_959000 0.0204
R_VDD2_7570 METAL6_2089900_959000 METAL6_2091700_959000 0.0036
R_VDD2_7571 METAL6_2091700_959000 METAL6_2101600_959000 0.0198
R_VDD2_7572 METAL6_2101600_959000 METAL6_2101900_959000 0.0006
R_VDD2_7573 METAL6_2101900_959000 METAL6_2105900_959000 0.008
R_VDD2_7574 METAL6_2105900_959000 METAL6_2113600_959000 0.0154
R_VDD2_7575 METAL6_2113600_959000 METAL6_2113900_959000 0.0006
R_VDD2_7576 METAL6_2113900_959000 METAL6_2117900_959000 0.008
R_VDD2_7577 METAL6_2117900_959000 METAL6_2121400_959000 0.007
R_VDD2_7578 METAL6_2121400_959000 METAL6_2125600_959000 0.0084
R_VDD2_7579 METAL6_2125600_959000 METAL6_2129700_959000 0.0082
R_VDD2_7580 METAL6_2129700_959000 METAL6_2129900_959000 0.0004
R_VDD2_7581 METAL6_2129900_959000 METAL6_2141400_959000 0.023
R_VDD2_7582 METAL6_2141400_959000 METAL6_2141900_959000 0.001
R_VDD2_7583 METAL6_2141900_959000 METAL6_2151900_959000 0.02
R_VDD2_7584 METAL6_2151900_959000 METAL6_2153400_959000 0.003
R_VDD2_7585 METAL6_2153400_959000 METAL6_2153900_959000 0.001
R_VDD2_7586 METAL6_2153900_959000 METAL6_2165400_959000 0.023
R_VDD2_7587 METAL6_2165400_959000 METAL6_2165900_959000 0.001
R_VDD2_7588 METAL6_2165900_959000 METAL6_2176700_959000 0.0216
R_VDD2_7589 METAL6_2176700_959000 METAL6_2177900_959000 0.0024
R_VDD2_7590 METAL6_2177900_959000 METAL6_2188700_959000 0.0216
R_VDD2_7591 METAL6_2188700_959000 METAL6_2189900_959000 0.0024
R_VDD2_7592 METAL6_2189900_959000 METAL6_2200700_959000 0.0216
R_VDD2_7593 METAL6_2200700_959000 METAL6_2209900_959000 0.0184
R_VDD2_7594 METAL6_2209900_959000 METAL6_2210600_959000 0.0014
R_VDD2_7595 METAL6_2210600_959000 METAL6_2212700_959000 0.0042
R_VDD2_7596 METAL6_2212700_959000 METAL5_2212700_959000 0.1
R_VDD2_7597 METAL5_2212700_959000 METAL5_2212700_971000 0.048
R_VDD2_7598 METAL5_2212700_971000 METAL5_2221900_971000 0.0368
R_VDD2_7599 METAL5_2221900_971000 METAL5_2221900_976000 0.02
R_VDD2_7600 METAL5_2221900_976000 METAL5_2221900_983000 0.028
R_VDD2_7601 METAL5_2221900_983000 METAL5_2221900_988000 0.02
R_VDD2_7602 METAL5_2221900_988000 METAL5_2221900_995000 0.028
R_VDD2_7603 METAL5_2221900_995000 METAL5_2221900_1000000 0.02
R_VDD2_7604 METAL5_2221900_1000000 METAL5_2221900_1007000 0.028
R_VDD2_7605 METAL5_2221900_1007000 METAL5_2221900_1012000 0.02
R_VDD2_7606 METAL5_2221900_1012000 METAL5_2221900_1013400 0.0056
R_VDD2_7607 METAL5_2221900_1013400 METAL5_2222600_1013400 0.0028
R_VDD2_7608 METAL5_2222600_1013400 METAL5_2224600_1013400 0.008
R_VDD2_7609 METAL5_2224600_1013400 METAL5_2224600_1014000 0.0024
R_VDD2_7610 METAL5_2224600_1014000 METAL5_2224600_1019000 0.02
R_VDD2_7611 METAL5_2224600_1019000 METAL5_2224600_1023700 0.0188
R_VDD2_7612 METAL5_2224600_1023700 METAL5_2224600_1025400 0.0068
R_VDD2_7613 METAL5_2224600_1025400 METAL5_2224600_1026000 0.0024
R_VDD2_7614 METAL5_2224600_1026000 METAL5_2224600_1029800 0.0152
R_VDD2_7615 METAL5_2224600_1029800 METAL5_2224600_1031000 0.0048
R_VDD2_7616 METAL5_2224600_1031000 METAL5_2224600_1035700 0.0188
R_VDD2_7617 METAL5_2224600_1035700 METAL5_2224600_1037400 0.0068
R_VDD2_7618 METAL5_2224600_1037400 METAL5_2224600_1038000 0.0024
R_VDD2_7619 METAL5_2224600_1038000 METAL5_2224600_1041800 0.0152
R_VDD2_7620 METAL5_2224600_1041800 METAL5_2224600_1042700 0.0036
R_VDD2_7621 METAL5_2224600_1042700 METAL5_2224600_1043000 0.0012
R_VDD2_7622 METAL5_2224600_1043000 METAL5_2224600_1047700 0.0188
R_VDD2_7623 METAL5_2224600_1047700 METAL5_2224600_1049400 0.0068
R_VDD2_7624 METAL5_2224600_1049400 METAL5_2224700_1049400 0.0004
R_VDD2_7625 METAL5_2224700_1049400 METAL6_2224700_1049400 0.1
R_VDD2_7626 METAL6_2224700_1049400 METAL6_2224700_1049800 0.0008
R_VDD2_7627 METAL6_2224700_1049800 METAL6_2224700_1053800 0.008
R_VDD2_7628 METAL6_2224700_1053800 METAL6_2224700_1054700 0.0018
R_VDD2_7629 METAL6_2224700_1054700 METAL6_2224700_1061400 0.0134
R_VDD2_7630 METAL6_2224700_1061400 METAL6_2224700_1061800 0.0008
R_VDD2_7631 METAL6_2224700_1061800 METAL6_2224700_1066700 0.0098
R_VDD2_7632 METAL6_2224700_1066700 METAL6_2233900_1066700 0.0184
R_VDD2_7633 METAL6_2233900_1066700 METAL6_2233900_1073400 0.0134
R_VDD2_7634 METAL6_2233900_1073400 METAL6_2234600_1073400 0.0014
R_VDD2_7635 METAL6_2234600_1073400 METAL6_2236600_1073400 0.004
R_VDD2_7636 METAL6_2236600_1073400 METAL6_2236600_1073800 0.0008
R_VDD2_7637 METAL6_2236600_1073800 METAL6_2236600_1074000 0.0004
R_VDD2_7638 METAL6_2236600_1074000 METAL6_2236600_1074500 0.001
R_VDD2_7639 METAL6_2236600_1074500 METAL6_2236600_1084800 0.0206
R_VDD2_7640 METAL6_2236600_1084800 METAL6_2236600_1085400 0.0012
R_VDD2_7641 METAL6_2236600_1085400 METAL6_2236600_1085800 0.0008
R_VDD2_7642 METAL6_2236600_1085800 METAL6_2236600_1086000 0.0004
R_VDD2_7643 METAL6_2236600_1086000 METAL6_2236600_1086300 0.0006
R_VDD2_7644 METAL6_2236600_1086300 METAL6_2236600_1086500 0.0004
R_VDD2_7645 METAL6_2236600_1086500 METAL6_2236600_1088000 0.003
R_VDD2_7646 METAL6_2236600_1088000 METAL6_2236600_1096800 0.0176
R_VDD2_7647 METAL6_2236600_1096800 METAL6_2236600_1097800 0.002
R_VDD2_7648 METAL6_2236600_1097800 METAL6_2236600_1098000 0.0004
R_VDD2_7649 METAL6_2236600_1098000 METAL6_2236600_1098300 0.0006
R_VDD2_7650 METAL6_2236600_1098300 METAL6_2236700_1098300 0.0002
R_VDD2_7651 METAL6_2236700_1098300 METAL6_2246600_1098300 0.0198
R_VDD2_7652 METAL6_2246600_1098300 METAL6_2248400_1098300 0.0036
R_VDD2_7653 METAL6_2248400_1098300 METAL6_2248600_1098300 0.0004
R_VDD2_7654 METAL6_2248600_1098300 METAL6_2248600_1098500 0.0004
R_VDD2_7655 METAL6_2248600_1098500 METAL6_2248600_1100000 0.003
R_VDD2_7656 METAL6_2248600_1100000 METAL6_2248600_1108800 0.0176
R_VDD2_7657 METAL6_2248600_1108800 METAL6_2248600_1110000 0.0024
R_VDD2_7658 METAL6_2248600_1110000 METAL6_2248600_1110300 0.0006
R_VDD2_7659 METAL6_2248600_1110300 METAL6_2248600_1110500 0.0004
R_VDD2_7660 METAL6_2248600_1110500 METAL6_2248600_1112000 0.003
R_VDD2_7661 METAL6_2248600_1112000 METAL6_2248600_1120800 0.0176
R_VDD2_7662 METAL6_2248600_1120800 METAL6_2248600_1122300 0.003
R_VDD2_7663 METAL6_2248600_1122300 METAL6_2248600_1122500 0.0004
R_VDD2_7664 METAL6_2248600_1122500 METAL6_2248600_1129300 0.0136
R_VDD2_7665 METAL6_2248600_1129300 METAL6_2248600_1132800 0.007
R_VDD2_7666 METAL6_2248600_1132800 METAL6_2248600_1134300 0.003
R_VDD2_7667 METAL6_2248600_1134300 METAL6_2248600_1134500 0.0004
R_VDD2_7668 METAL6_2248600_1134500 METAL6_2248600_1141300 0.0136
R_VDD2_7669 METAL6_2248600_1141300 METAL6_2248600_1144800 0.007
R_VDD2_7670 METAL6_2248600_1144800 METAL6_2248600_1146300 0.003
R_VDD2_7671 METAL6_2248600_1146300 METAL6_2248600_1146500 0.0004
R_VDD2_7672 METAL6_2248600_1146500 METAL6_2248600_1153300 0.0136
R_VDD2_7673 METAL6_2248600_1153300 METAL6_2248600_1157700 0.0088
R_VDD2_7674 METAL6_2248600_1157700 METAL6_2248600_1160600 0.0058
R_VDD2_7675 METAL6_2248600_1160600 METAL6_2248600_1165300 0.0094
R_VDD2_7676 METAL6_2248600_1165300 METAL6_2248600_1169700 0.0088
R_VDD2_7677 METAL6_2248600_1169700 METAL6_2248600_1172600 0.0058
R_VDD2_7678 METAL6_2248600_1172600 METAL6_2248600_1181700 0.0182
R_VDD2_7679 METAL6_2248600_1181700 METAL6_2248600_1181800 0.0002
R_VDD2_7680 METAL6_2248600_1181800 METAL6_2248600_1184600 0.0056
R_VDD2_7681 METAL6_2248600_1184600 METAL6_2248600_1191600 0.014
R_VDD2_7682 METAL6_2248600_1191600 METAL6_2248600_1193700 0.0042
R_VDD2_7683 METAL6_2248600_1193700 METAL6_2248600_1193800 0.0002
R_VDD2_7684 METAL6_2248600_1193800 METAL6_2248600_1205700 0.0238
R_VDD2_7685 METAL6_2248600_1205700 METAL6_2248600_1205800 0.0002
R_VDD2_7686 METAL6_2248600_1205800 METAL6_2248600_1217700 0.0238
R_VDD2_7687 METAL6_2248600_1217700 METAL6_2248600_1223700 0.012
R_VDD2_7688 METAL6_2248600_1223700 METAL5_2248600_1223700 0.1
R_VDD2_7689 METAL5_2248600_1223700 METAL5_2248700_1223700 0.0004
R_VDD2_7690 METAL5_2248700_1223700 METAL5_2258600_1223700 0.0396
R_VDD2_7691 METAL5_2258600_1223700 METAL5_2260400_1223700 0.0072
R_VDD2_7692 METAL5_2260400_1223700 METAL5_2260600_1223700 0.0008
R_VDD2_7693 METAL5_2260600_1223700 METAL5_2272400_1223700 0.0472
R_VDD2_7694 METAL5_2272400_1223700 METAL5_2272600_1223700 0.0008
R_VDD2_7695 METAL5_2272600_1223700 METAL5_2274900_1223700 0.0092
R_VDD2_7696 METAL5_2274900_1223700 METAL5_2284400_1223700 0.038
R_VDD2_7697 METAL5_2284400_1223700 METAL5_2284600_1223700 0.0008
R_VDD2_7698 METAL5_2284600_1223700 METAL5_2286900_1223700 0.0092
R_VDD2_7699 METAL5_2286900_1223700 METAL5_2296600_1223700 0.0388
R_VDD2_7700 METAL5_2296600_1223700 METAL5_2296600_1229700 0.024
R_VDD2_7701 METAL5_2296600_1229700 METAL5_2296600_1235700 0.024
R_VDD2_7702 METAL5_2296600_1235700 METAL5_2298900_1235700 0.0092
R_VDD2_7703 METAL5_2298900_1235700 METAL5_2308600_1235700 0.0388
R_VDD2_7704 METAL5_2308600_1235700 METAL5_2310900_1235700 0.0092
R_VDD2_7705 METAL5_2310900_1235700 METAL5_2320600_1235700 0.0388
R_VDD2_7706 METAL5_2320600_1235700 METAL5_2320600_1238000 0.0092
R_VDD2_7707 METAL5_2320600_1238000 METAL5_2320600_1247700 0.0388
R_VDD2_7708 METAL5_2320600_1247700 METAL5_2320600_1250000 0.0092
R_VDD2_7709 METAL5_2320600_1250000 METAL5_2320600_1259700 0.0388
R_VDD2_7710 METAL5_2320600_1259700 METAL5_2320600_1261000 0.0052
R_VDD2_7711 METAL5_2320600_1261000 METAL5_2320600_1262000 0.004
R_VDD2_7712 METAL5_2320600_1262000 METAL5_2320600_1271700 0.0388
R_VDD2_7713 METAL5_2320600_1271700 METAL5_2320600_1273000 0.0052
R_VDD2_7714 METAL5_2320600_1273000 METAL5_2320600_1283700 0.0428
R_VDD2_7715 METAL5_2320600_1283700 METAL5_2320600_1285000 0.0052
R_VDD2_7716 METAL5_2320600_1285000 METAL5_2320600_1290000 0.02
R_VDD2_7717 METAL5_2320600_1290000 METAL5_2320600_1295700 0.0228
R_VDD2_7718 METAL5_2320600_1295700 METAL5_2320600_1297000 0.0052
R_VDD2_7719 METAL5_2320600_1297000 METAL6_2320600_1297000 0.1
R_VDD2_7720 METAL6_2320600_1297000 METAL6_2320600_1302000 0.01
R_VDD2_7721 METAL6_2320600_1302000 METAL6_2320600_1307700 0.0114
R_VDD2_7722 METAL6_2320600_1307700 METAL6_2322900_1307700 0.0046
R_VDD2_7723 METAL6_2322900_1307700 METAL6_2343700_1307700 0.0416
R_VDD2_7724 METAL6_2343700_1307700 METAL6_2351900_1307700 0.0164
R_VDD2_7725 METAL6_2351900_1307700 METAL6_2357600_1307700 0.0114
R_VDD2_7726 METAL6_2357600_1307700 METAL6_2365900_1307700 0.0166
R_VDD2_7727 METAL6_2365900_1307700 METAL6_2369600_1307700 0.0074
R_VDD2_7728 METAL6_2369600_1307700 METAL6_2371100_1307700 0.003
R_VDD2_7729 METAL6_2371100_1307700 METAL6_2381600_1307700 0.021
R_VDD2_7730 METAL6_2381600_1307700 METAL6_2383100_1307700 0.003
R_VDD2_7731 METAL6_2383100_1307700 METAL6_2393600_1307700 0.021
R_VDD2_7732 METAL6_2393600_1307700 METAL6_2395100_1307700 0.003
R_VDD2_7733 METAL6_2395100_1307700 METAL6_2402100_1307700 0.014
R_VDD2_7734 METAL6_2402100_1307700 METAL6_2405600_1307700 0.007
R_VDD2_7735 METAL6_2405600_1307700 METAL6_2407100_1307700 0.003
R_VDD2_7736 METAL6_2407100_1307700 METAL6_2419100_1307700 0.024
R_VDD2_7737 METAL6_2419100_1307700 METAL6_2422600_1307700 0.007
R_VDD2_7738 METAL6_2422600_1307700 METAL6_2424600_1307700 0.004
R_VDD2_7739 METAL6_2424600_1307700 METAL6_2434600_1307700 0.02
R_VDD2_7740 METAL6_2434600_1307700 METAL6_2436600_1307700 0.004
R_VDD2_7741 METAL6_2436600_1307700 METAL6_2436600_1309000 0.0026
R_VDD2_7742 METAL6_2436600_1309000 METAL6_2436600_1314000 0.01
R_VDD2_7743 METAL6_2436600_1314000 METAL6_2436600_1319700 0.0114
R_VDD2_7744 METAL6_2436600_1319700 METAL6_2436600_1326000 0.0126
R_VDD2_7745 METAL6_2436600_1326000 METAL6_2436600_1338000 0.024
R_VDD2_7746 METAL6_2436600_1338000 METAL6_2436600_1350000 0.024
R_VDD2_7747 METAL6_2436600_1350000 METAL6_2436600_1357000 0.014
R_VDD2_7748 METAL6_2436600_1357000 METAL6_2436600_1362000 0.01
R_VDD2_7749 METAL6_2436600_1362000 METAL6_2436600_1369000 0.014
R_VDD2_7750 METAL6_2436600_1369000 METAL6_2436600_1374000 0.01
R_VDD2_7751 METAL6_2436600_1374000 METAL6_2436600_1381000 0.014
R_VDD2_7752 METAL6_2436600_1381000 METAL6_2436600_1386600 0.0112
R_VDD2_7753 METAL6_2436600_1386600 METAL6_2436600_1393000 0.0128
R_VDD2_7754 METAL6_2436600_1393000 METAL6_2436600_1405000 0.024
R_VDD2_7755 METAL6_2436600_1405000 METAL6_2436600_1417000 0.024
R_VDD2_7756 METAL6_2436600_1417000 METAL6_2436600_1437700 0.0414
R_VDD2_7757 METAL6_2436600_1437700 METAL6_2436600_1449700 0.024
R_VDD2_7758 METAL6_2436600_1449700 METAL6_2436600_1461700 0.024
R_VDD2_7759 METAL6_2436600_1461700 METAL5_2436600_1461700 0.1
R_VDD2_7760 METAL5_2436600_1461700 METAL5_2446600_1461700 0.04
R_VDD2_7761 METAL5_2446600_1461700 METAL5_2448600_1461700 0.008
R_VDD2_7762 METAL5_2448600_1461700 METAL5_2457000_1461700 0.0336
R_VDD2_7763 METAL5_2457000_1461700 METAL5_2458600_1461700 0.0064
R_VDD2_7764 METAL5_2458600_1461700 METAL5_2460600_1461700 0.008
R_VDD2_7765 METAL5_2460600_1461700 METAL5_2464000_1461700 0.0136
R_VDD2_7766 METAL5_2464000_1461700 METAL5_2465600_1461700 0.0064
R_VDD2_7767 METAL5_2465600_1461700 METAL5_2468400_1461700 0.0112
R_VDD2_7768 METAL5_2468400_1461700 METAL5_2469000_1461700 0.0024
R_VDD2_7769 METAL5_2469000_1461700 METAL5_2470600_1461700 0.0064
R_VDD2_7770 METAL5_2470600_1461700 METAL5_2472600_1461700 0.008
R_VDD2_7771 METAL5_2472600_1461700 METAL5_2476000_1461700 0.0136
R_VDD2_7772 METAL5_2476000_1461700 METAL5_2477600_1461700 0.0064
R_VDD2_7773 METAL5_2477600_1461700 METAL5_2480400_1461700 0.0112
R_VDD2_7774 METAL5_2480400_1461700 METAL5_2481000_1461700 0.0024
R_VDD2_7775 METAL5_2481000_1461700 METAL5_2484600_1461700 0.0144
R_VDD2_7776 METAL5_2484600_1461700 METAL5_2486900_1461700 0.0092
R_VDD2_7777 METAL5_2486900_1461700 METAL5_2488000_1461700 0.0044
R_VDD2_7778 METAL5_2488000_1461700 METAL5_2489600_1461700 0.0064
R_VDD2_7779 METAL5_2489600_1461700 METAL5_2492400_1461700 0.0112
R_VDD2_7780 METAL5_2492400_1461700 METAL5_2493000_1461700 0.0024
R_VDD2_7781 METAL5_2493000_1461700 METAL6_2493000_1461700 0.1
R_VDD2_7782 METAL6_2493000_1461700 METAL6_2493000_1492300 0.0612
R_VDD2_7783 METAL6_2493000_1492300 METAL6_2493000_1504300 0.024
R_VDD2_7784 METAL6_2493000_1504300 METAL6_2493000_1516300 0.024
R_VDD2_7785 METAL6_2493000_1516300 METAL6_2493000_1528300 0.024
R_VDD2_7786 METAL6_2493000_1528300 METAL6_2493000_1540300 0.024
R_VDD2_7787 METAL6_2493000_1540300 METAL6_2493000_1552300 0.024
R_VDD2_7788 METAL6_2493000_1552300 METAL6_2493000_1554500 0.0044
R_VDD2_7789 METAL6_2493000_1554500 METAL6_2493000_1564300 0.0196
R_VDD2_7790 METAL6_2493000_1564300 METAL6_2493000_1571300 0.014
R_VDD2_7791 METAL6_2493000_1571300 METAL6_2493000_1576300 0.01
R_VDD2_7792 METAL6_2493000_1576300 METAL6_2493000_1714500 0.2764
R_VDD2_7793 METAL6_2493000_1714500 METAL6_2493000_1720500 0.012
R_VDD2_7794 METAL6_2493000_1720500 METAL6_2493000_1726500 0.012
R_VDD2_7795 METAL6_2493000_1726500 METAL6_2493000_1731700 0.0104
R_VDD2_7796 METAL6_2493000_1731700 METAL6_2493000_1738500 0.0136
R_VDD2_7797 METAL6_2493000_1738500 METAL6_2493000_1750500 0.024
R_VDD2_7798 METAL6_2493000_1750500 METAL6_2493000_1762500 0.024
R_VDD2_7799 METAL6_2505000_1762500 METAL6_2500000_1762500 0.01
R_VDD2_7800 METAL6_2500000_1762500 METAL6_2498900_1762500 0.0022
R_VDD2_7801 METAL6_2498900_1762500 METAL6_2493000_1762500 0.0118
R_VDD2_7802 METAL6_995000_465000 METAL6_1007000_465000 0.024
R_VDD2_7803 METAL6_1337000_413000 METAL6_1337000_414800 0.0036
R_VDD2_7804 METAL6_1337000_414800 METAL6_1337000_424000 0.0184
R_VDD2_7805 METAL6_1337000_424000 METAL6_1337000_425000 0.002
R_VDD2_7806 METAL6_1337000_425000 METAL6_1337000_426800 0.0036
R_VDD2_7807 METAL6_1337000_426800 METAL6_1337000_437000 0.0204
R_VDD2_7808 METAL6_1337000_437000 METAL6_1336000_437000 0.002
R_VDD2_7809 METAL6_1336000_437000 METAL6_1325000_437000 0.022
R_VDD2_7810 METAL6_1325000_437000 METAL5_1325000_437000 0.1
R_VDD2_7811 METAL5_1325000_437000 METAL5_1325000_447000 0.04
R_VDD2_7812 METAL5_1325000_447000 METAL5_1325000_449000 0.008
R_VDD2_7813 METAL5_1325000_449000 METAL5_1325000_453000 0.016
R_VDD2_7814 METAL5_1325000_453000 METAL5_1325000_456400 0.0136
R_VDD2_7815 METAL5_1325000_456400 METAL5_1325000_459000 0.0104
R_VDD2_7816 METAL5_1325000_459000 METAL5_1325000_461000 0.008
R_VDD2_7817 METAL5_1325000_461000 METAL6_1325000_461000 0.1
R_VDD2_7818 METAL6_1325000_461000 METAL6_1325000_465000 0.008
R_VDD2_7819 METAL6_1325000_465000 METAL6_1324000_465000 0.002
R_VDD2_7820 METAL6_1324000_465000 METAL6_1323800_465000 0.0004
R_VDD2_7821 METAL6_1323800_465000 METAL6_1313000_465000 0.0216
R_VDD2_7822 METAL6_1313000_465000 METAL6_1312000_465000 0.002
R_VDD2_7823 METAL6_1312000_465000 METAL6_1311800_465000 0.0004
R_VDD2_7824 METAL6_1311800_465000 METAL6_1301000_465000 0.0216
R_VDD2_7825 METAL6_1301000_465000 METAL6_1300000_465000 0.002
R_VDD2_7826 METAL6_1300000_465000 METAL6_1299800_465000 0.0004
R_VDD2_7827 METAL6_1299800_465000 METAL6_1294300_465000 0.011
R_VDD2_7828 METAL6_1294300_465000 METAL6_1289000_465000 0.0106
R_VDD2_7829 METAL6_1289000_465000 METAL6_1288000_465000 0.002
R_VDD2_7830 METAL6_1288000_465000 METAL6_1287800_465000 0.0004
R_VDD2_7831 METAL6_1287800_465000 METAL6_1286700_465000 0.0022
R_VDD2_7832 METAL6_1286700_465000 METAL6_1282300_465000 0.0088
R_VDD2_7833 METAL6_1282300_465000 METAL6_1276000_465000 0.0126
R_VDD2_7834 METAL6_1276000_465000 METAL6_1274700_465000 0.0026
R_VDD2_7835 METAL6_1274700_465000 METAL6_1270300_465000 0.0088
R_VDD2_7836 METAL6_1270300_465000 METAL6_1266800_465000 0.007
R_VDD2_7837 METAL6_1266800_465000 METAL6_1262700_465000 0.0082
R_VDD2_7838 METAL6_1262700_465000 METAL6_1259800_465000 0.0058
R_VDD2_7839 METAL6_1259800_465000 METAL6_1258300_465000 0.003
R_VDD2_7840 METAL6_1258300_465000 METAL6_1254700_465000 0.0072
R_VDD2_7841 METAL6_1254700_465000 METAL6_1253300_465000 0.0028
R_VDD2_7842 METAL6_1253300_465000 METAL6_1248000_465000 0.0106
R_VDD2_7843 METAL6_1248000_465000 METAL6_1247800_465000 0.0004
R_VDD2_7844 METAL6_1247800_465000 METAL6_1246300_465000 0.003
R_VDD2_7845 METAL6_1246300_465000 METAL6_1242700_465000 0.0072
R_VDD2_7846 METAL6_1242700_465000 METAL6_1236000_465000 0.0134
R_VDD2_7847 METAL6_1236000_465000 METAL6_1235800_465000 0.0004
R_VDD2_7848 METAL6_1235800_465000 METAL6_1234300_465000 0.003
R_VDD2_7849 METAL6_1234300_465000 METAL6_1230700_465000 0.0072
R_VDD2_7850 METAL6_1230700_465000 METAL6_1224000_465000 0.0134
R_VDD2_7851 METAL6_1224000_465000 METAL6_1223800_465000 0.0004
R_VDD2_7852 METAL6_1223800_465000 METAL6_1222300_465000 0.003
R_VDD2_7853 METAL6_1222300_465000 METAL6_1218700_465000 0.0072
R_VDD2_7854 METAL6_1218700_465000 METAL6_1216400_465000 0.0046
R_VDD2_7855 METAL6_1216400_465000 METAL6_1212000_465000 0.0088
R_VDD2_7856 METAL6_1212000_465000 METAL6_1211800_465000 0.0004
R_VDD2_7857 METAL6_1211800_465000 METAL6_1210300_465000 0.003
R_VDD2_7858 METAL6_1210300_465000 METAL6_1206700_465000 0.0072
R_VDD2_7859 METAL6_1206700_465000 METAL6_1204400_465000 0.0046
R_VDD2_7860 METAL6_1204400_465000 METAL6_1200000_465000 0.0088
R_VDD2_7861 METAL6_1200000_465000 METAL6_1199800_465000 0.0004
R_VDD2_7862 METAL6_1199800_465000 METAL6_1198300_465000 0.003
R_VDD2_7863 METAL6_1198300_465000 METAL6_1194700_465000 0.0072
R_VDD2_7864 METAL6_1194700_465000 METAL6_1192400_465000 0.0046
R_VDD2_7865 METAL6_1192400_465000 METAL6_1188000_465000 0.0088
R_VDD2_7866 METAL6_1188000_465000 METAL6_1187800_465000 0.0004
R_VDD2_7867 METAL6_1187800_465000 METAL6_1186300_465000 0.003
R_VDD2_7868 METAL6_1186300_465000 METAL6_1182700_465000 0.0072
R_VDD2_7869 METAL6_1182700_465000 METAL6_1180400_465000 0.0046
R_VDD2_7870 METAL6_1180400_465000 METAL6_1176000_465000 0.0088
R_VDD2_7871 METAL6_1176000_465000 METAL6_1174300_465000 0.0034
R_VDD2_7872 METAL6_1174300_465000 METAL6_1173700_465000 0.0012
R_VDD2_7873 METAL6_1173700_465000 METAL6_1166700_465000 0.014
R_VDD2_7874 METAL6_1166700_465000 METAL6_1162300_465000 0.0088
R_VDD2_7875 METAL6_1162300_465000 METAL6_1154700_465000 0.0152
R_VDD2_7876 METAL6_1154700_465000 METAL6_1150300_465000 0.0088
R_VDD2_7877 METAL6_1150300_465000 METAL6_1142700_465000 0.0152
R_VDD2_7878 METAL6_1142700_465000 METAL6_1137000_465000 0.0114
R_VDD2_7879 METAL6_1137000_465000 METAL6_1130700_465000 0.0126
R_VDD2_7880 METAL6_1130700_465000 METAL6_1125000_465000 0.0114
R_VDD2_7881 METAL6_1125000_465000 METAL6_1118700_465000 0.0126
R_VDD2_7882 METAL6_1118700_465000 METAL6_1113000_465000 0.0114
R_VDD2_7883 METAL6_1113000_465000 METAL6_1019000_465000 0.188
R_VDD2_7884 METAL6_1019000_465000 METAL6_1007000_465000 0.024
R_VDD2_7885 METAL6_3275000_2505000 METAL6_3275000_2493000 0.024
R_VDD2_7886 METAL6_2493000_1762500 METAL6_2493000_1774500 0.024
R_VDD2_7887 METAL6_2493000_1774500 METAL6_2493000_1802500 0.056
R_VDD2_7888 METAL6_2493000_1802500 METAL6_2493000_1814500 0.024
R_VDD2_7889 METAL6_2493000_1814500 METAL6_2493000_1826500 0.024
R_VDD2_7890 METAL6_2493000_1826500 METAL6_2493000_1838500 0.024
R_VDD2_7891 METAL6_2493000_1838500 METAL6_2493000_1852300 0.0276
R_VDD2_7892 METAL6_2493000_1852300 METAL6_2493000_1854300 0.004
R_VDD2_7893 METAL6_2493000_1854300 METAL6_2493000_1866300 0.024
R_VDD2_7894 METAL6_2493000_1866300 METAL6_2493000_1878300 0.024
R_VDD2_7895 METAL6_2493000_1878300 METAL6_2493000_1890500 0.0244
R_VDD2_7896 METAL6_2493000_1890500 METAL6_2493000_1902500 0.024
R_VDD2_7897 METAL6_2493000_1902500 METAL6_2493000_1914500 0.024
R_VDD2_7898 METAL6_2493000_1914500 METAL6_2493000_1926500 0.024
R_VDD2_7899 METAL6_2493000_1926500 METAL6_2493000_1938500 0.024
R_VDD2_7900 METAL6_2493000_1938500 METAL6_2493000_1939000 0.001
R_VDD2_7901 METAL6_2493000_1939000 METAL6_2493000_1940500 0.003
R_VDD2_7902 METAL6_2493000_1940500 METAL5_2493000_1940500 0.1
R_VDD2_7903 METAL5_2493000_1940500 METAL5_2492400_1940500 0.0024
R_VDD2_7904 METAL5_2492400_1940500 METAL5_2489600_1940500 0.0112
R_VDD2_7905 METAL5_2489600_1940500 METAL5_2488000_1940500 0.0064
R_VDD2_7906 METAL5_2488000_1940500 METAL5_2486900_1940500 0.0044
R_VDD2_7907 METAL5_2486900_1940500 METAL5_2484600_1940500 0.0092
R_VDD2_7908 METAL5_2484600_1940500 METAL5_2481000_1940500 0.0144
R_VDD2_7909 METAL5_2481000_1940500 METAL5_2480400_1940500 0.0024
R_VDD2_7910 METAL5_2480400_1940500 METAL5_2477600_1940500 0.0112
R_VDD2_7911 METAL5_2477600_1940500 METAL5_2476000_1940500 0.0064
R_VDD2_7912 METAL5_2476000_1940500 METAL5_2472600_1940500 0.0136
R_VDD2_7913 METAL5_2472600_1940500 METAL5_2470600_1940500 0.008
R_VDD2_7914 METAL5_2470600_1940500 METAL5_2469000_1940500 0.0064
R_VDD2_7915 METAL5_2469000_1940500 METAL5_2468400_1940500 0.0024
R_VDD2_7916 METAL5_2468400_1940500 METAL5_2465600_1940500 0.0112
R_VDD2_7917 METAL5_2465600_1940500 METAL5_2464000_1940500 0.0064
R_VDD2_7918 METAL5_2464000_1940500 METAL5_2464000_1950500 0.04
R_VDD2_7919 METAL5_2464000_1950500 METAL5_2464000_1951000 0.002
R_VDD2_7920 METAL5_2464000_1951000 METAL5_2464000_1952500 0.006
R_VDD2_7921 METAL5_2464000_1952500 METAL5_2464000_1962500 0.04
R_VDD2_7922 METAL5_2464000_1962500 METAL5_2464000_1963000 0.002
R_VDD2_7923 METAL5_2464000_1963000 METAL5_2464000_1964500 0.006
R_VDD2_7924 METAL5_2464000_1964500 METAL5_2464000_1974500 0.04
R_VDD2_7925 METAL5_2464000_1974500 METAL5_2464000_1975000 0.002
R_VDD2_7926 METAL5_2464000_1975000 METAL5_2464000_1976500 0.006
R_VDD2_7927 METAL5_2464000_1976500 METAL6_2464000_1976500 0.1
R_VDD2_7928 METAL6_2464000_1976500 METAL6_2464000_1987000 0.021
R_VDD2_7929 METAL6_2464000_1987000 METAL6_2464000_1988500 0.003
R_VDD2_7930 METAL6_2464000_1988500 METAL6_2464000_1999000 0.021
R_VDD2_7931 METAL6_2464000_1999000 METAL6_2464000_2014500 0.031
R_VDD2_7932 METAL6_2464000_2014500 METAL6_2464000_2026500 0.024
R_VDD2_7933 METAL6_2464000_2026500 METAL6_2464000_2038500 0.024
R_VDD2_7934 METAL6_2464000_2038500 METAL6_2464000_2114500 0.152
R_VDD2_7935 METAL6_2464000_2114500 METAL6_2464000_2126500 0.024
R_VDD2_7936 METAL6_2464000_2126500 METAL6_2464000_2138500 0.024
R_VDD2_7937 METAL6_2464000_2138500 METAL6_2464000_2147300 0.0176
R_VDD2_7938 METAL6_2464000_2147300 METAL6_2464000_2150500 0.0064
R_VDD2_7939 METAL6_2464000_2150500 METAL6_2464000_2154300 0.0076
R_VDD2_7940 METAL6_2464000_2154300 METAL6_2464000_2163000 0.0174
R_VDD2_7941 METAL6_2464000_2163000 METAL6_2464000_2166300 0.0066
R_VDD2_7942 METAL6_2464000_2166300 METAL6_2464000_2175000 0.0174
R_VDD2_7943 METAL6_2464000_2175000 METAL6_2464000_2178300 0.0066
R_VDD2_7944 METAL6_2464000_2178300 METAL6_2464000_2187000 0.0174
R_VDD2_7945 METAL6_2464000_2187000 METAL6_2464000_2190300 0.0066
R_VDD2_7946 METAL6_2464000_2190300 METAL6_2464000_2199000 0.0174
R_VDD2_7947 METAL6_2464000_2199000 METAL6_2464000_2202300 0.0066
R_VDD2_7948 METAL6_2464000_2202300 METAL6_2464000_2211000 0.0174
R_VDD2_7949 METAL6_2464000_2211000 METAL6_2464000_2222500 0.023
R_VDD2_7950 METAL6_2464000_2222500 METAL6_2464000_2234500 0.024
R_VDD2_7951 METAL6_2464000_2234500 METAL6_2464000_2246500 0.024
R_VDD2_7952 METAL6_2464000_2246500 METAL6_2464000_2256500 0.02
R_VDD2_7953 METAL6_2464000_2256500 METAL6_2465600_2256500 0.0032
R_VDD2_7954 METAL6_2465600_2256500 METAL6_2468400_2256500 0.0056
R_VDD2_7955 METAL6_2468400_2256500 METAL6_2469000_2256500 0.0012
R_VDD2_7956 METAL6_2469000_2256500 METAL5_2469000_2256500 0.1
R_VDD2_7957 METAL5_2469000_2256500 METAL5_2470600_2256500 0.0064
R_VDD2_7958 METAL5_2470600_2256500 METAL5_2470600_2258500 0.008
R_VDD2_7959 METAL5_2470600_2258500 METAL5_2470600_2268500 0.04
R_VDD2_7960 METAL5_2470600_2268500 METAL5_2470600_2270500 0.008
R_VDD2_7961 METAL5_2470600_2270500 METAL5_2470600_2276000 0.022
R_VDD2_7962 METAL5_2470600_2276000 METAL5_2470600_2280500 0.018
R_VDD2_7963 METAL5_2470600_2280500 METAL5_2470600_2282500 0.008
R_VDD2_7964 METAL5_2470600_2282500 METAL5_2470600_2288000 0.022
R_VDD2_7965 METAL5_2470600_2288000 METAL5_2470600_2292000 0.016
R_VDD2_7966 METAL5_2470600_2292000 METAL5_2470600_2300000 0.032
R_VDD2_7967 METAL5_2470600_2300000 METAL5_2470600_2304000 0.016
R_VDD2_7968 METAL5_2470600_2304000 METAL5_2470600_2305000 0.004
R_VDD2_7969 METAL5_2470600_2305000 METAL5_2470600_2312000 0.028
R_VDD2_7970 METAL5_2470600_2312000 METAL5_2470600_2314000 0.008
R_VDD2_7971 METAL5_2470600_2314000 METAL5_2470600_2316000 0.008
R_VDD2_7972 METAL5_2470600_2316000 METAL5_2470600_2317000 0.004
R_VDD2_7973 METAL5_2470600_2317000 METAL5_2470600_2324000 0.028
R_VDD2_7974 METAL5_2470600_2324000 METAL5_2470600_2326000 0.008
R_VDD2_7975 METAL5_2470600_2326000 METAL5_2470600_2328000 0.008
R_VDD2_7976 METAL5_2470600_2328000 METAL5_2470600_2329000 0.004
R_VDD2_7977 METAL5_2470600_2329000 METAL5_2470600_2336000 0.028
R_VDD2_7978 METAL5_2470600_2336000 METAL5_2470600_2338000 0.008
R_VDD2_7979 METAL5_2470600_2338000 METAL5_2470600_2340000 0.008
R_VDD2_7980 METAL5_2470600_2340000 METAL6_2470600_2340000 0.1
R_VDD2_7981 METAL6_2470600_2340000 METAL6_2472600_2340000 0.004
R_VDD2_7982 METAL6_2472600_2340000 METAL6_2476000_2340000 0.0068
R_VDD2_7983 METAL6_2476000_2340000 METAL6_2477600_2340000 0.0032
R_VDD2_7984 METAL6_2477600_2340000 METAL6_2480400_2340000 0.0056
R_VDD2_7985 METAL6_2480400_2340000 METAL6_2480400_2341000 0.002
R_VDD2_7986 METAL6_2480400_2341000 METAL6_2480400_2350000 0.018
R_VDD2_7987 METAL6_2480400_2350000 METAL6_2480400_2352000 0.004
R_VDD2_7988 METAL6_2480400_2352000 METAL6_2480400_2353000 0.002
R_VDD2_7989 METAL6_2480400_2353000 METAL6_2480400_2362000 0.018
R_VDD2_7990 METAL6_2480400_2362000 METAL6_2480400_2364000 0.004
R_VDD2_7991 METAL6_2480400_2364000 METAL6_2480400_2365000 0.002
R_VDD2_7992 METAL6_2480400_2365000 METAL6_2480400_2374000 0.018
R_VDD2_7993 METAL6_2480400_2374000 METAL6_2480400_2376000 0.004
R_VDD2_7994 METAL6_2480400_2376000 METAL6_2480400_2377000 0.002
R_VDD2_7995 METAL6_2480400_2377000 METAL6_2480400_2388000 0.022
R_VDD2_7996 METAL6_2480400_2388000 METAL6_2480400_2389000 0.002
R_VDD2_7997 METAL6_2480400_2389000 METAL6_2480400_2395000 0.012
R_VDD2_7998 METAL6_2480400_2395000 METAL6_2480400_2400000 0.01
R_VDD2_7999 METAL6_2480400_2400000 METAL6_2480400_2401000 0.002
R_VDD2_8000 METAL6_2480400_2401000 METAL6_2480400_2407000 0.012
R_VDD2_8001 METAL6_2480400_2407000 METAL6_2480400_2412000 0.01
R_VDD2_8002 METAL6_2480400_2412000 METAL6_2480400_2413000 0.002
R_VDD2_8003 METAL6_2480400_2413000 METAL6_2480400_2419000 0.012
R_VDD2_8004 METAL6_2480400_2419000 METAL6_2480400_2424000 0.01
R_VDD2_8005 METAL6_2480400_2424000 METAL6_2480400_2436000 0.024
R_VDD2_8006 METAL6_2480400_2436000 METAL6_2480400_2438000 0.004
R_VDD2_8007 METAL6_2480400_2438000 METAL6_2480400_2444000 0.012
R_VDD2_8008 METAL6_2480400_2444000 METAL6_2480400_2448000 0.008
R_VDD2_8009 METAL6_2480400_2448000 METAL6_2480400_2450000 0.004
R_VDD2_8010 METAL6_2480400_2450000 METAL6_2480400_2456000 0.012
R_VDD2_8011 METAL6_2480400_2456000 METAL6_2480400_2462000 0.012
R_VDD2_8012 METAL6_2480400_2462000 METAL6_2480400_2468000 0.012
R_VDD2_8013 METAL6_2480400_2468000 METAL6_2480400_2469000 0.002
R_VDD2_8014 METAL6_2480400_2469000 METAL6_2480400_2481000 0.024
R_VDD2_8015 METAL6_2480400_2481000 METAL6_2480400_2493000 0.024
R_VDD2_8016 METAL6_2480400_2493000 METAL6_2481000_2493000 0.0012
R_VDD2_8017 METAL6_2481000_2493000 METAL6_2484600_2493000 0.0072
R_VDD2_8018 METAL6_2484600_2493000 METAL6_2486900_2493000 0.0046
R_VDD2_8019 METAL6_2486900_2493000 METAL6_2488000_2493000 0.0022
R_VDD2_8020 METAL6_2488000_2493000 METAL6_2489600_2493000 0.0032
R_VDD2_8021 METAL6_2489600_2493000 METAL6_2492400_2493000 0.0056
R_VDD2_8022 METAL6_2492400_2493000 METAL6_2493000_2493000 0.0012
R_VDD2_8023 METAL6_2493000_2493000 METAL6_2496600_2493000 0.0072
R_VDD2_8024 METAL6_2496600_2493000 METAL6_2498900_2493000 0.0046
R_VDD2_8025 METAL6_2498900_2493000 METAL6_2500000_2493000 0.0022
R_VDD2_8026 METAL6_2500000_2493000 METAL6_2501600_2493000 0.0032
R_VDD2_8027 METAL6_2501600_2493000 METAL6_2504400_2493000 0.0056
R_VDD2_8028 METAL6_2504400_2493000 METAL6_2505000_2493000 0.0012
R_VDD2_8029 METAL6_2505000_2493000 METAL6_2510900_2493000 0.0118
R_VDD2_8030 METAL6_2510900_2493000 METAL6_2512000_2493000 0.0022
R_VDD2_8031 METAL6_2512000_2493000 METAL6_2513600_2493000 0.0032
R_VDD2_8032 METAL6_2513600_2493000 METAL6_2516400_2493000 0.0056
R_VDD2_8033 METAL6_2516400_2493000 METAL6_2517000_2493000 0.0012
R_VDD2_8034 METAL6_2517000_2493000 METAL6_2524000_2493000 0.014
R_VDD2_8035 METAL6_2524000_2493000 METAL6_2525600_2493000 0.0032
R_VDD2_8036 METAL6_2525600_2493000 METAL6_2528400_2493000 0.0056
R_VDD2_8037 METAL6_2528400_2493000 METAL6_2529000_2493000 0.0012
R_VDD2_8038 METAL6_2529000_2493000 METAL6_2535400_2493000 0.0128
R_VDD2_8039 METAL6_2535400_2493000 METAL6_2536000_2493000 0.0012
R_VDD2_8040 METAL6_2536000_2493000 METAL6_2537600_2493000 0.0032
R_VDD2_8041 METAL6_2537600_2493000 METAL6_2548000_2493000 0.0208
R_VDD2_8042 METAL6_2548000_2493000 METAL6_2551900_2493000 0.0078
R_VDD2_8043 METAL6_2551900_2493000 METAL6_2556400_2493000 0.009
R_VDD2_8044 METAL6_2556400_2493000 METAL6_2565900_2493000 0.019
R_VDD2_8045 METAL6_2565900_2493000 METAL6_2568400_2493000 0.005
R_VDD2_8046 METAL6_2568400_2493000 METAL6_2580400_2493000 0.024
R_VDD2_8047 METAL6_2580400_2493000 METAL6_2592400_2493000 0.024
R_VDD2_8048 METAL6_2592400_2493000 METAL6_2604400_2493000 0.024
R_VDD2_8049 METAL6_2604400_2493000 METAL6_2646600_2493000 0.0844
R_VDD2_8050 METAL6_2646600_2493000 METAL6_2652200_2493000 0.0112
R_VDD2_8051 METAL6_2652200_2493000 METAL6_2660600_2493000 0.0168
R_VDD2_8052 METAL6_2660600_2493000 METAL6_2664200_2493000 0.0072
R_VDD2_8053 METAL6_2664200_2493000 METAL6_2676200_2493000 0.024
R_VDD2_8054 METAL6_2676200_2493000 METAL6_2683200_2493000 0.014
R_VDD2_8055 METAL6_2683200_2493000 METAL6_2686900_2493000 0.0074
R_VDD2_8056 METAL6_2686900_2493000 METAL6_2698900_2493000 0.024
R_VDD2_8057 METAL6_2698900_2493000 METAL6_2710900_2493000 0.024
R_VDD2_8058 METAL6_2710900_2493000 METAL6_2728200_2493000 0.0346
R_VDD2_8059 METAL6_2728200_2493000 METAL6_2751900_2493000 0.0474
R_VDD2_8060 METAL6_2751900_2493000 METAL6_2765900_2493000 0.028
R_VDD2_8061 METAL6_2765900_2493000 METAL6_2769600_2493000 0.0074
R_VDD2_8062 METAL6_2769600_2493000 METAL6_2781600_2493000 0.024
R_VDD2_8063 METAL6_2781600_2493000 METAL6_2786800_2493000 0.0104
R_VDD2_8064 METAL6_2786800_2493000 METAL6_2788000_2493000 0.0024
R_VDD2_8065 METAL6_2788000_2493000 METAL6_2793600_2493000 0.0112
R_VDD2_8066 METAL6_2793600_2493000 METAL6_2798800_2493000 0.0104
R_VDD2_8067 METAL6_2798800_2493000 METAL6_2800000_2493000 0.0024
R_VDD2_8068 METAL6_2800000_2493000 METAL6_2805600_2493000 0.0112
R_VDD2_8069 METAL6_2805600_2493000 METAL6_2810800_2493000 0.0104
R_VDD2_8070 METAL6_2810800_2493000 METAL6_2812000_2493000 0.0024
R_VDD2_8071 METAL6_2812000_2493000 METAL6_2817600_2493000 0.0112
R_VDD2_8072 METAL6_2817600_2493000 METAL6_2843800_2493000 0.0524
R_VDD2_8073 METAL6_2843800_2493000 METAL6_2846600_2493000 0.0056
R_VDD2_8074 METAL6_2846600_2493000 METAL6_2850800_2493000 0.0084
R_VDD2_8075 METAL6_2850800_2493000 METAL6_2860600_2493000 0.0196
R_VDD2_8076 METAL6_2860600_2493000 METAL6_2862800_2493000 0.0044
R_VDD2_8077 METAL6_2862800_2493000 METAL6_2874800_2493000 0.024
R_VDD2_8078 METAL6_2874800_2493000 METAL6_2886900_2493000 0.0242
R_VDD2_8079 METAL6_2886900_2493000 METAL6_2897100_2493000 0.0204
R_VDD2_8080 METAL6_2897100_2493000 METAL6_2898900_2493000 0.0036
R_VDD2_8081 METAL6_2898900_2493000 METAL6_2901600_2493000 0.0054
R_VDD2_8082 METAL6_2901600_2493000 METAL6_2910900_2493000 0.0186
R_VDD2_8083 METAL6_2910900_2493000 METAL6_2913600_2493000 0.0054
R_VDD2_8084 METAL6_2913600_2493000 METAL6_2918200_2493000 0.0092
R_VDD2_8085 METAL6_2918200_2493000 METAL6_2925600_2493000 0.0148
R_VDD2_8086 METAL6_2925600_2493000 METAL6_2930200_2493000 0.0092
R_VDD2_8087 METAL6_2930200_2493000 METAL6_2942200_2493000 0.024
R_VDD2_8088 METAL6_2942200_2493000 METAL6_2951900_2493000 0.0194
R_VDD2_8089 METAL6_2951900_2493000 METAL6_2958200_2493000 0.0126
R_VDD2_8090 METAL6_2958200_2493000 METAL6_2963200_2493000 0.01
R_VDD2_8091 METAL6_2963200_2493000 METAL6_2965900_2493000 0.0054
R_VDD2_8092 METAL6_2965900_2493000 METAL6_2970200_2493000 0.0086
R_VDD2_8093 METAL6_2970200_2493000 METAL6_2975200_2493000 0.01
R_VDD2_8094 METAL6_2975200_2493000 METAL6_2982200_2493000 0.014
R_VDD2_8095 METAL6_2982200_2493000 METAL6_2987200_2493000 0.01
R_VDD2_8096 METAL6_2987200_2493000 METAL6_2988000_2493000 0.0016
R_VDD2_8097 METAL6_2988000_2493000 METAL6_2993000_2493000 0.01
R_VDD2_8098 METAL6_2993000_2493000 METAL6_2994200_2493000 0.0024
R_VDD2_8099 METAL6_2994200_2493000 METAL6_3000000_2493000 0.0116
R_VDD2_8100 METAL6_3000000_2493000 METAL6_3006200_2493000 0.0124
R_VDD2_8101 METAL6_3006200_2493000 METAL6_3011200_2493000 0.01
R_VDD2_8102 METAL6_3011200_2493000 METAL6_3012000_2493000 0.0016
R_VDD2_8103 METAL6_3012000_2493000 METAL6_3018200_2493000 0.0124
R_VDD2_8104 METAL6_3018200_2493000 METAL6_3023200_2493000 0.01
R_VDD2_8105 METAL6_3023200_2493000 METAL6_3024000_2493000 0.0016
R_VDD2_8106 METAL6_3024000_2493000 METAL6_3035200_2493000 0.0224
R_VDD2_8107 METAL6_3035200_2493000 METAL6_3052000_2493000 0.0336
R_VDD2_8108 METAL6_3052000_2493000 METAL6_3060600_2493000 0.0172
R_VDD2_8109 METAL6_3060600_2493000 METAL6_3063200_2493000 0.0052
R_VDD2_8110 METAL6_3063200_2493000 METAL6_3064000_2493000 0.0016
R_VDD2_8111 METAL6_3064000_2493000 METAL6_3068200_2493000 0.0084
R_VDD2_8112 METAL6_3068200_2493000 METAL6_3075200_2493000 0.014
R_VDD2_8113 METAL6_3075200_2493000 METAL6_3076000_2493000 0.0016
R_VDD2_8114 METAL6_3076000_2493000 METAL6_3086900_2493000 0.0218
R_VDD2_8115 METAL6_3086900_2493000 METAL6_3087200_2493000 0.0006
R_VDD2_8116 METAL6_3087200_2493000 METAL6_3088000_2493000 0.0016
R_VDD2_8117 METAL6_3088000_2493000 METAL6_3098900_2493000 0.0218
R_VDD2_8118 METAL6_3098900_2493000 METAL6_3099200_2493000 0.0006
R_VDD2_8119 METAL6_3099200_2493000 METAL6_3100000_2493000 0.0016
R_VDD2_8120 METAL6_3100000_2493000 METAL6_3110900_2493000 0.0218
R_VDD2_8121 METAL6_3110900_2493000 METAL6_3111200_2493000 0.0006
R_VDD2_8122 METAL6_3111200_2493000 METAL6_3112000_2493000 0.0016
R_VDD2_8123 METAL6_3112000_2493000 METAL6_3124000_2493000 0.024
R_VDD2_8124 METAL6_3124000_2493000 METAL6_3155500_2493000 0.063
R_VDD2_8125 METAL6_3155500_2493000 METAL6_3165900_2493000 0.0208
R_VDD2_8126 METAL6_3165900_2493000 METAL6_3167500_2493000 0.0032
R_VDD2_8127 METAL6_3167500_2493000 METAL6_3179500_2493000 0.024
R_VDD2_8128 METAL6_3179500_2493000 METAL6_3188000_2493000 0.017
R_VDD2_8129 METAL6_3188000_2493000 METAL6_3200000_2493000 0.024
R_VDD2_8130 METAL6_3200000_2493000 METAL6_3200500_2493000 0.001
R_VDD2_8131 METAL6_3200500_2493000 METAL6_3207500_2493000 0.014
R_VDD2_8132 METAL6_3207500_2493000 METAL6_3212000_2493000 0.009
R_VDD2_8133 METAL6_3212000_2493000 METAL6_3212500_2493000 0.001
R_VDD2_8134 METAL6_3212500_2493000 METAL6_3219500_2493000 0.014
R_VDD2_8135 METAL6_3219500_2493000 METAL6_3224500_2493000 0.01
R_VDD2_8136 METAL6_3224500_2493000 METAL6_3231500_2493000 0.014
R_VDD2_8137 METAL6_3231500_2493000 METAL6_3243500_2493000 0.024
R_VDD2_8138 METAL6_3243500_2493000 METAL6_3260400_2493000 0.0338
R_VDD2_8139 METAL6_3260400_2493000 METAL6_3263000_2493000 0.0052
R_VDD2_8140 METAL6_3263000_2493000 METAL6_3275000_2493000 0.024
R_VDD2_8141 METAL6_2505000_1952500 METAL6_2500000_1952500 0.01
R_VDD2_8142 METAL6_2500000_1952500 METAL6_2498900_1952500 0.0022
R_VDD2_8143 METAL6_2498900_1952500 METAL6_2493000_1952500 0.0118
R_VDD2_8144 METAL5_2464000_1962500 METAL5_2460600_1962500 0.0136
R_VDD2_8145 METAL5_2460600_1962500 METAL5_2458600_1962500 0.008
R_VDD2_8146 METAL5_2458600_1962500 METAL5_2457000_1962500 0.0064
R_VDD2_8147 METAL5_2457000_1962500 METAL5_2452000_1962500 0.02
R_VDD2_8148 METAL5_2452000_1962500 METAL5_2452000_1963000 0.002
R_VDD2_8149 METAL5_2452000_1963000 METAL5_2452000_1964500 0.006
R_VDD2_8150 METAL5_2452000_1964500 METAL5_2452000_1974500 0.04
R_VDD2_8151 METAL5_2452000_1974500 METAL5_2452000_1975000 0.002
R_VDD2_8152 METAL5_2452000_1975000 METAL5_2452000_1976500 0.006
R_VDD2_8153 METAL5_2452000_1976500 METAL5_2452000_1987000 0.042
R_VDD2_8154 METAL5_2452000_1987000 METAL5_2452000_1988500 0.006
R_VDD2_8155 METAL5_2452000_1988500 METAL5_2457000_1988500 0.02
R_VDD2_8156 METAL5_2457000_1988500 METAL5_2458600_1988500 0.0064
R_VDD2_8157 METAL5_2458600_1988500 METAL5_2460600_1988500 0.008
R_VDD2_8158 METAL5_2460600_1988500 METAL5_2464000_1988500 0.0136
R_VDD2_8159 METAL5_2464000_1988500 METAL5_2465600_1988500 0.0064
R_VDD2_8160 METAL5_2465600_1988500 METAL5_2468400_1988500 0.0112
R_VDD2_8161 METAL5_2468400_1988500 METAL5_2469000_1988500 0.0024
R_VDD2_8162 METAL5_2469000_1988500 METAL5_2470600_1988500 0.0064
R_VDD2_8163 METAL5_2470600_1988500 METAL5_2472600_1988500 0.008
R_VDD2_8164 METAL5_2472600_1988500 METAL5_2476000_1988500 0.0136
R_VDD2_8165 METAL5_2476000_1988500 METAL5_2477600_1988500 0.0064
R_VDD2_8166 METAL5_2477600_1988500 METAL5_2480400_1988500 0.0112
R_VDD2_8167 METAL5_2480400_1988500 METAL5_2481000_1988500 0.0024
R_VDD2_8168 METAL5_2481000_1988500 METAL5_2482600_1988500 0.0064
R_VDD2_8169 METAL5_2482600_1988500 METAL5_2484600_1988500 0.008
R_VDD2_8170 METAL5_2484600_1988500 METAL5_2486900_1988500 0.0092
R_VDD2_8171 METAL5_2486900_1988500 METAL5_2488000_1988500 0.0044
R_VDD2_8172 METAL5_2488000_1988500 METAL5_2489600_1988500 0.0064
R_VDD2_8173 METAL5_2489600_1988500 METAL5_2492400_1988500 0.0112
R_VDD2_8174 METAL5_2492400_1988500 METAL5_2492400_1987000 0.006
R_VDD2_8175 METAL5_2492400_1987000 METAL5_2492400_1976500 0.042
R_VDD2_8176 METAL5_2492400_1976500 METAL5_2492400_1975000 0.006
R_VDD2_8177 METAL5_2492400_1975000 METAL5_2493000_1975000 0.0024
R_VDD2_8178 METAL5_2493000_1975000 METAL5_2493000_1974500 0.002
R_VDD2_8179 METAL5_2493000_1974500 METAL5_2493000_1964500 0.04
R_VDD2_8180 METAL5_2493000_1964500 METAL5_2493000_1963000 0.006
R_VDD2_8181 METAL5_2493000_1963000 METAL5_2493000_1962500 0.002
R_VDD2_8182 METAL5_2493000_1962500 METAL5_2493000_1952500 0.04
R_VDD2_8183 METAL5_2493000_1952500 METAL6_2493000_1952500 0.1
R_VDD2_8184 METAL6_2505000_1449700 METAL6_2500000_1449700 0.01
R_VDD2_8185 METAL6_2500000_1449700 METAL6_2498900_1449700 0.0022
R_VDD2_8186 METAL6_2498900_1449700 METAL6_2493000_1449700 0.0118
R_VDD2_8187 METAL6_2436600_1374000 METAL5_2436600_1374000 0.1
R_VDD2_8188 METAL5_2436600_1374000 METAL5_2440000_1374000 0.0136
R_VDD2_8189 METAL5_2440000_1374000 METAL5_2446600_1374000 0.0264
R_VDD2_8190 METAL5_2446600_1374000 METAL5_2448600_1374000 0.008
R_VDD2_8191 METAL5_2448600_1374000 METAL5_2452000_1374000 0.0136
R_VDD2_8192 METAL5_2452000_1374000 METAL5_2457000_1374000 0.02
R_VDD2_8193 METAL5_2457000_1374000 METAL5_2458600_1374000 0.0064
R_VDD2_8194 METAL5_2458600_1374000 METAL5_2460600_1374000 0.008
R_VDD2_8195 METAL5_2460600_1374000 METAL5_2464000_1374000 0.0136
R_VDD2_8196 METAL5_2464000_1374000 METAL5_2465600_1374000 0.0064
R_VDD2_8197 METAL5_2465600_1374000 METAL5_2468400_1374000 0.0112
R_VDD2_8198 METAL5_2468400_1374000 METAL5_2469000_1374000 0.0024
R_VDD2_8199 METAL5_2469000_1374000 METAL5_2470600_1374000 0.0064
R_VDD2_8200 METAL5_2470600_1374000 METAL5_2472600_1374000 0.008
R_VDD2_8201 METAL5_2472600_1374000 METAL5_2476000_1374000 0.0136
R_VDD2_8202 METAL5_2476000_1374000 METAL5_2477600_1374000 0.0064
R_VDD2_8203 METAL5_2477600_1374000 METAL5_2480400_1374000 0.0112
R_VDD2_8204 METAL5_2480400_1374000 METAL5_2481000_1374000 0.0024
R_VDD2_8205 METAL5_2481000_1374000 METAL5_2482600_1374000 0.0064
R_VDD2_8206 METAL5_2482600_1374000 METAL5_2484600_1374000 0.008
R_VDD2_8207 METAL5_2484600_1374000 METAL5_2486900_1374000 0.0092
R_VDD2_8208 METAL5_2486900_1374000 METAL5_2488000_1374000 0.0044
R_VDD2_8209 METAL5_2488000_1374000 METAL5_2489600_1374000 0.0064
R_VDD2_8210 METAL5_2489600_1374000 METAL5_2492400_1374000 0.0112
R_VDD2_8211 METAL5_2492400_1374000 METAL5_2493000_1374000 0.0024
R_VDD2_8212 METAL5_2493000_1374000 METAL6_2493000_1374000 0.1
R_VDD2_8213 METAL6_2493000_1374000 METAL6_2493000_1381000 0.014
R_VDD2_8214 METAL6_2493000_1381000 METAL6_2493000_1386600 0.0112
R_VDD2_8215 METAL6_2493000_1386600 METAL6_2493000_1393000 0.0128
R_VDD2_8216 METAL6_2493000_1393000 METAL6_2493000_1405000 0.024
R_VDD2_8217 METAL6_2493000_1405000 METAL6_2493000_1417000 0.024
R_VDD2_8218 METAL6_2493000_1417000 METAL6_2493000_1437700 0.0414
R_VDD2_8219 METAL6_2493000_1437700 METAL6_2493000_1449700 0.024
I_VDD2_27 METAL6_2505000_1762500 gnd 0.002
I_VDD2_28 METAL6_995000_465000 gnd 0.002
I_VDD2_29 METAL6_3275000_2505000 gnd 0.004
I_VDD2_30 METAL6_2505000_1952500 gnd 0.004
I_VDD2_31 METAL6_2505000_1449700 gnd 0.004

V_VDD20_13 METAL5_3500000_700000 gnd 1.5
R_VDD20_8220 METAL5_3500000_700000 METAL5_3490500_700000 0.038
R_VDD20_8221 METAL5_3490500_700000 METAL6_3490500_700000 0.1
R_VDD20_8222 METAL6_3490500_700000 METAL6_3478500_700000 0.024
R_VDD20_8223 METAL6_3478500_700000 METAL6_3478500_702800 0.0056
R_VDD20_8224 METAL6_3478500_702800 METAL6_3478500_709800 0.014
R_VDD20_8225 METAL6_3478500_709800 METAL6_3478500_712000 0.0044
R_VDD20_8226 METAL6_3478500_712000 METAL6_3478500_716800 0.0096
R_VDD20_8227 METAL6_3478500_716800 METAL6_3478500_721800 0.01
R_VDD20_8228 METAL6_3478500_721800 METAL6_3478500_733800 0.024
R_VDD20_8229 METAL6_3478500_733800 METAL6_3478500_735400 0.0032
R_VDD20_8230 METAL6_3478500_735400 METAL6_3478500_742400 0.014
R_VDD20_8231 METAL6_3478500_742400 METAL6_3478500_745800 0.0068
R_VDD20_8232 METAL6_3478500_745800 METAL6_3478500_754400 0.0172
R_VDD20_8233 METAL6_3478500_754400 METAL6_3478500_758400 0.008
R_VDD20_8234 METAL6_3478500_758400 METAL6_3478500_763000 0.0092
R_VDD20_8235 METAL6_3478500_763000 METAL6_3478500_766400 0.0068
R_VDD20_8236 METAL6_3478500_766400 METAL6_3478500_770400 0.008
R_VDD20_8237 METAL6_3478500_770400 METAL6_3478500_772000 0.0032
R_VDD20_8238 METAL6_3478500_772000 METAL6_3478500_778400 0.0128
R_VDD20_8239 METAL6_3478500_778400 METAL6_3477000_778400 0.003
R_VDD20_8240 METAL6_3477000_778400 METAL6_3466500_778400 0.021
R_VDD20_8241 METAL6_3466500_778400 METAL6_3465000_778400 0.003
R_VDD20_8242 METAL6_3465000_778400 METAL6_3454500_778400 0.021
R_VDD20_8243 METAL6_3454500_778400 METAL6_3453000_778400 0.003
R_VDD20_8244 METAL6_3453000_778400 METAL6_3442500_778400 0.021
R_VDD20_8245 METAL6_3442500_778400 METAL6_3360400_778400 0.1642
R_VDD20_8246 METAL6_3360400_778400 METAL6_3348400_778400 0.024
R_VDD20_8247 METAL6_3348400_778400 METAL6_3336400_778400 0.024
R_VDD20_8248 METAL6_3336400_778400 METAL5_3336400_778400 0.1
R_VDD20_8249 METAL5_3336400_778400 METAL5_3324400_778400 0.048
R_VDD20_8250 METAL5_3324400_778400 METAL5_3312400_778400 0.048
R_VDD20_8251 METAL5_3312400_778400 METAL6_3312400_778400 0.1
R_VDD20_8252 METAL6_3312400_778400 METAL6_3312400_779200 0.0016
R_VDD20_8253 METAL6_3312400_779200 METAL6_3312400_782400 0.0064
R_VDD20_8254 METAL6_3312400_782400 METAL6_3312400_784500 0.0042
R_VDD20_8255 METAL6_3312400_784500 METAL6_3312400_788000 0.007
R_VDD20_8256 METAL6_3312400_788000 METAL6_3312400_790400 0.0048
R_VDD20_8257 METAL6_3312400_790400 METAL6_3312400_791200 0.0016
R_VDD20_8258 METAL6_3312400_791200 METAL6_3312400_794400 0.0064
R_VDD20_8259 METAL6_3312400_794400 METAL6_3312000_794400 0.0008
R_VDD20_8260 METAL6_3312000_794400 METAL6_3305400_794400 0.0132
R_VDD20_8261 METAL6_3305400_794400 METAL6_3300400_794400 0.01
R_VDD20_8262 METAL6_3300400_794400 METAL6_3300000_794400 0.0008
R_VDD20_8263 METAL6_3300000_794400 METAL6_3288400_794400 0.0232
R_VDD20_8264 METAL6_3288400_794400 METAL6_3288000_794400 0.0008
R_VDD20_8265 METAL6_3288000_794400 METAL6_3287000_794400 0.002
R_VDD20_8266 METAL6_3287000_794400 METAL6_3276400_794400 0.0212
R_VDD20_8267 METAL6_3276400_794400 METAL6_3275000_794400 0.0028
R_VDD20_8268 METAL6_3275000_794400 METAL6_3263000_794400 0.024
R_VDD20_8269 METAL6_3263000_794400 METAL6_3260400_794400 0.0052
R_VDD20_8270 METAL6_3260400_794400 METAL6_3243500_794400 0.0338
R_VDD20_8271 METAL6_3243500_794400 METAL6_3231500_794400 0.024
R_VDD20_8272 METAL6_3231500_794400 METAL6_3224500_794400 0.014
R_VDD20_8273 METAL6_3224500_794400 METAL6_3219500_794400 0.01
R_VDD20_8274 METAL6_3219500_794400 METAL6_3212500_794400 0.014
R_VDD20_8275 METAL6_3212500_794400 METAL6_3212000_794400 0.001
R_VDD20_8276 METAL6_3212000_794400 METAL6_3207500_794400 0.009
R_VDD20_8277 METAL6_3207500_794400 METAL6_3200500_794400 0.014
R_VDD20_8278 METAL6_3200500_794400 METAL6_3200000_794400 0.001
R_VDD20_8279 METAL6_3200000_794400 METAL6_3188000_794400 0.024
R_VDD20_8280 METAL6_3188000_794400 METAL6_3179500_794400 0.017
R_VDD20_8281 METAL6_3179500_794400 METAL6_3167500_794400 0.024
R_VDD20_8282 METAL6_3167500_794400 METAL6_3165900_794400 0.0032
R_VDD20_8283 METAL6_3165900_794400 METAL6_3155500_794400 0.0208
R_VDD20_8284 METAL6_3155500_794400 METAL6_3124000_794400 0.063
R_VDD20_8285 METAL6_3124000_794400 METAL6_3112000_794400 0.024
R_VDD20_8286 METAL6_3112000_794400 METAL6_3110900_794400 0.0022
R_VDD20_8287 METAL6_3110900_794400 METAL6_3100000_794400 0.0218
R_VDD20_8288 METAL6_3100000_794400 METAL6_3099200_794400 0.0016
R_VDD20_8289 METAL6_3099200_794400 METAL6_3099200_794800 0.0008
R_VDD20_8290 METAL6_3099200_794800 METAL6_3099200_800000 0.0104
R_VDD20_8291 METAL6_3099200_800000 METAL6_3099200_802400 0.0048
R_VDD20_8292 METAL6_3099200_802400 METAL6_3099200_803200 0.0016
R_VDD20_8293 METAL6_3099200_803200 METAL6_3099200_806400 0.0064
R_VDD20_8294 METAL6_3099200_806400 METAL6_3099200_808000 0.0032
R_VDD20_8295 METAL6_3099200_808000 METAL6_3099200_812000 0.008
R_VDD20_8296 METAL6_3099200_812000 METAL6_3099200_814400 0.0048
R_VDD20_8297 METAL6_3099200_814400 METAL6_3099200_818400 0.008
R_VDD20_8298 METAL6_3099200_818400 METAL6_3099200_820000 0.0032
R_VDD20_8299 METAL6_3099200_820000 METAL6_3098900_820000 0.0006
R_VDD20_8300 METAL6_3098900_820000 METAL6_3088000_820000 0.0218
R_VDD20_8301 METAL6_3088000_820000 METAL6_3087200_820000 0.0016
R_VDD20_8302 METAL6_3075200_820000 METAL6_3087200_820000 0.024
R_VDD20_8303 METAL6_940400_2026500 METAL6_928400_2026500 0.024
R_VDD20_8304 METAL6_3087200_820000 METAL6_3087200_830400 0.0208
R_VDD20_8305 METAL6_3087200_830400 METAL6_3087200_832000 0.0032
R_VDD20_8306 METAL6_3087200_832000 METAL6_3087200_839500 0.015
R_VDD20_8307 METAL6_3087200_839500 METAL6_3087200_840700 0.0024
R_VDD20_8308 METAL6_3087200_840700 METAL6_3087200_851500 0.0216
R_VDD20_8309 METAL6_3087200_851500 METAL6_3087200_858200 0.0134
R_VDD20_8310 METAL6_3087200_858200 METAL6_3087200_863500 0.0106
R_VDD20_8311 METAL6_3087200_863500 METAL6_3087200_887000 0.047
R_VDD20_8312 METAL6_3087200_887000 METAL6_3087200_888000 0.002
R_VDD20_8313 METAL6_3087200_888000 METAL6_3087200_900000 0.024
R_VDD20_8314 METAL6_3087200_900000 METAL6_3087200_900400 0.0008
R_VDD20_8315 METAL6_3087200_900400 METAL6_3087200_912000 0.0232
R_VDD20_8316 METAL6_3087200_912000 METAL6_3087200_927300 0.0306
R_VDD20_8317 METAL6_3087200_927300 METAL6_3087200_947000 0.0394
R_VDD20_8318 METAL6_3087200_947000 METAL6_3087200_959000 0.024
R_VDD20_8319 METAL6_3087200_959000 METAL6_3087200_971000 0.024
R_VDD20_8320 METAL6_3087200_971000 METAL6_3087200_976000 0.01
R_VDD20_8321 METAL6_3087200_976000 METAL6_3087200_988000 0.024
R_VDD20_8322 METAL6_3087200_988000 METAL6_3087200_995000 0.014
R_VDD20_8323 METAL6_3087200_995000 METAL6_3087200_1000000 0.01
R_VDD20_8324 METAL6_3087200_1000000 METAL6_3087200_1007000 0.014
R_VDD20_8325 METAL6_3087200_1007000 METAL6_3087200_1012000 0.01
R_VDD20_8326 METAL6_3087200_1012000 METAL6_3087200_1014000 0.004
R_VDD20_8327 METAL6_3087200_1014000 METAL6_3087200_1019000 0.01
R_VDD20_8328 METAL6_3087200_1019000 METAL6_3087200_1023700 0.0094
R_VDD20_8329 METAL6_3087200_1023700 METAL6_3087200_1025400 0.0034
R_VDD20_8330 METAL6_3087200_1025400 METAL6_3087200_1026000 0.0012
R_VDD20_8331 METAL6_3087200_1026000 METAL6_3087200_1029800 0.0076
R_VDD20_8332 METAL6_3087200_1029800 METAL6_3087200_1031000 0.0024
R_VDD20_8333 METAL6_3087200_1031000 METAL6_3087200_1035700 0.0094
R_VDD20_8334 METAL6_3087200_1035700 METAL6_3087200_1037400 0.0034
R_VDD20_8335 METAL6_3087200_1037400 METAL6_3087200_1038000 0.0012
R_VDD20_8336 METAL6_3087200_1038000 METAL6_3087200_1041800 0.0076
R_VDD20_8337 METAL6_3087200_1041800 METAL6_3087200_1042700 0.0018
R_VDD20_8338 METAL6_3087200_1042700 METAL6_3087200_1047700 0.01
R_VDD20_8339 METAL6_3087200_1047700 METAL6_3087200_1049400 0.0034
R_VDD20_8340 METAL6_3087200_1049400 METAL6_3087200_1049800 0.0008
R_VDD20_8341 METAL6_3087200_1049800 METAL6_3087200_1053800 0.008
R_VDD20_8342 METAL6_3087200_1053800 METAL6_3087200_1054700 0.0018
R_VDD20_8343 METAL6_3087200_1054700 METAL6_3087200_1061400 0.0134
R_VDD20_8344 METAL6_3087200_1061400 METAL6_3087200_1061800 0.0008
R_VDD20_8345 METAL6_3087200_1061800 METAL6_3087200_1066700 0.0098
R_VDD20_8346 METAL6_3087200_1066700 METAL6_3087200_1073800 0.0142
R_VDD20_8347 METAL6_3087200_1073800 METAL6_3087200_1086000 0.0244
R_VDD20_8348 METAL6_3087200_1086000 METAL6_3086900_1086000 0.0006
R_VDD20_8349 METAL6_3086900_1086000 METAL6_3076000_1086000 0.0218
R_VDD20_8350 METAL6_3076000_1086000 METAL6_3075200_1086000 0.0016
R_VDD20_8351 METAL6_3075200_1086000 METAL6_3068200_1086000 0.014
R_VDD20_8352 METAL6_3068200_1086000 METAL6_3064000_1086000 0.0084
R_VDD20_8353 METAL6_3064000_1086000 METAL6_3060600_1086000 0.0068
R_VDD20_8354 METAL6_3060600_1086000 METAL6_3052000_1086000 0.0172
R_VDD20_8355 METAL6_3052000_1086000 METAL6_3023200_1086000 0.0576
R_VDD20_8356 METAL6_3023200_1086000 METAL6_3012000_1086000 0.0224
R_VDD20_8357 METAL6_3012000_1086000 METAL6_3006200_1086000 0.0116
R_VDD20_8358 METAL6_3006200_1086000 METAL5_3006200_1086000 0.1
R_VDD20_8359 METAL5_3006200_1086000 METAL5_3000000_1086000 0.0248
R_VDD20_8360 METAL5_3000000_1086000 METAL5_2994200_1086000 0.0232
R_VDD20_8361 METAL5_2994200_1086000 METAL5_2993000_1086000 0.0048
R_VDD20_8362 METAL5_2993000_1086000 METAL5_2988000_1086000 0.02
R_VDD20_8363 METAL5_2988000_1086000 METAL5_2982200_1086000 0.0232
R_VDD20_8364 METAL5_2982200_1086000 METAL6_2982200_1086000 0.1
R_VDD20_8365 METAL6_2982200_1086000 METAL6_2975200_1086000 0.014
R_VDD20_8366 METAL6_2975200_1086000 METAL6_2965900_1086000 0.0186
R_VDD20_8367 METAL6_2965900_1086000 METAL6_2951900_1086000 0.028
R_VDD20_8368 METAL6_2951900_1086000 METAL6_2942200_1086000 0.0194
R_VDD20_8369 METAL6_2942200_1086000 METAL6_2930200_1086000 0.024
R_VDD20_8370 METAL6_2930200_1086000 METAL6_2925600_1086000 0.0092
R_VDD20_8371 METAL6_2925600_1086000 METAL6_2918200_1086000 0.0148
R_VDD20_8372 METAL6_2918200_1086000 METAL6_2913600_1086000 0.0092
R_VDD20_8373 METAL6_2913600_1086000 METAL6_2910900_1086000 0.0054
R_VDD20_8374 METAL6_2910900_1086000 METAL6_2901600_1086000 0.0186
R_VDD20_8375 METAL6_2901600_1086000 METAL6_2898900_1086000 0.0054
R_VDD20_8376 METAL6_2898900_1086000 METAL6_2897100_1086000 0.0036
R_VDD20_8377 METAL6_2897100_1086000 METAL6_2886900_1086000 0.0204
R_VDD20_8378 METAL6_2886900_1086000 METAL6_2874800_1086000 0.0242
R_VDD20_8379 METAL6_2874800_1086000 METAL6_2862800_1086000 0.024
R_VDD20_8380 METAL6_2862800_1086000 METAL6_2860600_1086000 0.0044
R_VDD20_8381 METAL6_2860600_1086000 METAL6_2850800_1086000 0.0196
R_VDD20_8382 METAL6_2850800_1086000 METAL6_2846600_1086000 0.0084
R_VDD20_8383 METAL6_2846600_1086000 METAL6_2843800_1086000 0.0056
R_VDD20_8384 METAL6_2843800_1086000 METAL6_2812000_1086000 0.0636
R_VDD20_8385 METAL6_2812000_1086000 METAL6_2805600_1086000 0.0128
R_VDD20_8386 METAL6_2805600_1086000 METAL6_2800000_1086000 0.0112
R_VDD20_8387 METAL6_2800000_1086000 METAL6_2798800_1086000 0.0024
R_VDD20_8388 METAL6_2798800_1086000 METAL6_2793600_1086000 0.0104
R_VDD20_8389 METAL6_2793600_1086000 METAL6_2788000_1086000 0.0112
R_VDD20_8390 METAL6_2788000_1086000 METAL6_2781600_1086000 0.0128
R_VDD20_8391 METAL6_2781600_1086000 METAL6_2765900_1086000 0.0314
R_VDD20_8392 METAL6_2765900_1086000 METAL6_2751900_1086000 0.028
R_VDD20_8393 METAL6_2751900_1086000 METAL6_2728200_1086000 0.0474
R_VDD20_8394 METAL6_2728200_1086000 METAL6_2710900_1086000 0.0346
R_VDD20_8395 METAL6_2710900_1086000 METAL6_2698900_1086000 0.024
R_VDD20_8396 METAL6_2698900_1086000 METAL6_2686900_1086000 0.024
R_VDD20_8397 METAL6_2686900_1086000 METAL6_2683200_1086000 0.0074
R_VDD20_8398 METAL6_2683200_1086000 METAL6_2676200_1086000 0.014
R_VDD20_8399 METAL6_2676200_1086000 METAL6_2664200_1086000 0.024
R_VDD20_8400 METAL6_2664200_1086000 METAL6_2660600_1086000 0.0072
R_VDD20_8401 METAL6_2660600_1086000 METAL6_2652200_1086000 0.0168
R_VDD20_8402 METAL6_2652200_1086000 METAL6_2646600_1086000 0.0112
R_VDD20_8403 METAL6_2646600_1086000 METAL6_2592400_1086000 0.1084
R_VDD20_8404 METAL6_2592400_1086000 METAL6_2592400_1086300 0.0006
R_VDD20_8405 METAL6_2592400_1086300 METAL6_2592400_1086500 0.0004
R_VDD20_8406 METAL6_2592400_1086500 METAL6_2592400_1088000 0.003
R_VDD20_8407 METAL6_2592400_1088000 METAL6_2592400_1096800 0.0176
R_VDD20_8408 METAL6_2592400_1096800 METAL6_2592400_1098300 0.003
R_VDD20_8409 METAL6_2592400_1098300 METAL6_2592400_1098500 0.0004
R_VDD20_8410 METAL6_2592400_1098500 METAL6_2592400_1100000 0.003
R_VDD20_8411 METAL6_2592400_1100000 METAL6_2592400_1108800 0.0176
R_VDD20_8412 METAL6_2592400_1108800 METAL6_2592400_1110300 0.003
R_VDD20_8413 METAL6_2592400_1110300 METAL6_2592400_1110500 0.0004
R_VDD20_8414 METAL6_2592400_1110500 METAL6_2580400_1110500 0.024
R_VDD20_8415 METAL6_2580400_1110500 METAL6_2568400_1110500 0.024
R_VDD20_8416 METAL6_2568400_1110500 METAL6_2565900_1110500 0.005
R_VDD20_8417 METAL6_2565900_1110500 METAL6_2556400_1110500 0.019
R_VDD20_8418 METAL6_2556400_1110500 METAL6_2551900_1110500 0.009
R_VDD20_8419 METAL6_2551900_1110500 METAL6_2537600_1110500 0.0286
R_VDD20_8420 METAL6_2537600_1110500 METAL6_2536000_1110500 0.0032
R_VDD20_8421 METAL6_2536000_1110500 METAL6_2536000_1112000 0.003
R_VDD20_8422 METAL6_2536000_1112000 METAL6_2536000_1120800 0.0176
R_VDD20_8423 METAL6_2536000_1120800 METAL6_2536000_1122300 0.003
R_VDD20_8424 METAL6_2536000_1122300 METAL6_2535400_1122300 0.0012
R_VDD20_8425 METAL6_2535400_1122300 METAL6_2529000_1122300 0.0128
R_VDD20_8426 METAL6_2529000_1122300 METAL6_2528400_1122300 0.0012
R_VDD20_8427 METAL6_2528400_1122300 METAL6_2525600_1122300 0.0056
R_VDD20_8428 METAL6_2525600_1122300 METAL6_2524000_1122300 0.0032
R_VDD20_8429 METAL6_2524000_1122300 METAL5_2524000_1122300 0.1
R_VDD20_8430 METAL5_2524000_1122300 METAL5_2517000_1122300 0.028
R_VDD20_8431 METAL5_2517000_1122300 METAL5_2516400_1122300 0.0024
R_VDD20_8432 METAL5_2516400_1122300 METAL5_2513600_1122300 0.0112
R_VDD20_8433 METAL5_2513600_1122300 METAL5_2512000_1122300 0.0064
R_VDD20_8434 METAL5_2512000_1122300 METAL5_2510900_1122300 0.0044
R_VDD20_8435 METAL5_2510900_1122300 METAL5_2505000_1122300 0.0236
R_VDD20_8436 METAL5_2505000_1122300 METAL5_2504400_1122300 0.0024
R_VDD20_8437 METAL5_2504400_1122300 METAL5_2501600_1122300 0.0112
R_VDD20_8438 METAL5_2501600_1122300 METAL5_2500000_1122300 0.0064
R_VDD20_8439 METAL5_2500000_1122300 METAL6_2500000_1122300 0.1
R_VDD20_8440 METAL6_2500000_1122300 METAL6_2498900_1122300 0.0022
R_VDD20_8441 METAL6_2498900_1122300 METAL6_2493000_1122300 0.0118
R_VDD20_8442 METAL6_2493000_1122300 METAL6_2489600_1122300 0.0068
R_VDD20_8443 METAL6_2489600_1122300 METAL6_2488000_1122300 0.0032
R_VDD20_8444 METAL6_2488000_1122300 METAL6_2486900_1122300 0.0022
R_VDD20_8445 METAL6_2486900_1122300 METAL6_2481000_1122300 0.0118
R_VDD20_8446 METAL6_2481000_1122300 METAL6_2477600_1122300 0.0068
R_VDD20_8447 METAL6_2477600_1122300 METAL6_2476000_1122300 0.0032
R_VDD20_8448 METAL6_2476000_1122300 METAL6_2472600_1122300 0.0068
R_VDD20_8449 METAL6_2472600_1122300 METAL6_2469000_1122300 0.0072
R_VDD20_8450 METAL6_2469000_1122300 METAL6_2465600_1122300 0.0068
R_VDD20_8451 METAL6_2465600_1122300 METAL6_2464000_1122300 0.0032
R_VDD20_8452 METAL6_2464000_1122300 METAL6_2460600_1122300 0.0068
R_VDD20_8453 METAL6_2460600_1122300 METAL6_2448600_1122300 0.024
R_VDD20_8454 METAL6_2448600_1122300 METAL6_2446600_1122300 0.004
R_VDD20_8455 METAL6_2446600_1122300 METAL6_2436600_1122300 0.02
R_VDD20_8456 METAL6_2436600_1122300 METAL6_2419100_1122300 0.035
R_VDD20_8457 METAL6_2419100_1122300 METAL6_2407100_1122300 0.024
R_VDD20_8458 METAL6_2407100_1122300 METAL6_2405600_1122300 0.003
R_VDD20_8459 METAL6_2405600_1122300 METAL6_2402100_1122300 0.007
R_VDD20_8460 METAL6_2402100_1122300 METAL6_2395100_1122300 0.014
R_VDD20_8461 METAL6_2395100_1122300 METAL6_2393600_1122300 0.003
R_VDD20_8462 METAL6_2393600_1122300 METAL6_2383100_1122300 0.021
R_VDD20_8463 METAL6_2383100_1122300 METAL6_2381600_1122300 0.003
R_VDD20_8464 METAL6_2381600_1122300 METAL6_2371100_1122300 0.021
R_VDD20_8465 METAL6_2371100_1122300 METAL6_2369600_1122300 0.003
R_VDD20_8466 METAL6_2369600_1122300 METAL6_2365900_1122300 0.0074
R_VDD20_8467 METAL6_2365900_1122300 METAL6_2357600_1122300 0.0166
R_VDD20_8468 METAL6_2357600_1122300 METAL6_2351900_1122300 0.0114
R_VDD20_8469 METAL6_2351900_1122300 METAL6_2343700_1122300 0.0164
R_VDD20_8470 METAL6_2343700_1122300 METAL6_2310900_1122300 0.0656
R_VDD20_8471 METAL6_2310900_1122300 METAL6_2308600_1122300 0.0046
R_VDD20_8472 METAL6_2308600_1122300 METAL6_2298900_1122300 0.0194
R_VDD20_8473 METAL6_2298900_1122300 METAL6_2296600_1122300 0.0046
R_VDD20_8474 METAL6_2296600_1122300 METAL6_2286900_1122300 0.0194
R_VDD20_8475 METAL6_2286900_1122300 METAL6_2284600_1122300 0.0046
R_VDD20_8476 METAL6_2284600_1122300 METAL5_2284600_1122300 0.1
R_VDD20_8477 METAL5_2284600_1122300 METAL5_2284400_1122300 0.0008
R_VDD20_8478 METAL5_2284400_1122300 METAL5_2272600_1122300 0.0472
R_VDD20_8479 METAL5_2272600_1122300 METAL5_2272400_1122300 0.0008
R_VDD20_8480 METAL5_2272400_1122300 METAL5_2260600_1122300 0.0472
R_VDD20_8481 METAL5_2260600_1122300 METAL5_2260400_1122300 0.0008
R_VDD20_8482 METAL5_2260400_1122300 METAL5_2258600_1122300 0.0072
R_VDD20_8483 METAL5_2258600_1122300 METAL5_2248700_1122300 0.0396
R_VDD20_8484 METAL5_2248700_1122300 METAL5_2248600_1122300 0.0004
R_VDD20_8485 METAL5_2248600_1122300 METAL5_2248400_1122300 0.0008
R_VDD20_8486 METAL5_2248400_1122300 METAL5_2246600_1122300 0.0072
R_VDD20_8487 METAL5_2246600_1122300 METAL5_2236700_1122300 0.0396
R_VDD20_8488 METAL5_2236700_1122300 METAL5_2236600_1122300 0.0004
R_VDD20_8489 METAL5_2236600_1122300 METAL5_2234600_1122300 0.008
R_VDD20_8490 METAL5_2234600_1122300 METAL5_2233900_1122300 0.0028
R_VDD20_8491 METAL5_2233900_1122300 METAL5_2224700_1122300 0.0368
R_VDD20_8492 METAL5_2224700_1122300 METAL5_2222600_1122300 0.0084
R_VDD20_8493 METAL5_2222600_1122300 METAL5_2221900_1122300 0.0028
R_VDD20_8494 METAL5_2221900_1122300 METAL5_2212700_1122300 0.0368
R_VDD20_8495 METAL5_2212700_1122300 METAL5_2210600_1122300 0.0084
R_VDD20_8496 METAL5_2210600_1122300 METAL5_2209900_1122300 0.0028
R_VDD20_8497 METAL5_2209900_1122300 METAL5_2200700_1122300 0.0368
R_VDD20_8498 METAL5_2200700_1122300 METAL6_2200700_1122300 0.1
R_VDD20_8499 METAL6_2200700_1122300 METAL6_2189900_1122300 0.0216
R_VDD20_8500 METAL6_2189900_1122300 METAL6_2188700_1122300 0.0024
R_VDD20_8501 METAL6_2188700_1122300 METAL6_2177900_1122300 0.0216
R_VDD20_8502 METAL6_2177900_1122300 METAL6_2176700_1122300 0.0024
R_VDD20_8503 METAL6_2176700_1122300 METAL6_2165900_1122300 0.0216
R_VDD20_8504 METAL6_2165900_1122300 METAL6_2165400_1122300 0.001
R_VDD20_8505 METAL6_2165400_1122300 METAL6_2153900_1122300 0.023
R_VDD20_8506 METAL6_2153900_1122300 METAL6_2153400_1122300 0.001
R_VDD20_8507 METAL6_2153400_1122300 METAL6_2151900_1122300 0.003
R_VDD20_8508 METAL6_2151900_1122300 METAL6_2141900_1122300 0.02
R_VDD20_8509 METAL6_2141900_1122300 METAL6_2141400_1122300 0.001
R_VDD20_8510 METAL6_2141400_1122300 METAL6_2129900_1122300 0.023
R_VDD20_8511 METAL6_2129900_1122300 METAL6_2129700_1122300 0.0004
R_VDD20_8512 METAL6_2129700_1122300 METAL6_2125600_1122300 0.0082
R_VDD20_8513 METAL6_2125600_1122300 METAL6_2121400_1122300 0.0084
R_VDD20_8514 METAL6_2121400_1122300 METAL6_2117900_1122300 0.007
R_VDD20_8515 METAL6_2117900_1122300 METAL6_2113900_1122300 0.008
R_VDD20_8516 METAL6_2113900_1122300 METAL6_2113600_1122300 0.0006
R_VDD20_8517 METAL6_2113600_1122300 METAL6_2105900_1122300 0.0154
R_VDD20_8518 METAL6_2105900_1122300 METAL6_2101900_1122300 0.008
R_VDD20_8519 METAL6_2101900_1122300 METAL6_2101600_1122300 0.0006
R_VDD20_8520 METAL6_2101600_1122300 METAL6_2089900_1122300 0.0234
R_VDD20_8521 METAL6_2089900_1122300 METAL6_2079700_1122300 0.0204
R_VDD20_8522 METAL6_2079700_1122300 METAL6_2077900_1122300 0.0036
R_VDD20_8523 METAL6_2077900_1122300 METAL6_2067700_1122300 0.0204
R_VDD20_8524 METAL6_2067700_1122300 METAL6_2060600_1122300 0.0142
R_VDD20_8525 METAL6_2060600_1122300 METAL6_2058800_1122300 0.0036
R_VDD20_8526 METAL6_2058800_1122300 METAL6_2055700_1122300 0.0062
R_VDD20_8527 METAL6_2055700_1122300 METAL6_2046800_1122300 0.0178
R_VDD20_8528 METAL6_2046800_1122300 METAL6_2046600_1122300 0.0004
R_VDD20_8529 METAL6_2046600_1122300 METAL6_2046400_1122300 0.0004
R_VDD20_8530 METAL6_2046400_1122300 METAL6_2043700_1122300 0.0054
R_VDD20_8531 METAL6_2043700_1122300 METAL6_2034800_1122300 0.0178
R_VDD20_8532 METAL6_2034800_1122300 METAL6_2031700_1122300 0.0062
R_VDD20_8533 METAL6_2031700_1122300 METAL6_2030900_1122300 0.0016
R_VDD20_8534 METAL6_2030900_1122300 METAL6_2026400_1122300 0.009
R_VDD20_8535 METAL6_2026400_1122300 METAL6_2021200_1122300 0.0104
R_VDD20_8536 METAL6_2021200_1122300 METAL6_2019700_1122300 0.003
R_VDD20_8537 METAL6_2019700_1122300 METAL6_2018900_1122300 0.0016
R_VDD20_8538 METAL6_2018900_1122300 METAL6_2014400_1122300 0.009
R_VDD20_8539 METAL6_2014400_1122300 METAL6_2012000_1122300 0.0048
R_VDD20_8540 METAL6_2012000_1122300 METAL6_2007700_1122300 0.0086
R_VDD20_8541 METAL6_2007700_1122300 METAL6_2006900_1122300 0.0016
R_VDD20_8542 METAL6_2006900_1122300 METAL6_2002400_1122300 0.009
R_VDD20_8543 METAL6_2002400_1122300 METAL6_2000000_1122300 0.0048
R_VDD20_8544 METAL6_2000000_1122300 METAL6_1988000_1122300 0.024
R_VDD20_8545 METAL6_1988000_1122300 METAL6_1951900_1122300 0.0722
R_VDD20_8546 METAL6_1951900_1122300 METAL6_1951900_1122500 0.0004
R_VDD20_8547 METAL6_1951900_1122500 METAL6_1951900_1129300 0.0136
R_VDD20_8548 METAL6_1951900_1129300 METAL6_1951900_1132800 0.007
R_VDD20_8549 METAL6_1951900_1132800 METAL6_1951900_1134300 0.003
R_VDD20_8550 METAL6_1951900_1134300 METAL6_1951900_1141300 0.014
R_VDD20_8551 METAL6_1951900_1141300 METAL6_1951900_1153300 0.024
R_VDD20_8552 METAL6_1951900_1153300 METAL6_1951900_1160600 0.0146
R_VDD20_8553 METAL6_1951900_1160600 METAL6_1951900_1169700 0.0182
R_VDD20_8554 METAL6_1951900_1169700 METAL6_1951900_1172600 0.0058
R_VDD20_8555 METAL6_1951900_1172600 METAL6_1951900_1181700 0.0182
R_VDD20_8556 METAL6_1951900_1181700 METAL6_1951800_1181700 0.0002
R_VDD20_8557 METAL6_1951800_1181700 METAL6_1939800_1181700 0.024
R_VDD20_8558 METAL6_1939800_1181700 METAL6_1931200_1181700 0.0172
R_VDD20_8559 METAL6_1931200_1181700 METAL6_1927800_1181700 0.0068
R_VDD20_8560 METAL6_1927800_1181700 METAL6_1926200_1181700 0.0032
R_VDD20_8561 METAL6_1926200_1181700 METAL6_1925600_1181700 0.0012
R_VDD20_8562 METAL6_1925600_1181700 METAL6_1919200_1181700 0.0128
R_VDD20_8563 METAL6_1919200_1181700 METAL5_1919200_1181700 0.1
R_VDD20_8564 METAL5_1919200_1181700 METAL5_1913600_1181700 0.0224
R_VDD20_8565 METAL5_1913600_1181700 METAL5_1907400_1181700 0.0248
R_VDD20_8566 METAL5_1907400_1181700 METAL5_1907200_1181700 0.0008
R_VDD20_8567 METAL5_1907200_1181700 METAL5_1901600_1181700 0.0224
R_VDD20_8568 METAL5_1901600_1181700 METAL5_1900700_1181700 0.0036
R_VDD20_8569 METAL5_1900700_1181700 METAL5_1895200_1181700 0.022
R_VDD20_8570 METAL5_1895200_1181700 METAL5_1889600_1181700 0.0224
R_VDD20_8571 METAL5_1889600_1181700 METAL5_1889400_1181700 0.0008
R_VDD20_8572 METAL5_1889400_1181700 METAL5_1888700_1181700 0.0028
R_VDD20_8573 METAL5_1888700_1181700 METAL5_1883200_1181700 0.022
R_VDD20_8574 METAL5_1883200_1181700 METAL5_1877600_1181700 0.0224
R_VDD20_8575 METAL5_1877600_1181700 METAL5_1877400_1181700 0.0008
R_VDD20_8576 METAL5_1877400_1181700 METAL5_1876700_1181700 0.0028
R_VDD20_8577 METAL5_1876700_1181700 METAL5_1874700_1181700 0.008
R_VDD20_8578 METAL5_1874700_1181700 METAL5_1871200_1181700 0.014
R_VDD20_8579 METAL5_1871200_1181700 METAL5_1870600_1181700 0.0024
R_VDD20_8580 METAL5_1870600_1181700 METAL5_1865600_1181700 0.02
R_VDD20_8581 METAL5_1865600_1181700 METAL5_1865400_1181700 0.0008
R_VDD20_8582 METAL5_1865400_1181700 METAL5_1864700_1181700 0.0028
R_VDD20_8583 METAL5_1864700_1181700 METAL5_1859200_1181700 0.022
R_VDD20_8584 METAL5_1859200_1181700 METAL5_1858600_1181700 0.0024
R_VDD20_8585 METAL5_1858600_1181700 METAL5_1858400_1181700 0.0008
R_VDD20_8586 METAL5_1858400_1181700 METAL5_1853400_1181700 0.02
R_VDD20_8587 METAL5_1853400_1181700 METAL5_1852700_1181700 0.0028
R_VDD20_8588 METAL5_1852700_1181700 METAL5_1847200_1181700 0.022
R_VDD20_8589 METAL5_1847200_1181700 METAL5_1846800_1181700 0.0016
R_VDD20_8590 METAL5_1846800_1181700 METAL5_1846600_1181700 0.0008
R_VDD20_8591 METAL5_1846600_1181700 METAL5_1846400_1181700 0.0008
R_VDD20_8592 METAL5_1846400_1181700 METAL5_1844800_1181700 0.0064
R_VDD20_8593 METAL5_1844800_1181700 METAL5_1841400_1181700 0.0136
R_VDD20_8594 METAL5_1841400_1181700 METAL5_1834600_1181700 0.0272
R_VDD20_8595 METAL5_1834600_1181700 METAL5_1834400_1181700 0.0008
R_VDD20_8596 METAL5_1834400_1181700 METAL6_1834400_1181700 0.1
R_VDD20_8597 METAL6_1834400_1181700 METAL6_1832800_1181700 0.0032
R_VDD20_8598 METAL6_1832800_1181700 METAL6_1822600_1181700 0.0204
R_VDD20_8599 METAL6_1822600_1181700 METAL6_1822400_1181700 0.0004
R_VDD20_8600 METAL6_1822400_1181700 METAL6_1820800_1181700 0.0032
R_VDD20_8601 METAL6_1820800_1181700 METAL6_1812000_1181700 0.0176
R_VDD20_8602 METAL6_1812000_1181700 METAL6_1800000_1181700 0.024
R_VDD20_8603 METAL6_1800000_1181700 METAL6_1788000_1181700 0.024
R_VDD20_8604 METAL6_1788000_1181700 METAL6_1755700_1181700 0.0646
R_VDD20_8605 METAL6_1755700_1181700 METAL6_1753800_1181700 0.0038
R_VDD20_8606 METAL6_1753800_1181700 METAL6_1751800_1181700 0.004
R_VDD20_8607 METAL6_1751800_1181700 METAL6_1751400_1181700 0.0008
R_VDD20_8608 METAL6_1751400_1181700 METAL6_1744000_1181700 0.0148
R_VDD20_8609 METAL6_1744000_1181700 METAL6_1743700_1181700 0.0006
R_VDD20_8610 METAL6_1743700_1181700 METAL6_1741800_1181700 0.0038
R_VDD20_8611 METAL6_1741800_1181700 METAL6_1739800_1181700 0.004
R_VDD20_8612 METAL6_1739800_1181700 METAL6_1731700_1181700 0.0162
R_VDD20_8613 METAL6_1731700_1181700 METAL6_1729800_1181700 0.0038
R_VDD20_8614 METAL6_1729800_1181700 METAL6_1727800_1181700 0.004
R_VDD20_8615 METAL6_1727800_1181700 METAL6_1719700_1181700 0.0162
R_VDD20_8616 METAL6_1719700_1181700 METAL6_1717800_1181700 0.0038
R_VDD20_8617 METAL6_1717800_1181700 METAL6_1710800_1181700 0.014
R_VDD20_8618 METAL6_1710800_1181700 METAL6_1707700_1181700 0.0062
R_VDD20_8619 METAL6_1707700_1181700 METAL6_1699000_1181700 0.0174
R_VDD20_8620 METAL6_1699000_1181700 METAL6_1692000_1181700 0.014
R_VDD20_8621 METAL6_1692000_1181700 METAL6_1680000_1181700 0.024
R_VDD20_8622 METAL6_1680000_1181700 METAL6_1670800_1181700 0.0184
R_VDD20_8623 METAL6_1670800_1181700 METAL6_1668000_1181700 0.0056
R_VDD20_8624 METAL6_1668000_1181700 METAL6_1658800_1181700 0.0184
R_VDD20_8625 METAL6_1658800_1181700 METAL6_1646800_1181700 0.024
R_VDD20_8626 METAL6_1646800_1181700 METAL6_1634800_1181700 0.024
R_VDD20_8627 METAL6_1634800_1181700 METAL6_1632800_1181700 0.004
R_VDD20_8628 METAL6_1632800_1181700 METAL6_1627800_1181700 0.01
R_VDD20_8629 METAL6_1627800_1181700 METAL6_1615800_1181700 0.024
R_VDD20_8630 METAL6_1615800_1181700 METAL6_1612700_1181700 0.0062
R_VDD20_8631 METAL6_1612700_1181700 METAL6_1612000_1181700 0.0014
R_VDD20_8632 METAL6_1612000_1181700 METAL6_1607900_1181700 0.0082
R_VDD20_8633 METAL6_1607900_1181700 METAL6_1603800_1181700 0.0082
R_VDD20_8634 METAL6_1603800_1181700 METAL6_1600700_1181700 0.0062
R_VDD20_8635 METAL6_1600700_1181700 METAL6_1600000_1181700 0.0014
R_VDD20_8636 METAL6_1600000_1181700 METAL6_1591800_1181700 0.0164
R_VDD20_8637 METAL6_1591800_1181700 METAL6_1588700_1181700 0.0062
R_VDD20_8638 METAL6_1588700_1181700 METAL6_1588000_1181700 0.0014
R_VDD20_8639 METAL6_1588000_1181700 METAL6_1579800_1181700 0.0164
R_VDD20_8640 METAL6_1579800_1181700 METAL6_1576700_1181700 0.0062
R_VDD20_8641 METAL6_1576700_1181700 METAL6_1576000_1181700 0.0014
R_VDD20_8642 METAL6_1576000_1181700 METAL6_1574700_1181700 0.0026
R_VDD20_8643 METAL6_1574700_1181700 METAL6_1557000_1181700 0.0354
R_VDD20_8644 METAL6_1557000_1181700 METAL6_1555400_1181700 0.0032
R_VDD20_8645 METAL6_1555400_1181700 METAL6_1551800_1181700 0.0072
R_VDD20_8646 METAL6_1551800_1181700 METAL6_1539800_1181700 0.024
R_VDD20_8647 METAL6_1539800_1181700 METAL6_1527800_1181700 0.024
R_VDD20_8648 METAL6_1527800_1181700 METAL6_1512000_1181700 0.0316
R_VDD20_8649 METAL6_1512000_1181700 METAL6_1510400_1181700 0.0032
R_VDD20_8650 METAL6_1510400_1181700 METAL6_1503400_1181700 0.014
R_VDD20_8651 METAL6_1503400_1181700 METAL6_1500000_1181700 0.0068
R_VDD20_8652 METAL6_1500000_1181700 METAL6_1498300_1181700 0.0034
R_VDD20_8653 METAL6_1498300_1181700 METAL6_1491400_1181700 0.0138
R_VDD20_8654 METAL6_1491400_1181700 METAL6_1488000_1181700 0.0068
R_VDD20_8655 METAL6_1488000_1181700 METAL6_1479400_1181700 0.0172
R_VDD20_8656 METAL6_1479400_1181700 METAL6_1443700_1181700 0.0714
R_VDD20_8657 METAL6_1443700_1181700 METAL6_1432800_1181700 0.0218
R_VDD20_8658 METAL6_1432800_1181700 METAL6_1431700_1181700 0.0022
R_VDD20_8659 METAL6_1431700_1181700 METAL6_1424000_1181700 0.0154
R_VDD20_8660 METAL6_1424000_1181700 METAL6_1419700_1181700 0.0086
R_VDD20_8661 METAL6_1419700_1181700 METAL6_1412000_1181700 0.0154
R_VDD20_8662 METAL6_1412000_1181700 METAL6_1400000_1181700 0.024
R_VDD20_8663 METAL6_1400000_1181700 METAL6_1388000_1181700 0.024
R_VDD20_8664 METAL6_1388000_1181700 METAL6_1337000_1181700 0.102
R_VDD20_8665 METAL6_1337000_1181700 METAL6_1325000_1181700 0.024
R_VDD20_8666 METAL6_1325000_1181700 METAL6_1324000_1181700 0.002
R_VDD20_8667 METAL6_1324000_1181700 METAL6_1323800_1181700 0.0004
R_VDD20_8668 METAL6_1323800_1181700 METAL6_1313000_1181700 0.0216
R_VDD20_8669 METAL6_1313000_1181700 METAL6_1312000_1181700 0.002
R_VDD20_8670 METAL6_1312000_1181700 METAL6_1311800_1181700 0.0004
R_VDD20_8671 METAL6_1311800_1181700 METAL6_1301000_1181700 0.0216
R_VDD20_8672 METAL6_1301000_1181700 METAL6_1300000_1181700 0.002
R_VDD20_8673 METAL6_1300000_1181700 METAL6_1299800_1181700 0.0004
R_VDD20_8674 METAL6_1299800_1181700 METAL6_1289000_1181700 0.0216
R_VDD20_8675 METAL6_1289000_1181700 METAL6_1288000_1181700 0.002
R_VDD20_8676 METAL6_1288000_1181700 METAL6_1287800_1181700 0.0004
R_VDD20_8677 METAL6_1287800_1181700 METAL6_1286700_1181700 0.0022
R_VDD20_8678 METAL6_1286700_1181700 METAL6_1274700_1181700 0.024
R_VDD20_8679 METAL6_1274700_1181700 METAL6_1266800_1181700 0.0158
R_VDD20_8680 METAL6_1266800_1181700 METAL6_1262700_1181700 0.0082
R_VDD20_8681 METAL6_1262700_1181700 METAL6_1259800_1181700 0.0058
R_VDD20_8682 METAL6_1259800_1181700 METAL6_1258300_1181700 0.003
R_VDD20_8683 METAL6_1258300_1181700 METAL6_1254700_1181700 0.0072
R_VDD20_8684 METAL6_1254700_1181700 METAL6_1253300_1181700 0.0028
R_VDD20_8685 METAL6_1253300_1181700 METAL6_1247800_1181700 0.011
R_VDD20_8686 METAL6_1247800_1181700 METAL6_1246300_1181700 0.003
R_VDD20_8687 METAL6_1246300_1181700 METAL6_1242700_1181700 0.0072
R_VDD20_8688 METAL6_1242700_1181700 METAL6_1235800_1181700 0.0138
R_VDD20_8689 METAL6_1235800_1181700 METAL6_1234300_1181700 0.003
R_VDD20_8690 METAL6_1234300_1181700 METAL6_1230700_1181700 0.0072
R_VDD20_8691 METAL6_1230700_1181700 METAL6_1230700_1184600 0.0058
R_VDD20_8692 METAL6_1230700_1184600 METAL6_1230700_1191600 0.014
R_VDD20_8693 METAL6_1230700_1191600 METAL6_1230700_1193700 0.0042
R_VDD20_8694 METAL6_1230700_1193700 METAL6_1230700_1193800 0.0002
R_VDD20_8695 METAL6_1230700_1193800 METAL6_1230700_1205700 0.0238
R_VDD20_8696 METAL6_1230700_1205700 METAL6_1230700_1217700 0.024
R_VDD20_8697 METAL6_1230700_1217700 METAL6_1230700_1223700 0.012
R_VDD20_8698 METAL6_1230700_1223700 METAL6_1230700_1229700 0.012
R_VDD20_8699 METAL6_1230700_1229700 METAL6_1230700_1235700 0.012
R_VDD20_8700 METAL6_1230700_1235700 METAL6_1230700_1238000 0.0046
R_VDD20_8701 METAL6_1230700_1238000 METAL6_1230700_1247700 0.0194
R_VDD20_8702 METAL6_1230700_1247700 METAL6_1230700_1250000 0.0046
R_VDD20_8703 METAL6_1230700_1250000 METAL6_1230700_1259700 0.0194
R_VDD20_8704 METAL6_1230700_1259700 METAL6_1230700_1262000 0.0046
R_VDD20_8705 METAL6_1230700_1262000 METAL6_1230700_1271700 0.0194
R_VDD20_8706 METAL6_1230700_1271700 METAL6_1230700_1273000 0.0026
R_VDD20_8707 METAL6_1230700_1273000 METAL5_1230700_1273000 0.1
R_VDD20_8708 METAL5_1230700_1273000 METAL5_1224000_1273000 0.0268
R_VDD20_8709 METAL5_1224000_1273000 METAL5_1223800_1273000 0.0008
R_VDD20_8710 METAL5_1223800_1273000 METAL5_1222300_1273000 0.006
R_VDD20_8711 METAL5_1222300_1273000 METAL5_1218700_1273000 0.0144
R_VDD20_8712 METAL5_1218700_1273000 METAL5_1216400_1273000 0.0092
R_VDD20_8713 METAL5_1216400_1273000 METAL5_1212000_1273000 0.0176
R_VDD20_8714 METAL5_1212000_1273000 METAL5_1211800_1273000 0.0008
R_VDD20_8715 METAL5_1211800_1273000 METAL5_1210300_1273000 0.006
R_VDD20_8716 METAL5_1210300_1273000 METAL5_1206700_1273000 0.0144
R_VDD20_8717 METAL5_1206700_1273000 METAL6_1206700_1273000 0.1
R_VDD20_8718 METAL6_1206700_1273000 METAL6_1206700_1283700 0.0214
R_VDD20_8719 METAL6_1206700_1283700 METAL6_1206700_1295700 0.024
R_VDD20_8720 METAL6_1206700_1295700 METAL6_1206700_1302000 0.0126
R_VDD20_8721 METAL6_1206700_1302000 METAL6_1206700_1307700 0.0114
R_VDD20_8722 METAL6_1206700_1307700 METAL6_1206700_1314000 0.0126
R_VDD20_8723 METAL6_1206700_1314000 METAL6_1206700_1326000 0.024
R_VDD20_8724 METAL6_1206700_1326000 METAL6_1206700_1338000 0.024
R_VDD20_8725 METAL6_1206700_1338000 METAL6_1204400_1338000 0.0046
R_VDD20_8726 METAL6_1204400_1338000 METAL6_1200000_1338000 0.0088
R_VDD20_8727 METAL6_1200000_1338000 METAL6_1198300_1338000 0.0034
R_VDD20_8728 METAL6_1198300_1338000 METAL6_1194700_1338000 0.0072
R_VDD20_8729 METAL6_1194700_1338000 METAL6_1192400_1338000 0.0046
R_VDD20_8730 METAL6_1192400_1338000 METAL6_1188000_1338000 0.0088
R_VDD20_8731 METAL6_1188000_1338000 METAL6_1186300_1338000 0.0034
R_VDD20_8732 METAL6_1186300_1338000 METAL6_1180400_1338000 0.0118
R_VDD20_8733 METAL6_1180400_1338000 METAL6_1173700_1338000 0.0134
R_VDD20_8734 METAL6_1173700_1338000 METAL6_1166700_1338000 0.014
R_VDD20_8735 METAL6_1166700_1338000 METAL6_1154700_1338000 0.024
R_VDD20_8736 METAL6_1154700_1338000 METAL6_1142700_1338000 0.024
R_VDD20_8737 METAL6_1142700_1338000 METAL6_1137000_1338000 0.0114
R_VDD20_8738 METAL6_1137000_1338000 METAL6_1130700_1338000 0.0126
R_VDD20_8739 METAL6_1130700_1338000 METAL6_1125000_1338000 0.0114
R_VDD20_8740 METAL6_1125000_1338000 METAL6_1113000_1338000 0.024
R_VDD20_8741 METAL6_1113000_1338000 METAL6_1019000_1338000 0.188
R_VDD20_8742 METAL6_1019000_1338000 METAL6_1007000_1338000 0.024
R_VDD20_8743 METAL6_1007000_1338000 METAL6_995000_1338000 0.024
R_VDD20_8744 METAL6_995000_1338000 METAL6_988000_1338000 0.014
R_VDD20_8745 METAL6_988000_1338000 METAL6_947400_1338000 0.0812
R_VDD20_8746 METAL6_947400_1338000 METAL6_940400_1338000 0.014
R_VDD20_8747 METAL6_940400_1338000 METAL6_928400_1338000 0.024
R_VDD20_8748 METAL6_928400_1338000 METAL6_916400_1338000 0.024
R_VDD20_8749 METAL6_916400_1338000 METAL6_904400_1338000 0.024
R_VDD20_8750 METAL6_904400_1338000 METAL6_892400_1338000 0.024
R_VDD20_8751 METAL6_892400_1338000 METAL5_892400_1338000 0.1
R_VDD20_8752 METAL5_892400_1338000 METAL5_892400_1350000 0.048
R_VDD20_8753 METAL5_892400_1350000 METAL5_892400_1357000 0.028
R_VDD20_8754 METAL5_892400_1357000 METAL5_892400_1362000 0.02
R_VDD20_8755 METAL5_892400_1362000 METAL6_892400_1362000 0.1
R_VDD20_8756 METAL6_892400_1362000 METAL6_892400_1369000 0.014
R_VDD20_8757 METAL6_892400_1369000 METAL6_892400_1374000 0.01
R_VDD20_8758 METAL6_892400_1374000 METAL6_892400_1381000 0.014
R_VDD20_8759 METAL6_892400_1381000 METAL6_892400_1386600 0.0112
R_VDD20_8760 METAL6_892400_1386600 METAL6_892400_1393000 0.0128
R_VDD20_8761 METAL6_892400_1393000 METAL6_892400_1405000 0.024
R_VDD20_8762 METAL6_892400_1405000 METAL6_892400_1437700 0.0654
R_VDD20_8763 METAL6_892400_1437700 METAL6_892400_1449700 0.024
R_VDD20_8764 METAL6_892400_1449700 METAL6_892400_1461700 0.024
R_VDD20_8765 METAL6_892400_1461700 METAL6_892400_1492300 0.0612
R_VDD20_8766 METAL6_892400_1492300 METAL6_892400_1504300 0.024
R_VDD20_8767 METAL6_892400_1504300 METAL6_892400_1516300 0.024
R_VDD20_8768 METAL6_892400_1516300 METAL6_892400_1528300 0.024
R_VDD20_8769 METAL6_892400_1528300 METAL6_892400_1540300 0.024
R_VDD20_8770 METAL6_892400_1540300 METAL6_892400_1552300 0.024
R_VDD20_8771 METAL6_892400_1552300 METAL6_892400_1554500 0.0044
R_VDD20_8772 METAL6_892400_1554500 METAL6_892400_1564300 0.0196
R_VDD20_8773 METAL6_892400_1564300 METAL6_892400_1571300 0.014
R_VDD20_8774 METAL6_892400_1571300 METAL6_892400_1576300 0.01
R_VDD20_8775 METAL6_892400_1576300 METAL6_892400_1714500 0.2764
R_VDD20_8776 METAL6_892400_1714500 METAL6_892400_1720500 0.012
R_VDD20_8777 METAL6_892400_1720500 METAL6_892400_1726500 0.012
R_VDD20_8778 METAL6_892400_1726500 METAL6_892400_1731700 0.0104
R_VDD20_8779 METAL6_892400_1731700 METAL6_892400_1738500 0.0136
R_VDD20_8780 METAL6_892400_1738500 METAL6_892400_1750500 0.024
R_VDD20_8781 METAL6_892400_1750500 METAL6_892400_1762500 0.024
R_VDD20_8782 METAL6_892400_1762500 METAL6_892400_1774500 0.024
R_VDD20_8783 METAL6_892400_1774500 METAL6_892400_1802500 0.056
R_VDD20_8784 METAL6_892400_1802500 METAL6_892400_1814500 0.024
R_VDD20_8785 METAL6_892400_1814500 METAL6_892400_1826500 0.024
R_VDD20_8786 METAL6_892400_1826500 METAL6_892400_1838500 0.024
R_VDD20_8787 METAL6_892400_1838500 METAL6_892400_1852300 0.0276
R_VDD20_8788 METAL6_892400_1852300 METAL6_892400_1866300 0.028
R_VDD20_8789 METAL6_892400_1866300 METAL6_892400_1902500 0.0724
R_VDD20_8790 METAL6_892400_1902500 METAL6_892400_1914500 0.024
R_VDD20_8791 METAL6_892400_1914500 METAL6_892400_1926500 0.024
R_VDD20_8792 METAL6_892400_1926500 METAL6_904400_1926500 0.024
R_VDD20_8793 METAL6_904400_1926500 METAL6_916400_1926500 0.024
R_VDD20_8794 METAL6_916400_1926500 METAL6_916400_1938500 0.024
R_VDD20_8795 METAL6_916400_1938500 METAL6_928400_1938500 0.024
R_VDD20_8796 METAL6_928400_1938500 METAL6_928400_1940500 0.004
R_VDD20_8797 METAL6_928400_1940500 METAL6_928400_1950500 0.02
R_VDD20_8798 METAL6_928400_1950500 METAL6_928400_1951000 0.001
R_VDD20_8799 METAL6_928400_1951000 METAL6_928400_1952500 0.003
R_VDD20_8800 METAL6_928400_1952500 METAL6_928400_1962500 0.02
R_VDD20_8801 METAL6_928400_1962500 METAL6_928400_1963000 0.001
R_VDD20_8802 METAL6_928400_1963000 METAL6_928400_1964500 0.003
R_VDD20_8803 METAL6_928400_1964500 METAL6_928400_1975000 0.021
R_VDD20_8804 METAL6_928400_1975000 METAL6_928400_1976500 0.003
R_VDD20_8805 METAL6_928400_1976500 METAL6_928400_1987000 0.021
R_VDD20_8806 METAL6_928400_1987000 METAL6_928400_2014500 0.055
R_VDD20_8807 METAL6_928400_2014500 METAL6_928400_2026500 0.024
R_VDD20_8808 METAL6_1246300_2813700 METAL6_1234300_2813700 0.024
R_VDD20_8809 METAL6_928400_2026500 METAL6_916400_2026500 0.024
R_VDD20_8810 METAL6_916400_2026500 METAL6_916400_2038500 0.024
R_VDD20_8811 METAL6_916400_2038500 METAL6_916400_2114500 0.152
R_VDD20_8812 METAL6_916400_2114500 METAL6_916400_2126500 0.024
R_VDD20_8813 METAL6_916400_2126500 METAL6_916400_2138500 0.024
R_VDD20_8814 METAL6_916400_2138500 METAL6_928400_2138500 0.024
R_VDD20_8815 METAL6_928400_2138500 METAL6_928400_2147300 0.0176
R_VDD20_8816 METAL6_928400_2147300 METAL6_928400_2154300 0.014
R_VDD20_8817 METAL6_928400_2154300 METAL6_928400_2163000 0.0174
R_VDD20_8818 METAL6_928400_2163000 METAL6_928400_2166300 0.0066
R_VDD20_8819 METAL6_928400_2166300 METAL6_928400_2175000 0.0174
R_VDD20_8820 METAL6_928400_2175000 METAL6_928400_2178300 0.0066
R_VDD20_8821 METAL6_928400_2178300 METAL6_928400_2187000 0.0174
R_VDD20_8822 METAL6_928400_2187000 METAL6_928400_2190300 0.0066
R_VDD20_8823 METAL6_928400_2190300 METAL6_928400_2202300 0.024
R_VDD20_8824 METAL6_928400_2202300 METAL6_928400_2222500 0.0404
R_VDD20_8825 METAL6_928400_2222500 METAL6_928400_2234500 0.024
R_VDD20_8826 METAL6_928400_2234500 METAL6_928400_2246500 0.024
R_VDD20_8827 METAL6_928400_2246500 METAL6_928400_2268500 0.044
R_VDD20_8828 METAL6_928400_2268500 METAL6_928400_2288000 0.039
R_VDD20_8829 METAL6_928400_2288000 METAL6_940400_2288000 0.024
R_VDD20_8830 METAL6_940400_2288000 METAL6_940400_2300000 0.024
R_VDD20_8831 METAL6_940400_2300000 METAL6_947400_2300000 0.014
R_VDD20_8832 METAL6_947400_2300000 METAL6_988000_2300000 0.0812
R_VDD20_8833 METAL6_988000_2300000 METAL6_995000_2300000 0.014
R_VDD20_8834 METAL6_995000_2300000 METAL6_1007000_2300000 0.024
R_VDD20_8835 METAL6_1007000_2300000 METAL6_1019000_2300000 0.024
R_VDD20_8836 METAL6_1019000_2300000 METAL6_1113000_2300000 0.188
R_VDD20_8837 METAL6_1113000_2300000 METAL6_1125000_2300000 0.024
R_VDD20_8838 METAL6_1125000_2300000 METAL6_1130700_2300000 0.0114
R_VDD20_8839 METAL6_1130700_2300000 METAL6_1137000_2300000 0.0126
R_VDD20_8840 METAL6_1137000_2300000 METAL6_1142700_2300000 0.0114
R_VDD20_8841 METAL6_1142700_2300000 METAL6_1154700_2300000 0.024
R_VDD20_8842 METAL6_1154700_2300000 METAL6_1166700_2300000 0.024
R_VDD20_8843 METAL6_1166700_2300000 METAL6_1173700_2300000 0.014
R_VDD20_8844 METAL6_1173700_2300000 METAL6_1180400_2300000 0.0134
R_VDD20_8845 METAL6_1180400_2300000 METAL6_1186300_2300000 0.0118
R_VDD20_8846 METAL6_1186300_2300000 METAL6_1186300_2304000 0.008
R_VDD20_8847 METAL6_1186300_2304000 METAL6_1186300_2305000 0.002
R_VDD20_8848 METAL6_1186300_2305000 METAL6_1186300_2312000 0.014
R_VDD20_8849 METAL6_1186300_2312000 METAL6_1186300_2314000 0.004
R_VDD20_8850 METAL6_1186300_2314000 METAL6_1186300_2316000 0.004
R_VDD20_8851 METAL6_1186300_2316000 METAL6_1186300_2317000 0.002
R_VDD20_8852 METAL6_1186300_2317000 METAL6_1186300_2326000 0.018
R_VDD20_8853 METAL6_1186300_2326000 METAL6_1186300_2328000 0.004
R_VDD20_8854 METAL6_1186300_2328000 METAL6_1186300_2329000 0.002
R_VDD20_8855 METAL6_1186300_2329000 METAL6_1186300_2338000 0.018
R_VDD20_8856 METAL6_1186300_2338000 METAL6_1186300_2340000 0.004
R_VDD20_8857 METAL6_1186300_2340000 METAL6_1186300_2341000 0.002
R_VDD20_8858 METAL6_1186300_2341000 METAL6_1186300_2350000 0.018
R_VDD20_8859 METAL6_1186300_2350000 METAL6_1186300_2352000 0.004
R_VDD20_8860 METAL6_1186300_2352000 METAL6_1186300_2353000 0.002
R_VDD20_8861 METAL6_1186300_2353000 METAL6_1186300_2362000 0.018
R_VDD20_8862 METAL6_1186300_2362000 METAL6_1186300_2364000 0.004
R_VDD20_8863 METAL6_1186300_2364000 METAL6_1186300_2365000 0.002
R_VDD20_8864 METAL6_1186300_2365000 METAL6_1186300_2374000 0.018
R_VDD20_8865 METAL6_1186300_2374000 METAL6_1186300_2376000 0.004
R_VDD20_8866 METAL6_1186300_2376000 METAL6_1186300_2377000 0.002
R_VDD20_8867 METAL6_1186300_2377000 METAL6_1186300_2388000 0.022
R_VDD20_8868 METAL6_1186300_2388000 METAL6_1186300_2389000 0.002
R_VDD20_8869 METAL6_1186300_2389000 METAL6_1186300_2395000 0.012
R_VDD20_8870 METAL6_1186300_2395000 METAL6_1186300_2400000 0.01
R_VDD20_8871 METAL6_1186300_2400000 METAL6_1186300_2401000 0.002
R_VDD20_8872 METAL6_1186300_2401000 METAL6_1186300_2407000 0.012
R_VDD20_8873 METAL6_1186300_2407000 METAL6_1186300_2412000 0.01
R_VDD20_8874 METAL6_1186300_2412000 METAL6_1186300_2413000 0.002
R_VDD20_8875 METAL6_1186300_2413000 METAL6_1186300_2419000 0.012
R_VDD20_8876 METAL6_1186300_2419000 METAL6_1186300_2424000 0.01
R_VDD20_8877 METAL6_1186300_2424000 METAL6_1186300_2436000 0.024
R_VDD20_8878 METAL6_1186300_2436000 METAL6_1186300_2438000 0.004
R_VDD20_8879 METAL6_1186300_2438000 METAL6_1186300_2444000 0.012
R_VDD20_8880 METAL6_1186300_2444000 METAL6_1186300_2450000 0.012
R_VDD20_8881 METAL6_1186300_2450000 METAL6_1186300_2456000 0.012
R_VDD20_8882 METAL6_1186300_2456000 METAL6_1186300_2462000 0.012
R_VDD20_8883 METAL6_1186300_2462000 METAL6_1186300_2468000 0.012
R_VDD20_8884 METAL6_1186300_2468000 METAL6_1186300_2481000 0.026
R_VDD20_8885 METAL6_1186300_2481000 METAL6_1186300_2493000 0.024
R_VDD20_8886 METAL6_1186300_2493000 METAL6_1186300_2505000 0.024
R_VDD20_8887 METAL6_1186300_2505000 METAL6_1186300_2512000 0.014
R_VDD20_8888 METAL6_1186300_2512000 METAL6_1186300_2517700 0.0114
R_VDD20_8889 METAL6_1186300_2517700 METAL6_1186300_2524000 0.0126
R_VDD20_8890 METAL6_1186300_2524000 METAL6_1186300_2529700 0.0114
R_VDD20_8891 METAL6_1186300_2529700 METAL6_1186300_2536000 0.0126
R_VDD20_8892 METAL6_1186300_2536000 METAL6_1186300_2541700 0.0114
R_VDD20_8893 METAL6_1186300_2541700 METAL6_1186300_2548000 0.0126
R_VDD20_8894 METAL6_1186300_2548000 METAL6_1186300_2553700 0.0114
R_VDD20_8895 METAL6_1186300_2553700 METAL6_1186300_2589000 0.0706
R_VDD20_8896 METAL6_1186300_2589000 METAL6_1186300_2603000 0.028
R_VDD20_8897 METAL6_1186300_2603000 METAL6_1186300_2644000 0.082
R_VDD20_8898 METAL6_1186300_2644000 METAL6_1186300_2656000 0.024
R_VDD20_8899 METAL6_1186300_2656000 METAL6_1186300_2665700 0.0194
R_VDD20_8900 METAL6_1186300_2665700 METAL6_1186300_2668000 0.0046
R_VDD20_8901 METAL6_1186300_2668000 METAL6_1186300_2701000 0.066
R_VDD20_8902 METAL6_1186300_2701000 METAL6_1186300_2701700 0.0014
R_VDD20_8903 METAL6_1186300_2701700 METAL6_1186300_2713000 0.0226
R_VDD20_8904 METAL6_1186300_2713000 METAL6_1186300_2713700 0.0014
R_VDD20_8905 METAL6_1186300_2713700 METAL6_1186300_2724000 0.0206
R_VDD20_8906 METAL6_1186300_2724000 METAL6_1186300_2725000 0.002
R_VDD20_8907 METAL6_1186300_2725000 METAL6_1186300_2725700 0.0014
R_VDD20_8908 METAL6_1186300_2725700 METAL5_1186300_2725700 0.1
R_VDD20_8909 METAL5_1186300_2725700 METAL5_1188000_2725700 0.0068
R_VDD20_8910 METAL5_1188000_2725700 METAL5_1192400_2725700 0.0176
R_VDD20_8911 METAL5_1192400_2725700 METAL5_1194700_2725700 0.0092
R_VDD20_8912 METAL5_1194700_2725700 METAL5_1198300_2725700 0.0144
R_VDD20_8913 METAL5_1198300_2725700 METAL5_1200000_2725700 0.0068
R_VDD20_8914 METAL5_1200000_2725700 METAL5_1204400_2725700 0.0176
R_VDD20_8915 METAL5_1204400_2725700 METAL5_1206700_2725700 0.0092
R_VDD20_8916 METAL5_1206700_2725700 METAL5_1210300_2725700 0.0144
R_VDD20_8917 METAL5_1210300_2725700 METAL5_1211800_2725700 0.006
R_VDD20_8918 METAL5_1211800_2725700 METAL5_1212000_2725700 0.0008
R_VDD20_8919 METAL5_1212000_2725700 METAL5_1216400_2725700 0.0176
R_VDD20_8920 METAL5_1216400_2725700 METAL5_1218700_2725700 0.0092
R_VDD20_8921 METAL5_1218700_2725700 METAL5_1222300_2725700 0.0144
R_VDD20_8922 METAL5_1222300_2725700 METAL5_1223800_2725700 0.006
R_VDD20_8923 METAL5_1223800_2725700 METAL5_1224000_2725700 0.0008
R_VDD20_8924 METAL5_1224000_2725700 METAL5_1230700_2725700 0.0268
R_VDD20_8925 METAL5_1230700_2725700 METAL5_1234300_2725700 0.0144
R_VDD20_8926 METAL5_1234300_2725700 METAL6_1234300_2725700 0.1
R_VDD20_8927 METAL6_1234300_2725700 METAL6_1234300_2736000 0.0206
R_VDD20_8928 METAL6_1234300_2736000 METAL6_1234300_2737000 0.002
R_VDD20_8929 METAL6_1234300_2737000 METAL6_1234300_2748000 0.022
R_VDD20_8930 METAL6_1234300_2748000 METAL6_1234300_2777000 0.058
R_VDD20_8931 METAL6_1234300_2777000 METAL6_1234300_2789000 0.024
R_VDD20_8932 METAL6_1234300_2789000 METAL6_1234300_2801000 0.024
R_VDD20_8933 METAL6_1234300_2801000 METAL6_1234300_2801700 0.0014
R_VDD20_8934 METAL6_1234300_2801700 METAL6_1234300_2803000 0.0026
R_VDD20_8935 METAL6_1234300_2803000 METAL6_1234300_2808000 0.01
R_VDD20_8936 METAL6_1234300_2808000 METAL6_1234300_2813700 0.0114
I_VDD20_32 METAL6_3075200_820000 gnd 0.001
I_VDD20_33 METAL6_940400_2026500 gnd 0.0016
I_VDD20_34 METAL6_1246300_2813700 gnd 0.0022

V_VDD21_14 METAL5_3500000_800000 gnd 1
R_VDD21_8937 METAL5_3500000_800000 METAL5_3490500_800000 0.038
R_VDD21_8938 METAL5_3490500_800000 METAL6_3490500_800000 0.1
R_VDD21_8939 METAL6_3490500_800000 METAL6_3478500_800000 0.024
R_VDD21_8940 METAL6_3478500_800000 METAL6_3478500_794800 0.0104
R_VDD21_8941 METAL6_3478500_794800 METAL6_3477000_794800 0.003
R_VDD21_8942 METAL6_3477000_794800 METAL6_3466500_794800 0.021
R_VDD21_8943 METAL6_3466500_794800 METAL6_3465000_794800 0.003
R_VDD21_8944 METAL6_3465000_794800 METAL6_3454500_794800 0.021
R_VDD21_8945 METAL6_3454500_794800 METAL6_3453000_794800 0.003
R_VDD21_8946 METAL6_3453000_794800 METAL6_3442500_794800 0.021
R_VDD21_8947 METAL6_3442500_794800 METAL6_3372400_794800 0.1402
R_VDD21_8948 METAL6_3372400_794800 METAL6_3360400_794800 0.024
R_VDD21_8949 METAL6_3360400_794800 METAL6_3348400_794800 0.024
R_VDD21_8950 METAL6_3348400_794800 METAL6_3336400_794800 0.024
R_VDD21_8951 METAL6_3336400_794800 METAL6_3336400_794400 0.0008
R_VDD21_8952 METAL6_3336400_794400 METAL6_3336400_791200 0.0064
R_VDD21_8953 METAL6_3336400_791200 METAL6_3336400_790400 0.0016
R_VDD21_8954 METAL6_3336400_790400 METAL5_3336400_790400 0.1
R_VDD21_8955 METAL5_3336400_790400 METAL5_3324400_790400 0.048
R_VDD21_8956 METAL5_3324400_790400 METAL5_3312400_790400 0.048
R_VDD21_8957 METAL5_3312400_790400 METAL5_3312000_790400 0.0016
R_VDD21_8958 METAL5_3312000_790400 METAL5_3305400_790400 0.0264
R_VDD21_8959 METAL5_3305400_790400 METAL5_3300400_790400 0.02
R_VDD21_8960 METAL5_3300400_790400 METAL5_3300400_788000 0.0096
R_VDD21_8961 METAL5_3300400_788000 METAL5_3300400_784500 0.014
R_VDD21_8962 METAL5_3300400_784500 METAL5_3300400_784000 0.002
R_VDD21_8963 METAL5_3300400_784000 METAL5_3300400_782400 0.0064
R_VDD21_8964 METAL5_3300400_782400 METAL5_3300400_781800 0.0024
R_VDD21_8965 METAL5_3300400_781800 METAL5_3300400_779200 0.0104
R_VDD21_8966 METAL5_3300400_779200 METAL5_3300400_778400 0.0032
R_VDD21_8967 METAL5_3300400_778400 METAL5_3300400_772000 0.0256
R_VDD21_8968 METAL5_3300400_772000 METAL5_3300400_770400 0.0064
R_VDD21_8969 METAL5_3300400_770400 METAL5_3300000_770400 0.0016
R_VDD21_8970 METAL5_3300000_770400 METAL5_3299000_770400 0.004
R_VDD21_8971 METAL5_3299000_770400 METAL5_3288400_770400 0.0424
R_VDD21_8972 METAL5_3288400_770400 METAL5_3288000_770400 0.0016
R_VDD21_8973 METAL5_3288000_770400 METAL5_3287000_770400 0.004
R_VDD21_8974 METAL5_3287000_770400 METAL5_3276400_770400 0.0424
R_VDD21_8975 METAL5_3276400_770400 METAL5_3275000_770400 0.0056
R_VDD21_8976 METAL5_3275000_770400 METAL5_3263000_770400 0.048
R_VDD21_8977 METAL5_3263000_770400 METAL5_3260400_770400 0.0104
R_VDD21_8978 METAL5_3260400_770400 METAL5_3243500_770400 0.0676
R_VDD21_8979 METAL5_3243500_770400 METAL5_3231500_770400 0.048
R_VDD21_8980 METAL5_3231500_770400 METAL5_3224500_770400 0.028
R_VDD21_8981 METAL5_3224500_770400 METAL5_3219500_770400 0.02
R_VDD21_8982 METAL5_3219500_770400 METAL6_3219500_770400 0.1
R_VDD21_8983 METAL6_3219500_770400 METAL6_3212500_770400 0.014
R_VDD21_8984 METAL6_3212500_770400 METAL6_3212500_769800 0.0012
R_VDD21_8985 METAL6_3212500_769800 METAL6_3212500_766400 0.0068
R_VDD21_8986 METAL6_3212500_766400 METAL6_3212500_763000 0.0068
R_VDD21_8987 METAL6_3212500_763000 METAL6_3212500_760000 0.006
R_VDD21_8988 METAL6_3212500_760000 METAL6_3212500_758400 0.0032
R_VDD21_8989 METAL6_3212500_758400 METAL6_3212500_757800 0.0012
R_VDD21_8990 METAL6_3212500_757800 METAL6_3212500_754400 0.0068
R_VDD21_8991 METAL6_3212500_754400 METAL6_3212500_746400 0.016
R_VDD21_8992 METAL6_3212500_746400 METAL6_3212500_745800 0.0012
R_VDD21_8993 METAL6_3212500_745800 METAL6_3212500_742400 0.0068
R_VDD21_8994 METAL6_3212500_742400 METAL6_3212500_735400 0.014
R_VDD21_8995 METAL6_3212500_735400 METAL6_3212500_734400 0.002
R_VDD21_8996 METAL6_3212500_734400 METAL6_3212500_733800 0.0012
R_VDD21_8997 METAL6_3212500_733800 METAL6_3212500_722400 0.0228
R_VDD21_8998 METAL6_3212500_722400 METAL6_3212500_721800 0.0012
R_VDD21_8999 METAL6_3212500_721800 METAL6_3212500_716800 0.01
R_VDD21_9000 METAL6_3212500_716800 METAL6_3212000_716800 0.001
R_VDD21_9001 METAL6_3212000_716800 METAL6_3207500_716800 0.009
R_VDD21_9002 METAL6_3207500_716800 METAL6_3200500_716800 0.014
R_VDD21_9003 METAL6_3200500_716800 METAL6_3200000_716800 0.001
R_VDD21_9004 METAL6_3200000_716800 METAL6_3188000_716800 0.024
R_VDD21_9005 METAL6_3188000_716800 METAL6_3179500_716800 0.017
R_VDD21_9006 METAL6_3179500_716800 METAL6_3167500_716800 0.024
R_VDD21_9007 METAL6_3167500_716800 METAL6_3167500_712000 0.0096
R_VDD21_9008 METAL6_3167500_712000 METAL6_3167500_709800 0.0044
R_VDD21_9009 METAL6_3167500_709800 METAL6_3167500_702800 0.014
R_VDD21_9010 METAL6_3167500_702800 METAL6_3167500_700000 0.0056
R_VDD21_9011 METAL6_3167500_700000 METAL6_3167500_697800 0.0044
R_VDD21_9012 METAL6_3167500_697800 METAL6_3167500_688000 0.0196
R_VDD21_9013 METAL6_3167500_688000 METAL6_3167500_685800 0.0044
R_VDD21_9014 METAL6_3167500_685800 METAL6_3167500_665400 0.0408
R_VDD21_9015 METAL6_3167500_665400 METAL6_3167500_661800 0.0072
R_VDD21_9016 METAL6_3167500_661800 METAL6_3167500_653400 0.0168
R_VDD21_9017 METAL6_3167500_653400 METAL6_3167500_649800 0.0072
R_VDD21_9018 METAL6_3167500_649800 METAL6_3167500_641400 0.0168
R_VDD21_9019 METAL6_3167500_641400 METAL6_3167500_637800 0.0072
R_VDD21_9020 METAL6_3167500_637800 METAL6_3167500_629400 0.0168
R_VDD21_9021 METAL6_3167500_629400 METAL6_3167500_617400 0.024
R_VDD21_9022 METAL6_3167500_617400 METAL6_3167500_612000 0.0108
R_VDD21_9023 METAL6_3167500_612000 METAL6_3167500_605400 0.0132
R_VDD21_9024 METAL6_3167500_605400 METAL6_3167500_600000 0.0108
R_VDD21_9025 METAL6_3167500_600000 METAL6_3165900_600000 0.0032
R_VDD21_9026 METAL6_3165900_600000 METAL6_3155500_600000 0.0208
R_VDD21_9027 METAL6_3155500_600000 METAL6_3124000_600000 0.063
R_VDD21_9028 METAL6_3124000_600000 METAL6_3112000_600000 0.024
R_VDD21_9029 METAL6_3112000_600000 METAL6_3112000_598400 0.0032
R_VDD21_9030 METAL6_3112000_598400 METAL6_3112000_597000 0.0028
R_VDD21_9031 METAL6_3112000_597000 METAL6_3112000_588000 0.018
R_VDD21_9032 METAL6_3112000_588000 METAL6_3112000_586400 0.0032
R_VDD21_9033 METAL6_3112000_586400 METAL6_3112000_585000 0.0028
R_VDD21_9034 METAL6_3112000_585000 METAL6_3112000_579800 0.0104
R_VDD21_9035 METAL6_3112000_579800 METAL6_3112000_574400 0.0108
R_VDD21_9036 METAL6_3112000_574400 METAL6_3112000_573000 0.0028
R_VDD21_9037 METAL6_3112000_573000 METAL6_3112000_571400 0.0032
R_VDD21_9038 METAL6_3112000_571400 METAL6_3112000_562400 0.018
R_VDD21_9039 METAL6_3112000_562400 METAL6_3112000_561000 0.0028
R_VDD21_9040 METAL6_3112000_561000 METAL6_3112000_559400 0.0032
R_VDD21_9041 METAL6_3112000_559400 METAL6_3112000_556200 0.0064
R_VDD21_9042 METAL6_3112000_556200 METAL6_3111200_556200 0.0016
R_VDD21_9043 METAL6_3111200_556200 METAL6_3110900_556200 0.0006
R_VDD21_9044 METAL6_3110900_556200 METAL6_3100000_556200 0.0218
R_VDD21_9045 METAL6_3100000_556200 METAL6_3099200_556200 0.0016
R_VDD21_9046 METAL6_3099200_556200 METAL6_3098900_556200 0.0006
R_VDD21_9047 METAL6_3098900_556200 METAL6_3088000_556200 0.0218
R_VDD21_9048 METAL6_3088000_556200 METAL6_3087200_556200 0.0016
R_VDD21_9049 METAL6_3087200_556200 METAL6_3086900_556200 0.0006
R_VDD21_9050 METAL6_3086900_556200 METAL6_3076000_556200 0.0218
R_VDD21_9051 METAL6_3076000_556200 METAL6_3075200_556200 0.0016
R_VDD21_9052 METAL6_3075200_556200 METAL6_3068200_556200 0.014
R_VDD21_9053 METAL6_3068200_556200 METAL6_3064000_556200 0.0084
R_VDD21_9054 METAL6_3064000_556200 METAL6_3063200_556200 0.0016
R_VDD21_9055 METAL6_3063200_556200 METAL6_3060600_556200 0.0052
R_VDD21_9056 METAL6_3060600_556200 METAL6_3052000_556200 0.0172
R_VDD21_9057 METAL6_3052000_556200 METAL6_3035200_556200 0.0336
R_VDD21_9058 METAL6_3035200_556200 METAL6_3024000_556200 0.0224
R_VDD21_9059 METAL6_3024000_556200 METAL6_3023200_556200 0.0016
R_VDD21_9060 METAL6_3023200_556200 METAL6_3018200_556200 0.01
R_VDD21_9061 METAL6_3018200_556200 METAL6_3012000_556200 0.0124
R_VDD21_9062 METAL6_3012000_556200 METAL6_3011200_556200 0.0016
R_VDD21_9063 METAL6_3011200_556200 METAL6_3006200_556200 0.01
R_VDD21_9064 METAL6_3006200_556200 METAL6_3000000_556200 0.0124
R_VDD21_9065 METAL6_3000000_556200 METAL6_2994200_556200 0.0116
R_VDD21_9066 METAL6_2994200_556200 METAL6_2993000_556200 0.0024
R_VDD21_9067 METAL6_2993000_556200 METAL6_2988000_556200 0.01
R_VDD21_9068 METAL6_2988000_556200 METAL6_2987200_556200 0.0016
R_VDD21_9069 METAL6_2987200_556200 METAL6_2982200_556200 0.01
R_VDD21_9070 METAL6_2982200_556200 METAL6_2975200_556200 0.014
R_VDD21_9071 METAL6_2975200_556200 METAL6_2970200_556200 0.01
R_VDD21_9072 METAL6_2970200_556200 METAL6_2965900_556200 0.0086
R_VDD21_9073 METAL6_2965900_556200 METAL6_2963200_556200 0.0054
R_VDD21_9074 METAL6_2963200_556200 METAL6_2958200_556200 0.01
R_VDD21_9075 METAL6_2958200_556200 METAL6_2951900_556200 0.0126
R_VDD21_9076 METAL6_2951900_556200 METAL6_2942200_556200 0.0194
R_VDD21_9077 METAL6_2942200_556200 METAL6_2930200_556200 0.024
R_VDD21_9078 METAL6_2930200_556200 METAL6_2925600_556200 0.0092
R_VDD21_9079 METAL6_2925600_556200 METAL6_2918200_556200 0.0148
R_VDD21_9080 METAL6_2918200_556200 METAL6_2913600_556200 0.0092
R_VDD21_9081 METAL6_2913600_556200 METAL6_2910900_556200 0.0054
R_VDD21_9082 METAL6_2910900_556200 METAL6_2901600_556200 0.0186
R_VDD21_9083 METAL6_2901600_556200 METAL6_2898900_556200 0.0054
R_VDD21_9084 METAL6_2898900_556200 METAL6_2897100_556200 0.0036
R_VDD21_9085 METAL6_2897100_556200 METAL6_2886900_556200 0.0204
R_VDD21_9086 METAL6_2886900_556200 METAL5_2886900_556200 0.1
R_VDD21_9087 METAL5_2886900_556200 METAL5_2886900_550400 0.0232
R_VDD21_9088 METAL5_2886900_550400 METAL5_2886900_547400 0.012
R_VDD21_9089 METAL5_2886900_547400 METAL5_2886900_544200 0.0128
R_VDD21_9090 METAL5_2886900_544200 METAL5_2886900_538400 0.0232
R_VDD21_9091 METAL5_2886900_538400 METAL5_2886900_535400 0.012
R_VDD21_9092 METAL5_2886900_535400 METAL5_2886900_532200 0.0128
R_VDD21_9093 METAL5_2886900_532200 METAL5_2886900_528000 0.0168
R_VDD21_9094 METAL5_2886900_528000 METAL5_2886900_520200 0.0312
R_VDD21_9095 METAL5_2886900_520200 METAL5_2886900_519000 0.0048
R_VDD21_9096 METAL5_2886900_519000 METAL5_2886900_516000 0.012
R_VDD21_9097 METAL5_2886900_516000 METAL5_2886900_512000 0.016
R_VDD21_9098 METAL5_2886900_512000 METAL5_2886900_507800 0.0168
R_VDD21_9099 METAL5_2886900_507800 METAL5_2886900_507000 0.0032
R_VDD21_9100 METAL5_2886900_507000 METAL5_2886900_504000 0.012
R_VDD21_9101 METAL5_2886900_504000 METAL5_2886900_500000 0.016
R_VDD21_9102 METAL5_2886900_500000 METAL5_2886900_495000 0.02
R_VDD21_9103 METAL5_2886900_495000 METAL5_2886900_492400 0.0104
R_VDD21_9104 METAL5_2886900_492400 METAL5_2886900_488000 0.0176
R_VDD21_9105 METAL5_2886900_488000 METAL5_2886900_483000 0.02
R_VDD21_9106 METAL5_2886900_483000 METAL5_2886900_480400 0.0104
R_VDD21_9107 METAL5_2886900_480400 METAL5_2886900_477000 0.0136
R_VDD21_9108 METAL5_2886900_477000 METAL5_2886900_473000 0.016
R_VDD21_9109 METAL5_2886900_473000 METAL5_2886900_471000 0.008
R_VDD21_9110 METAL5_2886900_471000 METAL6_2886900_471000 0.1
R_VDD21_9111 METAL6_2886900_471000 METAL6_2874800_471000 0.0242
R_VDD21_9112 METAL6_2874800_471000 METAL6_2862800_471000 0.024
R_VDD21_9113 METAL6_2862800_471000 METAL6_2862800_468400 0.0052
R_VDD21_9114 METAL6_2862800_468400 METAL6_2862800_465000 0.0068
R_VDD21_9115 METAL6_2862800_465000 METAL6_2862800_461000 0.008
R_VDD21_9116 METAL6_2862800_461000 METAL6_2860600_461000 0.0044
R_VDD21_9117 METAL6_2860600_461000 METAL6_2850800_461000 0.0196
R_VDD21_9118 METAL6_2850800_461000 METAL6_2846600_461000 0.0084
R_VDD21_9119 METAL6_2846600_461000 METAL6_2843800_461000 0.0056
R_VDD21_9120 METAL6_2843800_461000 METAL6_2817600_461000 0.0524
R_VDD21_9121 METAL6_2817600_461000 METAL6_2812000_461000 0.0112
R_VDD21_9122 METAL6_2812000_461000 METAL6_2812000_459000 0.004
R_VDD21_9123 METAL6_2812000_459000 METAL6_2812000_456400 0.0052
R_VDD21_9124 METAL6_2812000_456400 METAL6_2812000_453000 0.0068
R_VDD21_9125 METAL6_2812000_453000 METAL6_2812000_449000 0.008
R_VDD21_9126 METAL6_2812000_449000 METAL6_2810800_449000 0.0024
R_VDD21_9127 METAL6_2810800_449000 METAL6_2805600_449000 0.0104
R_VDD21_9128 METAL6_2805600_449000 METAL6_2800000_449000 0.0112
R_VDD21_9129 METAL6_2800000_449000 METAL6_2798800_449000 0.0024
R_VDD21_9130 METAL6_2798800_449000 METAL6_2793600_449000 0.0104
R_VDD21_9131 METAL6_2793600_449000 METAL6_2788000_449000 0.0112
R_VDD21_9132 METAL6_2788000_449000 METAL6_2786800_449000 0.0024
R_VDD21_9133 METAL6_2786800_449000 METAL6_2781600_449000 0.0104
R_VDD21_9134 METAL6_2781600_449000 METAL6_2769600_449000 0.024
R_VDD21_9135 METAL6_2769600_449000 METAL6_2765900_449000 0.0074
R_VDD21_9136 METAL6_2765900_449000 METAL6_2751900_449000 0.028
R_VDD21_9137 METAL6_2751900_449000 METAL6_2728200_449000 0.0474
R_VDD21_9138 METAL6_2728200_449000 METAL6_2710900_449000 0.0346
R_VDD21_9139 METAL6_2710900_449000 METAL6_2698900_449000 0.024
R_VDD21_9140 METAL6_2698900_449000 METAL6_2686900_449000 0.024
R_VDD21_9141 METAL6_2686900_449000 METAL6_2683200_449000 0.0074
R_VDD21_9142 METAL6_2683200_449000 METAL6_2676200_449000 0.014
R_VDD21_9143 METAL6_2676200_449000 METAL6_2664200_449000 0.024
R_VDD21_9144 METAL6_2664200_449000 METAL6_2660600_449000 0.0072
R_VDD21_9145 METAL6_2660600_449000 METAL6_2652200_449000 0.0168
R_VDD21_9146 METAL6_2652200_449000 METAL6_2646600_449000 0.0112
R_VDD21_9147 METAL6_2646600_449000 METAL6_2604400_449000 0.0844
R_VDD21_9148 METAL6_2604400_449000 METAL6_2592400_449000 0.024
R_VDD21_9149 METAL6_2592400_449000 METAL6_2580400_449000 0.024
R_VDD21_9150 METAL6_2580400_449000 METAL6_2568400_449000 0.024
R_VDD21_9151 METAL6_2568400_449000 METAL6_2565900_449000 0.005
R_VDD21_9152 METAL6_2565900_449000 METAL6_2556400_449000 0.019
R_VDD21_9153 METAL6_2556400_449000 METAL6_2551900_449000 0.009
R_VDD21_9154 METAL6_2551900_449000 METAL6_2548000_449000 0.0078
R_VDD21_9155 METAL6_2548000_449000 METAL6_2537600_449000 0.0208
R_VDD21_9156 METAL6_2537600_449000 METAL6_2536000_449000 0.0032
R_VDD21_9157 METAL6_2536000_449000 METAL6_2535400_449000 0.0012
R_VDD21_9158 METAL6_2535400_449000 METAL6_2529000_449000 0.0128
R_VDD21_9159 METAL6_2529000_449000 METAL6_2528400_449000 0.0012
R_VDD21_9160 METAL6_2528400_449000 METAL6_2525600_449000 0.0056
R_VDD21_9161 METAL6_2525600_449000 METAL6_2524000_449000 0.0032
R_VDD21_9162 METAL6_2524000_449000 METAL6_2517000_449000 0.014
R_VDD21_9163 METAL6_2517000_449000 METAL6_2516400_449000 0.0012
R_VDD21_9164 METAL6_2516400_449000 METAL6_2513600_449000 0.0056
R_VDD21_9165 METAL6_2513600_449000 METAL6_2512000_449000 0.0032
R_VDD21_9166 METAL6_2512000_449000 METAL6_2510900_449000 0.0022
R_VDD21_9167 METAL6_2510900_449000 METAL6_2505000_449000 0.0118
R_VDD21_9168 METAL6_2505000_449000 METAL6_2504400_449000 0.0012
R_VDD21_9169 METAL6_2504400_449000 METAL6_2501600_449000 0.0056
R_VDD21_9170 METAL6_2501600_449000 METAL6_2500000_449000 0.0032
R_VDD21_9171 METAL6_2500000_449000 METAL6_2498900_449000 0.0022
R_VDD21_9172 METAL6_2498900_449000 METAL6_2496600_449000 0.0046
R_VDD21_9173 METAL6_2496600_449000 METAL6_2493000_449000 0.0072
R_VDD21_9174 METAL6_2493000_449000 METAL6_2492400_449000 0.0012
R_VDD21_9175 METAL6_2492400_449000 METAL6_2489600_449000 0.0056
R_VDD21_9176 METAL6_2489600_449000 METAL6_2488000_449000 0.0032
R_VDD21_9177 METAL6_2488000_449000 METAL6_2486900_449000 0.0022
R_VDD21_9178 METAL6_2486900_449000 METAL6_2484600_449000 0.0046
R_VDD21_9179 METAL6_2484600_449000 METAL6_2482600_449000 0.004
R_VDD21_9180 METAL6_2482600_449000 METAL6_2481000_449000 0.0032
R_VDD21_9181 METAL6_2481000_449000 METAL6_2480400_449000 0.0012
R_VDD21_9182 METAL6_2480400_449000 METAL6_2477600_449000 0.0056
R_VDD21_9183 METAL6_2477600_449000 METAL6_2476000_449000 0.0032
R_VDD21_9184 METAL6_2476000_449000 METAL6_2472600_449000 0.0068
R_VDD21_9185 METAL6_2472600_449000 METAL6_2470600_449000 0.004
R_VDD21_9186 METAL6_2470600_449000 METAL6_2469000_449000 0.0032
R_VDD21_9187 METAL6_2469000_449000 METAL6_2468400_449000 0.0012
R_VDD21_9188 METAL6_2468400_449000 METAL6_2465600_449000 0.0056
R_VDD21_9189 METAL6_2465600_449000 METAL6_2464000_449000 0.0032
R_VDD21_9190 METAL6_2464000_449000 METAL6_2460600_449000 0.0068
R_VDD21_9191 METAL6_2460600_449000 METAL6_2458600_449000 0.004
R_VDD21_9192 METAL6_2458600_449000 METAL6_2457000_449000 0.0032
R_VDD21_9193 METAL6_2457000_449000 METAL6_2452000_449000 0.01
R_VDD21_9194 METAL6_2452000_449000 METAL6_2448600_449000 0.0068
R_VDD21_9195 METAL6_2448600_449000 METAL6_2446600_449000 0.004
R_VDD21_9196 METAL6_2446600_449000 METAL6_2440000_449000 0.0132
R_VDD21_9197 METAL6_2440000_449000 METAL6_2436600_449000 0.0068
R_VDD21_9198 METAL6_2436600_449000 METAL6_2434600_449000 0.004
R_VDD21_9199 METAL6_2434600_449000 METAL6_2424600_449000 0.02
R_VDD21_9200 METAL6_2424600_449000 METAL6_2422600_449000 0.004
R_VDD21_9201 METAL6_2422600_449000 METAL6_2419100_449000 0.007
R_VDD21_9202 METAL6_2419100_449000 METAL6_2407100_449000 0.024
R_VDD21_9203 METAL6_2407100_449000 METAL6_2405600_449000 0.003
R_VDD21_9204 METAL6_2405600_449000 METAL6_2402100_449000 0.007
R_VDD21_9205 METAL6_2402100_449000 METAL6_2395100_449000 0.014
R_VDD21_9206 METAL6_2395100_449000 METAL6_2393600_449000 0.003
R_VDD21_9207 METAL6_2393600_449000 METAL6_2383100_449000 0.021
R_VDD21_9208 METAL6_2383100_449000 METAL6_2381600_449000 0.003
R_VDD21_9209 METAL6_2381600_449000 METAL6_2371100_449000 0.021
R_VDD21_9210 METAL6_2371100_449000 METAL6_2369600_449000 0.003
R_VDD21_9211 METAL6_2369600_449000 METAL6_2365900_449000 0.0074
R_VDD21_9212 METAL6_2365900_449000 METAL6_2357600_449000 0.0166
R_VDD21_9213 METAL6_2357600_449000 METAL6_2351900_449000 0.0114
R_VDD21_9214 METAL6_2351900_449000 METAL6_2343700_449000 0.0164
R_VDD21_9215 METAL6_2343700_449000 METAL6_2332600_449000 0.0222
R_VDD21_9216 METAL6_2332600_449000 METAL6_2322900_449000 0.0194
R_VDD21_9217 METAL6_2322900_449000 METAL6_2320600_449000 0.0046
R_VDD21_9218 METAL6_2320600_449000 METAL6_2310900_449000 0.0194
R_VDD21_9219 METAL6_2310900_449000 METAL6_2308600_449000 0.0046
R_VDD21_9220 METAL6_2308600_449000 METAL6_2298900_449000 0.0194
R_VDD21_9221 METAL6_2298900_449000 METAL6_2296600_449000 0.0046
R_VDD21_9222 METAL6_2296600_449000 METAL6_2286900_449000 0.0194
R_VDD21_9223 METAL6_2286900_449000 METAL6_2284600_449000 0.0046
R_VDD21_9224 METAL6_2284600_449000 METAL6_2284400_449000 0.0004
R_VDD21_9225 METAL6_2284400_449000 METAL6_2274900_449000 0.019
R_VDD21_9226 METAL6_2274900_449000 METAL6_2272600_449000 0.0046
R_VDD21_9227 METAL6_2272600_449000 METAL6_2272400_449000 0.0004
R_VDD21_9228 METAL6_2272400_449000 METAL6_2260600_449000 0.0236
R_VDD21_9229 METAL6_2260600_449000 METAL6_2260400_449000 0.0004
R_VDD21_9230 METAL6_2260400_449000 METAL6_2258600_449000 0.0036
R_VDD21_9231 METAL6_2258600_449000 METAL6_2248700_449000 0.0198
R_VDD21_9232 METAL6_2248700_449000 METAL6_2248600_449000 0.0002
R_VDD21_9233 METAL6_2248600_449000 METAL6_2248400_449000 0.0004
R_VDD21_9234 METAL6_2248400_449000 METAL6_2246600_449000 0.0036
R_VDD21_9235 METAL6_2246600_449000 METAL6_2245900_449000 0.0014
R_VDD21_9236 METAL6_2245900_449000 METAL6_2236700_449000 0.0184
R_VDD21_9237 METAL6_2236700_449000 METAL6_2236600_449000 0.0002
R_VDD21_9238 METAL6_2236600_449000 METAL6_2234600_449000 0.004
R_VDD21_9239 METAL6_2234600_449000 METAL6_2233900_449000 0.0014
R_VDD21_9240 METAL6_2233900_449000 METAL6_2224700_449000 0.0184
R_VDD21_9241 METAL6_2224700_449000 METAL6_2224600_449000 0.0002
R_VDD21_9242 METAL6_2224600_449000 METAL6_2222600_449000 0.004
R_VDD21_9243 METAL6_2222600_449000 METAL6_2221900_449000 0.0014
R_VDD21_9244 METAL6_2221900_449000 METAL6_2212700_449000 0.0184
R_VDD21_9245 METAL6_2212700_449000 METAL6_2212600_449000 0.0002
R_VDD21_9246 METAL6_2212600_449000 METAL6_2210600_449000 0.004
R_VDD21_9247 METAL6_2210600_449000 METAL6_2209900_449000 0.0014
R_VDD21_9248 METAL6_2209900_449000 METAL6_2200700_449000 0.0184
R_VDD21_9249 METAL6_2200700_449000 METAL6_2189900_449000 0.0216
R_VDD21_9250 METAL6_2189900_449000 METAL6_2188700_449000 0.0024
R_VDD21_9251 METAL6_2188700_449000 METAL6_2177900_449000 0.0216
R_VDD21_9252 METAL6_2177900_449000 METAL6_2176700_449000 0.0024
R_VDD21_9253 METAL6_2176700_449000 METAL6_2165900_449000 0.0216
R_VDD21_9254 METAL6_2165900_449000 METAL6_2165400_449000 0.001
R_VDD21_9255 METAL6_2165400_449000 METAL6_2153900_449000 0.023
R_VDD21_9256 METAL6_2153900_449000 METAL6_2153400_449000 0.001
R_VDD21_9257 METAL6_2153400_449000 METAL6_2151900_449000 0.003
R_VDD21_9258 METAL6_2151900_449000 METAL6_2141900_449000 0.02
R_VDD21_9259 METAL6_2141900_449000 METAL6_2141400_449000 0.001
R_VDD21_9260 METAL6_2141400_449000 METAL6_2129900_449000 0.023
R_VDD21_9261 METAL6_2129900_449000 METAL6_2129700_449000 0.0004
R_VDD21_9262 METAL6_2129700_449000 METAL6_2125600_449000 0.0082
R_VDD21_9263 METAL6_2125600_449000 METAL6_2121400_449000 0.0084
R_VDD21_9264 METAL6_2121400_449000 METAL6_2117900_449000 0.007
R_VDD21_9265 METAL6_2117900_449000 METAL6_2113900_449000 0.008
R_VDD21_9266 METAL6_2113900_449000 METAL6_2113600_449000 0.0006
R_VDD21_9267 METAL6_2113600_449000 METAL6_2105900_449000 0.0154
R_VDD21_9268 METAL6_2105900_449000 METAL6_2101900_449000 0.008
R_VDD21_9269 METAL6_2101900_449000 METAL6_2101600_449000 0.0006
R_VDD21_9270 METAL6_2101600_449000 METAL6_2091700_449000 0.0198
R_VDD21_9271 METAL6_2091700_449000 METAL6_2089900_449000 0.0036
R_VDD21_9272 METAL6_2089900_449000 METAL6_2079700_449000 0.0204
R_VDD21_9273 METAL6_2079700_449000 METAL6_2077900_449000 0.0036
R_VDD21_9274 METAL6_2077900_449000 METAL6_2067700_449000 0.0204
R_VDD21_9275 METAL6_2067700_449000 METAL6_2060600_449000 0.0142
R_VDD21_9276 METAL6_2060600_449000 METAL6_2058800_449000 0.0036
R_VDD21_9277 METAL6_2058800_449000 METAL6_2055700_449000 0.0062
R_VDD21_9278 METAL6_2055700_449000 METAL6_2046800_449000 0.0178
R_VDD21_9279 METAL6_2046800_449000 METAL6_2046600_449000 0.0004
R_VDD21_9280 METAL6_2046600_449000 METAL6_2046400_449000 0.0004
R_VDD21_9281 METAL6_2046400_449000 METAL6_2043700_449000 0.0054
R_VDD21_9282 METAL6_2043700_449000 METAL6_2034800_449000 0.0178
R_VDD21_9283 METAL6_2034800_449000 METAL6_2031700_449000 0.0062
R_VDD21_9284 METAL6_2031700_449000 METAL6_2030900_449000 0.0016
R_VDD21_9285 METAL6_2030900_449000 METAL6_2026400_449000 0.009
R_VDD21_9286 METAL6_2026400_449000 METAL6_2021200_449000 0.0104
R_VDD21_9287 METAL6_2021200_449000 METAL6_2019700_449000 0.003
R_VDD21_9288 METAL6_2019700_449000 METAL6_2018900_449000 0.0016
R_VDD21_9289 METAL6_2018900_449000 METAL6_2014400_449000 0.009
R_VDD21_9290 METAL6_2014400_449000 METAL6_2012000_449000 0.0048
R_VDD21_9291 METAL6_2012000_449000 METAL6_2007700_449000 0.0086
R_VDD21_9292 METAL6_2007700_449000 METAL6_2006900_449000 0.0016
R_VDD21_9293 METAL6_2006900_449000 METAL6_2002400_449000 0.009
R_VDD21_9294 METAL6_2002400_449000 METAL6_2000000_449000 0.0048
R_VDD21_9295 METAL6_2000000_449000 METAL6_1988000_449000 0.024
R_VDD21_9296 METAL6_1988000_449000 METAL6_1975900_449000 0.0242
R_VDD21_9297 METAL6_1975900_449000 METAL6_1963900_449000 0.024
R_VDD21_9298 METAL6_1963900_449000 METAL6_1963800_449000 0.0002
R_VDD21_9299 METAL6_1963800_449000 METAL6_1951900_449000 0.0238
R_VDD21_9300 METAL6_1951900_449000 METAL6_1951800_449000 0.0002
R_VDD21_9301 METAL6_1951800_449000 METAL6_1939900_449000 0.0238
R_VDD21_9302 METAL6_1939900_449000 METAL6_1939800_449000 0.0002
R_VDD21_9303 METAL6_1939800_449000 METAL6_1937600_449000 0.0044
R_VDD21_9304 METAL6_1937600_449000 METAL6_1931200_449000 0.0128
R_VDD21_9305 METAL6_1931200_449000 METAL6_1927800_449000 0.0068
R_VDD21_9306 METAL6_1927800_449000 METAL6_1926200_449000 0.0032
R_VDD21_9307 METAL6_1926200_449000 METAL6_1925600_449000 0.0012
R_VDD21_9308 METAL6_1925600_449000 METAL6_1919200_449000 0.0128
R_VDD21_9309 METAL6_1919200_449000 METAL6_1913600_449000 0.0112
R_VDD21_9310 METAL6_1913600_449000 METAL6_1907400_449000 0.0124
R_VDD21_9311 METAL6_1907400_449000 METAL6_1907200_449000 0.0004
R_VDD21_9312 METAL6_1907200_449000 METAL6_1901600_449000 0.0112
R_VDD21_9313 METAL6_1901600_449000 METAL6_1901400_449000 0.0004
R_VDD21_9314 METAL6_1901400_449000 METAL6_1900700_449000 0.0014
R_VDD21_9315 METAL6_1900700_449000 METAL6_1895200_449000 0.011
R_VDD21_9316 METAL6_1895200_449000 METAL6_1889600_449000 0.0112
R_VDD21_9317 METAL6_1889600_449000 METAL6_1889400_449000 0.0004
R_VDD21_9318 METAL6_1889400_449000 METAL6_1888700_449000 0.0014
R_VDD21_9319 METAL6_1888700_449000 METAL5_1888700_449000 0.1
R_VDD21_9320 METAL5_1888700_449000 METAL5_1883200_449000 0.022
R_VDD21_9321 METAL5_1883200_449000 METAL5_1877600_449000 0.0224
R_VDD21_9322 METAL5_1877600_449000 METAL5_1877400_449000 0.0008
R_VDD21_9323 METAL5_1877400_449000 METAL5_1876700_449000 0.0028
R_VDD21_9324 METAL5_1876700_449000 METAL5_1874700_449000 0.008
R_VDD21_9325 METAL5_1874700_449000 METAL5_1871200_449000 0.014
R_VDD21_9326 METAL5_1871200_449000 METAL5_1870600_449000 0.0024
R_VDD21_9327 METAL5_1870600_449000 METAL5_1865600_449000 0.02
R_VDD21_9328 METAL5_1865600_449000 METAL5_1865400_449000 0.0008
R_VDD21_9329 METAL5_1865400_449000 METAL5_1864700_449000 0.0028
R_VDD21_9330 METAL5_1864700_449000 METAL5_1859200_449000 0.022
R_VDD21_9331 METAL5_1859200_449000 METAL5_1858600_449000 0.0024
R_VDD21_9332 METAL5_1858600_449000 METAL5_1858400_449000 0.0008
R_VDD21_9333 METAL5_1858400_449000 METAL5_1853400_449000 0.02
R_VDD21_9334 METAL5_1853400_449000 METAL5_1852700_449000 0.0028
R_VDD21_9335 METAL5_1852700_449000 METAL5_1847200_449000 0.022
R_VDD21_9336 METAL5_1847200_449000 METAL5_1846800_449000 0.0016
R_VDD21_9337 METAL5_1846800_449000 METAL5_1846600_449000 0.0008
R_VDD21_9338 METAL5_1846600_449000 METAL5_1846400_449000 0.0008
R_VDD21_9339 METAL5_1846400_449000 METAL5_1844800_449000 0.0064
R_VDD21_9340 METAL5_1844800_449000 METAL5_1841400_449000 0.0136
R_VDD21_9341 METAL5_1841400_449000 METAL5_1834600_449000 0.0272
R_VDD21_9342 METAL5_1834600_449000 METAL5_1834400_449000 0.0008
R_VDD21_9343 METAL5_1834400_449000 METAL5_1832800_449000 0.0064
R_VDD21_9344 METAL5_1832800_449000 METAL5_1822600_449000 0.0408
R_VDD21_9345 METAL5_1822600_449000 METAL5_1822400_449000 0.0008
R_VDD21_9346 METAL5_1822400_449000 METAL5_1820800_449000 0.0064
R_VDD21_9347 METAL5_1820800_449000 METAL5_1812000_449000 0.0352
R_VDD21_9348 METAL5_1812000_449000 METAL5_1810600_449000 0.0056
R_VDD21_9349 METAL5_1810600_449000 METAL5_1800000_449000 0.0424
R_VDD21_9350 METAL5_1800000_449000 METAL5_1788000_449000 0.048
R_VDD21_9351 METAL5_1788000_449000 METAL5_1787400_449000 0.0024
R_VDD21_9352 METAL5_1787400_449000 METAL5_1775400_449000 0.048
R_VDD21_9353 METAL5_1775400_449000 METAL5_1768000_449000 0.0296
R_VDD21_9354 METAL5_1768000_449000 METAL5_1767700_449000 0.0012
R_VDD21_9355 METAL5_1767700_449000 METAL5_1763800_449000 0.0156
R_VDD21_9356 METAL5_1763800_449000 METAL5_1763400_449000 0.0016
R_VDD21_9357 METAL5_1763400_449000 METAL5_1756000_449000 0.0296
R_VDD21_9358 METAL5_1756000_449000 METAL5_1755700_449000 0.0012
R_VDD21_9359 METAL5_1755700_449000 METAL5_1753800_449000 0.0076
R_VDD21_9360 METAL5_1753800_449000 METAL5_1751800_449000 0.008
R_VDD21_9361 METAL5_1751800_449000 METAL5_1751400_449000 0.0016
R_VDD21_9362 METAL5_1751400_449000 METAL5_1744000_449000 0.0296
R_VDD21_9363 METAL5_1744000_449000 METAL5_1743700_449000 0.0012
R_VDD21_9364 METAL5_1743700_449000 METAL5_1741800_449000 0.0076
R_VDD21_9365 METAL5_1741800_449000 METAL5_1739800_449000 0.008
R_VDD21_9366 METAL5_1739800_449000 METAL5_1739400_449000 0.0016
R_VDD21_9367 METAL5_1739400_449000 METAL5_1732000_449000 0.0296
R_VDD21_9368 METAL5_1732000_449000 METAL5_1731700_449000 0.0012
R_VDD21_9369 METAL5_1731700_449000 METAL5_1729800_449000 0.0076
R_VDD21_9370 METAL5_1729800_449000 METAL5_1727800_449000 0.008
R_VDD21_9371 METAL5_1727800_449000 METAL5_1719700_449000 0.0324
R_VDD21_9372 METAL5_1719700_449000 METAL5_1717800_449000 0.0076
R_VDD21_9373 METAL5_1717800_449000 METAL5_1710800_449000 0.028
R_VDD21_9374 METAL5_1710800_449000 METAL5_1707700_449000 0.0124
R_VDD21_9375 METAL5_1707700_449000 METAL5_1699000_449000 0.0348
R_VDD21_9376 METAL5_1699000_449000 METAL5_1692000_449000 0.028
R_VDD21_9377 METAL5_1692000_449000 METAL5_1682800_449000 0.0368
R_VDD21_9378 METAL5_1682800_449000 METAL5_1680000_449000 0.0112
R_VDD21_9379 METAL5_1680000_449000 METAL5_1670800_449000 0.0368
R_VDD21_9380 METAL5_1670800_449000 METAL5_1670800_453000 0.016
R_VDD21_9381 METAL5_1670800_453000 METAL5_1670800_456400 0.0136
R_VDD21_9382 METAL5_1670800_456400 METAL5_1668000_456400 0.0112
R_VDD21_9383 METAL5_1668000_456400 METAL5_1658800_456400 0.0368
R_VDD21_9384 METAL5_1658800_456400 METAL5_1648700_456400 0.0404
R_VDD21_9385 METAL5_1648700_456400 METAL5_1648700_459000 0.0104
R_VDD21_9386 METAL5_1648700_459000 METAL5_1648700_461000 0.008
R_VDD21_9387 METAL5_1648700_461000 METAL5_1648700_465000 0.016
R_VDD21_9388 METAL5_1648700_465000 METAL5_1648700_468400 0.0136
R_VDD21_9389 METAL5_1648700_468400 METAL5_1648700_471000 0.0104
R_VDD21_9390 METAL5_1648700_471000 METAL5_1648700_473000 0.008
R_VDD21_9391 METAL5_1648700_473000 METAL5_1648700_477000 0.016
R_VDD21_9392 METAL5_1648700_477000 METAL5_1648700_480400 0.0136
R_VDD21_9393 METAL5_1648700_480400 METAL5_1648000_480400 0.0028
R_VDD21_9394 METAL5_1648000_480400 METAL5_1646800_480400 0.0048
R_VDD21_9395 METAL5_1646800_480400 METAL5_1636700_480400 0.0404
R_VDD21_9396 METAL5_1636700_480400 METAL5_1636000_480400 0.0028
R_VDD21_9397 METAL5_1636000_480400 METAL5_1634800_480400 0.0048
R_VDD21_9398 METAL5_1634800_480400 METAL5_1632800_480400 0.008
R_VDD21_9399 METAL5_1632800_480400 METAL5_1627800_480400 0.02
R_VDD21_9400 METAL5_1627800_480400 METAL5_1624700_480400 0.0124
R_VDD21_9401 METAL5_1624700_480400 METAL5_1624000_480400 0.0028
R_VDD21_9402 METAL5_1624000_480400 METAL5_1615800_480400 0.0328
R_VDD21_9403 METAL5_1615800_480400 METAL5_1612700_480400 0.0124
R_VDD21_9404 METAL5_1612700_480400 METAL5_1612000_480400 0.0028
R_VDD21_9405 METAL5_1612000_480400 METAL5_1607900_480400 0.0164
R_VDD21_9406 METAL5_1607900_480400 METAL5_1603800_480400 0.0164
R_VDD21_9407 METAL5_1603800_480400 METAL5_1600700_480400 0.0124
R_VDD21_9408 METAL5_1600700_480400 METAL5_1600000_480400 0.0028
R_VDD21_9409 METAL5_1600000_480400 METAL5_1591800_480400 0.0328
R_VDD21_9410 METAL5_1591800_480400 METAL5_1588700_480400 0.0124
R_VDD21_9411 METAL5_1588700_480400 METAL5_1588000_480400 0.0028
R_VDD21_9412 METAL5_1588000_480400 METAL5_1579800_480400 0.0328
R_VDD21_9413 METAL5_1579800_480400 METAL5_1576700_480400 0.0124
R_VDD21_9414 METAL5_1576700_480400 METAL5_1576000_480400 0.0028
R_VDD21_9415 METAL5_1576000_480400 METAL5_1574700_480400 0.0052
R_VDD21_9416 METAL5_1574700_480400 METAL5_1569000_480400 0.0228
R_VDD21_9417 METAL5_1569000_480400 METAL5_1567800_480400 0.0048
R_VDD21_9418 METAL5_1567800_480400 METAL5_1564000_480400 0.0152
R_VDD21_9419 METAL5_1564000_480400 METAL5_1557000_480400 0.028
R_VDD21_9420 METAL5_1557000_480400 METAL5_1555400_480400 0.0064
R_VDD21_9421 METAL5_1555400_480400 METAL5_1552000_480400 0.0136
R_VDD21_9422 METAL5_1552000_480400 METAL5_1551800_480400 0.0008
R_VDD21_9423 METAL5_1551800_480400 METAL5_1545000_480400 0.0272
R_VDD21_9424 METAL5_1545000_480400 METAL5_1540000_480400 0.02
R_VDD21_9425 METAL5_1540000_480400 METAL5_1539800_480400 0.0008
R_VDD21_9426 METAL5_1539800_480400 METAL5_1528000_480400 0.0472
R_VDD21_9427 METAL5_1528000_480400 METAL5_1527800_480400 0.0008
R_VDD21_9428 METAL5_1527800_480400 METAL5_1512000_480400 0.0632
R_VDD21_9429 METAL5_1512000_480400 METAL5_1510400_480400 0.0064
R_VDD21_9430 METAL5_1510400_480400 METAL5_1503400_480400 0.028
R_VDD21_9431 METAL5_1503400_480400 METAL5_1500000_480400 0.0136
R_VDD21_9432 METAL5_1500000_480400 METAL5_1498300_480400 0.0068
R_VDD21_9433 METAL5_1498300_480400 METAL5_1491400_480400 0.0276
R_VDD21_9434 METAL5_1491400_480400 METAL5_1491400_483000 0.0104
R_VDD21_9435 METAL5_1491400_483000 METAL5_1491400_488000 0.02
R_VDD21_9436 METAL5_1491400_488000 METAL5_1491400_492400 0.0176
R_VDD21_9437 METAL5_1491400_492400 METAL6_1491400_492400 0.1
R_VDD21_9438 METAL6_1491400_492400 METAL6_1491400_495000 0.0052
R_VDD21_9439 METAL6_1491400_495000 METAL6_1491400_500000 0.01
R_VDD21_9440 METAL6_1491400_500000 METAL6_1491400_504000 0.008
R_VDD21_9441 METAL6_1491400_504000 METAL6_1491400_507000 0.006
R_VDD21_9442 METAL6_1491400_507000 METAL6_1491400_507800 0.0016
R_VDD21_9443 METAL6_1491400_507800 METAL6_1491400_512000 0.0084
R_VDD21_9444 METAL6_1491400_512000 METAL6_1491400_516000 0.008
R_VDD21_9445 METAL6_1491400_516000 METAL6_1491400_519000 0.006
R_VDD21_9446 METAL6_1491400_519000 METAL6_1491400_520200 0.0024
R_VDD21_9447 METAL6_1491400_520200 METAL6_1491400_528000 0.0156
R_VDD21_9448 METAL6_1491400_528000 METAL6_1491400_532200 0.0084
R_VDD21_9449 METAL6_1491400_532200 METAL6_1491400_535400 0.0064
R_VDD21_9450 METAL6_1491400_535400 METAL6_1491400_538400 0.006
R_VDD21_9451 METAL6_1491400_538400 METAL6_1491400_544200 0.0116
R_VDD21_9452 METAL6_1491400_544200 METAL6_1491400_547400 0.0064
R_VDD21_9453 METAL6_1503400_547400 METAL6_1500000_547400 0.0068
R_VDD21_9454 METAL6_1500000_547400 METAL6_1498300_547400 0.0034
R_VDD21_9455 METAL6_1498300_547400 METAL6_1491400_547400 0.0138
I_VDD21_35 METAL6_1503400_547400 gnd 0.001

V_VDD22_15 METAL5_3500000_900000 gnd 1
R_VDD22_9456 METAL5_3500000_900000 METAL5_3490500_900000 0.038
R_VDD22_9457 METAL5_3490500_900000 METAL6_3490500_900000 0.1
R_VDD22_9458 METAL6_3490500_900000 METAL6_3478500_900000 0.024
R_VDD22_9459 METAL6_3478500_900000 METAL6_3477000_900000 0.003
R_VDD22_9460 METAL6_3477000_900000 METAL6_3466500_900000 0.021
R_VDD22_9461 METAL6_3466500_900000 METAL6_3465000_900000 0.003
R_VDD22_9462 METAL6_3465000_900000 METAL6_3454500_900000 0.021
R_VDD22_9463 METAL6_3454500_900000 METAL6_3453000_900000 0.003
R_VDD22_9464 METAL6_3453000_900000 METAL6_3442500_900000 0.021
R_VDD22_9465 METAL6_3442500_900000 METAL6_3336400_900000 0.2122
R_VDD22_9466 METAL6_3336400_900000 METAL6_3336400_900400 0.0008
R_VDD22_9467 METAL6_3336400_900400 METAL6_3336400_912000 0.0232
R_VDD22_9468 METAL6_3336400_912000 METAL6_3336400_927300 0.0306
R_VDD22_9469 METAL6_3336400_927300 METAL6_3336400_947000 0.0394
R_VDD22_9470 METAL6_3336400_947000 METAL6_3336400_959000 0.024
R_VDD22_9471 METAL6_3336400_959000 METAL6_3336400_971000 0.024
R_VDD22_9472 METAL6_3336400_971000 METAL6_3336400_976000 0.01
R_VDD22_9473 METAL6_3336400_976000 METAL6_3336400_988000 0.024
R_VDD22_9474 METAL6_3336400_988000 METAL6_3336400_995000 0.014
R_VDD22_9475 METAL6_3336400_995000 METAL6_3336400_1000000 0.01
R_VDD22_9476 METAL6_3336400_1000000 METAL6_3336400_1007000 0.014
R_VDD22_9477 METAL6_3336400_1007000 METAL6_3336400_1012000 0.01
R_VDD22_9478 METAL6_3336400_1012000 METAL6_3336400_1014000 0.004
R_VDD22_9479 METAL6_3336400_1014000 METAL6_3336400_1019000 0.01
R_VDD22_9480 METAL6_3336400_1019000 METAL6_3336400_1023700 0.0094
R_VDD22_9481 METAL6_3336400_1023700 METAL6_3336400_1025400 0.0034
R_VDD22_9482 METAL6_3336400_1025400 METAL6_3336400_1026000 0.0012
R_VDD22_9483 METAL6_3336400_1026000 METAL6_3336400_1029800 0.0076
R_VDD22_9484 METAL6_3336400_1029800 METAL6_3336400_1031000 0.0024
R_VDD22_9485 METAL6_3336400_1031000 METAL6_3336400_1035700 0.0094
R_VDD22_9486 METAL6_3336400_1035700 METAL6_3336400_1037400 0.0034
R_VDD22_9487 METAL6_3336400_1037400 METAL6_3336400_1038000 0.0012
R_VDD22_9488 METAL6_3336400_1038000 METAL6_3336400_1041800 0.0076
R_VDD22_9489 METAL6_3336400_1041800 METAL6_3336400_1042700 0.0018
R_VDD22_9490 METAL6_3336400_1042700 METAL6_3336400_1047700 0.01
R_VDD22_9491 METAL6_3336400_1047700 METAL6_3336400_1049400 0.0034
R_VDD22_9492 METAL6_3336400_1049400 METAL6_3336400_1049800 0.0008
R_VDD22_9493 METAL6_3336400_1049800 METAL6_3336400_1053800 0.008
R_VDD22_9494 METAL6_3336400_1053800 METAL6_3336400_1054700 0.0018
R_VDD22_9495 METAL6_3336400_1054700 METAL6_3336400_1061400 0.0134
R_VDD22_9496 METAL6_3336400_1061400 METAL6_3336400_1061800 0.0008
R_VDD22_9497 METAL6_3336400_1061800 METAL6_3336400_1066700 0.0098
R_VDD22_9498 METAL6_3336400_1066700 METAL6_3336400_1073800 0.0142
R_VDD22_9499 METAL6_3336400_1073800 METAL6_3336400_1086000 0.0244
R_VDD22_9500 METAL6_3336400_1086000 METAL6_3336400_1086300 0.0006
R_VDD22_9501 METAL6_3336400_1086300 METAL6_3336400_1086500 0.0004
R_VDD22_9502 METAL6_3336400_1086500 METAL6_3336400_1088000 0.003
R_VDD22_9503 METAL6_3336400_1088000 METAL6_3336400_1096800 0.0176
R_VDD22_9504 METAL6_3336400_1096800 METAL6_3336400_1098300 0.003
R_VDD22_9505 METAL6_3336400_1098300 METAL6_3336400_1098500 0.0004
R_VDD22_9506 METAL6_3336400_1098500 METAL6_3336400_1100000 0.003
R_VDD22_9507 METAL6_3336400_1100000 METAL6_3336400_1108800 0.0176
R_VDD22_9508 METAL6_3336400_1108800 METAL6_3336400_1110300 0.003
R_VDD22_9509 METAL6_3336400_1110300 METAL6_3336400_1110500 0.0004
R_VDD22_9510 METAL6_3336400_1110500 METAL6_3336400_1112000 0.003
R_VDD22_9511 METAL6_3336400_1112000 METAL6_3336400_1120800 0.0176
R_VDD22_9512 METAL6_3336400_1120800 METAL6_3324400_1120800 0.024
R_VDD22_9513 METAL6_3324400_1120800 METAL5_3324400_1120800 0.1
R_VDD22_9514 METAL5_3324400_1120800 METAL5_3312400_1120800 0.048
R_VDD22_9515 METAL5_3312400_1120800 METAL5_3312000_1120800 0.0016
R_VDD22_9516 METAL5_3312000_1120800 METAL5_3305400_1120800 0.0264
R_VDD22_9517 METAL5_3305400_1120800 METAL5_3300400_1120800 0.02
R_VDD22_9518 METAL5_3300400_1120800 METAL6_3300400_1120800 0.1
R_VDD22_9519 METAL6_3300400_1120800 METAL6_3300400_1122300 0.003
R_VDD22_9520 METAL6_3300400_1122300 METAL6_3300400_1129300 0.014
R_VDD22_9521 METAL6_3300400_1129300 METAL6_3300400_1134300 0.01
R_VDD22_9522 METAL6_3300400_1134300 METAL6_3300400_1141300 0.014
R_VDD22_9523 METAL6_3300400_1141300 METAL6_3300400_1153300 0.024
R_VDD22_9524 METAL6_3300400_1153300 METAL6_3300400_1160600 0.0146
R_VDD22_9525 METAL6_3300400_1160600 METAL6_3300400_1172600 0.024
R_VDD22_9526 METAL6_3300400_1172600 METAL6_3300400_1184600 0.024
R_VDD22_9527 METAL6_3300400_1184600 METAL6_3300400_1191600 0.014
R_VDD22_9528 METAL6_3300400_1191600 METAL6_3300400_1193700 0.0042
R_VDD22_9529 METAL6_3300400_1193700 METAL6_3300000_1193700 0.0008
R_VDD22_9530 METAL6_3300000_1193700 METAL6_3288400_1193700 0.0232
R_VDD22_9531 METAL6_3288400_1193700 METAL6_3288000_1193700 0.0008
R_VDD22_9532 METAL6_3288000_1193700 METAL6_3287000_1193700 0.002
R_VDD22_9533 METAL6_3287000_1193700 METAL6_3276400_1193700 0.0212
R_VDD22_9534 METAL6_3276400_1193700 METAL6_3275000_1193700 0.0028
R_VDD22_9535 METAL6_3275000_1193700 METAL6_3263000_1193700 0.024
R_VDD22_9536 METAL6_3263000_1193700 METAL6_3260400_1193700 0.0052
R_VDD22_9537 METAL6_3260400_1193700 METAL6_3243500_1193700 0.0338
R_VDD22_9538 METAL6_3243500_1193700 METAL6_3231500_1193700 0.024
R_VDD22_9539 METAL6_3231500_1193700 METAL6_3219500_1193700 0.024
R_VDD22_9540 METAL6_3219500_1193700 METAL6_3212500_1193700 0.014
R_VDD22_9541 METAL6_3212500_1193700 METAL6_3212000_1193700 0.001
R_VDD22_9542 METAL6_3212000_1193700 METAL6_3200000_1193700 0.024
R_VDD22_9543 METAL6_3200000_1193700 METAL6_3188000_1193700 0.024
R_VDD22_9544 METAL6_3188000_1193700 METAL6_3179500_1193700 0.017
R_VDD22_9545 METAL6_3179500_1193700 METAL6_3167500_1193700 0.024
R_VDD22_9546 METAL6_3167500_1193700 METAL6_3165900_1193700 0.0032
R_VDD22_9547 METAL6_3165900_1193700 METAL6_3155500_1193700 0.0208
R_VDD22_9548 METAL6_3155500_1193700 METAL6_3124000_1193700 0.063
R_VDD22_9549 METAL6_3124000_1193700 METAL6_3112000_1193700 0.024
R_VDD22_9550 METAL6_3112000_1193700 METAL6_3110900_1193700 0.0022
R_VDD22_9551 METAL6_3110900_1193700 METAL6_3100000_1193700 0.0218
R_VDD22_9552 METAL6_3100000_1193700 METAL6_3099200_1193700 0.0016
R_VDD22_9553 METAL6_3099200_1193700 METAL6_3098900_1193700 0.0006
R_VDD22_9554 METAL6_3098900_1193700 METAL6_3088000_1193700 0.0218
R_VDD22_9555 METAL6_3088000_1193700 METAL6_3087200_1193700 0.0016
R_VDD22_9556 METAL6_3087200_1193700 METAL6_3086900_1193700 0.0006
R_VDD22_9557 METAL6_3086900_1193700 METAL6_3076000_1193700 0.0218
R_VDD22_9558 METAL6_3076000_1193700 METAL6_3075200_1193700 0.0016
R_VDD22_9559 METAL6_3075200_1193700 METAL6_3068200_1193700 0.014
R_VDD22_9560 METAL6_3068200_1193700 METAL6_3064000_1193700 0.0084
R_VDD22_9561 METAL6_3064000_1193700 METAL6_3060600_1193700 0.0068
R_VDD22_9562 METAL6_3060600_1193700 METAL6_3052000_1193700 0.0172
R_VDD22_9563 METAL6_3052000_1193700 METAL6_3023200_1193700 0.0576
R_VDD22_9564 METAL6_3023200_1193700 METAL6_3012000_1193700 0.0224
R_VDD22_9565 METAL6_3012000_1193700 METAL6_3006200_1193700 0.0116
R_VDD22_9566 METAL6_3006200_1193700 METAL6_3000000_1193700 0.0124
R_VDD22_9567 METAL6_3000000_1193700 METAL6_2994200_1193700 0.0116
R_VDD22_9568 METAL6_2994200_1193700 METAL6_2993000_1193700 0.0024
R_VDD22_9569 METAL6_2993000_1193700 METAL6_2988000_1193700 0.01
R_VDD22_9570 METAL6_2988000_1193700 METAL6_2982200_1193700 0.0116
R_VDD22_9571 METAL6_2982200_1193700 METAL6_2975200_1193700 0.014
R_VDD22_9572 METAL6_2975200_1193700 METAL6_2965900_1193700 0.0186
R_VDD22_9573 METAL6_2965900_1193700 METAL6_2951900_1193700 0.028
R_VDD22_9574 METAL6_2951900_1193700 METAL6_2942200_1193700 0.0194
R_VDD22_9575 METAL6_2942200_1193700 METAL6_2930200_1193700 0.024
R_VDD22_9576 METAL6_2930200_1193700 METAL6_2925600_1193700 0.0092
R_VDD22_9577 METAL6_2925600_1193700 METAL6_2918200_1193700 0.0148
R_VDD22_9578 METAL6_2918200_1193700 METAL6_2913600_1193700 0.0092
R_VDD22_9579 METAL6_2913600_1193700 METAL6_2910900_1193700 0.0054
R_VDD22_9580 METAL6_2910900_1193700 METAL6_2901600_1193700 0.0186
R_VDD22_9581 METAL6_2901600_1193700 METAL6_2898900_1193700 0.0054
R_VDD22_9582 METAL6_2898900_1193700 METAL6_2897100_1193700 0.0036
R_VDD22_9583 METAL6_2897100_1193700 METAL6_2886900_1193700 0.0204
R_VDD22_9584 METAL6_2886900_1193700 METAL6_2874800_1193700 0.0242
R_VDD22_9585 METAL6_2874800_1193700 METAL6_2862800_1193700 0.024
R_VDD22_9586 METAL6_2862800_1193700 METAL6_2860600_1193700 0.0044
R_VDD22_9587 METAL6_2860600_1193700 METAL6_2850800_1193700 0.0196
R_VDD22_9588 METAL6_2850800_1193700 METAL6_2846600_1193700 0.0084
R_VDD22_9589 METAL6_2846600_1193700 METAL6_2843800_1193700 0.0056
R_VDD22_9590 METAL6_2843800_1193700 METAL6_2812000_1193700 0.0636
R_VDD22_9591 METAL6_2812000_1193700 METAL6_2805600_1193700 0.0128
R_VDD22_9592 METAL6_2805600_1193700 METAL6_2800000_1193700 0.0112
R_VDD22_9593 METAL6_2800000_1193700 METAL6_2798800_1193700 0.0024
R_VDD22_9594 METAL6_2798800_1193700 METAL6_2793600_1193700 0.0104
R_VDD22_9595 METAL6_2793600_1193700 METAL6_2788000_1193700 0.0112
R_VDD22_9596 METAL6_2788000_1193700 METAL6_2781600_1193700 0.0128
R_VDD22_9597 METAL6_2781600_1193700 METAL6_2765900_1193700 0.0314
R_VDD22_9598 METAL6_2765900_1193700 METAL6_2751900_1193700 0.028
R_VDD22_9599 METAL6_2751900_1193700 METAL6_2728200_1193700 0.0474
R_VDD22_9600 METAL6_2728200_1193700 METAL6_2710900_1193700 0.0346
R_VDD22_9601 METAL6_2710900_1193700 METAL6_2698900_1193700 0.024
R_VDD22_9602 METAL6_2698900_1193700 METAL6_2686900_1193700 0.024
R_VDD22_9603 METAL6_2686900_1193700 METAL6_2683200_1193700 0.0074
R_VDD22_9604 METAL6_2683200_1193700 METAL6_2676200_1193700 0.014
R_VDD22_9605 METAL6_2676200_1193700 METAL6_2664200_1193700 0.024
R_VDD22_9606 METAL6_2664200_1193700 METAL6_2660600_1193700 0.0072
R_VDD22_9607 METAL6_2660600_1193700 METAL6_2652200_1193700 0.0168
R_VDD22_9608 METAL6_2652200_1193700 METAL6_2646600_1193700 0.0112
R_VDD22_9609 METAL6_2646600_1193700 METAL6_2592400_1193700 0.1084
R_VDD22_9610 METAL6_2592400_1193700 METAL6_2580400_1193700 0.024
R_VDD22_9611 METAL6_2580400_1193700 METAL6_2568400_1193700 0.024
R_VDD22_9612 METAL6_2568400_1193700 METAL6_2565900_1193700 0.005
R_VDD22_9613 METAL6_2565900_1193700 METAL6_2556400_1193700 0.019
R_VDD22_9614 METAL6_2556400_1193700 METAL6_2551900_1193700 0.009
R_VDD22_9615 METAL6_2551900_1193700 METAL6_2537600_1193700 0.0286
R_VDD22_9616 METAL6_2537600_1193700 METAL6_2535400_1193700 0.0044
R_VDD22_9617 METAL6_2535400_1193700 METAL6_2529000_1193700 0.0128
R_VDD22_9618 METAL6_2529000_1193700 METAL6_2528400_1193700 0.0012
R_VDD22_9619 METAL6_2528400_1193700 METAL6_2525600_1193700 0.0056
R_VDD22_9620 METAL6_2525600_1193700 METAL6_2524000_1193700 0.0032
R_VDD22_9621 METAL6_2524000_1193700 METAL6_2524000_1193800 0.0002
R_VDD22_9622 METAL6_2524000_1193800 METAL6_2524000_1205700 0.0238
R_VDD22_9623 METAL6_2524000_1205700 METAL5_2524000_1205700 0.1
R_VDD22_9624 METAL5_2524000_1205700 METAL5_2524000_1217700 0.048
R_VDD22_9625 METAL5_2524000_1217700 METAL5_2517000_1217700 0.028
R_VDD22_9626 METAL5_2517000_1217700 METAL5_2516400_1217700 0.0024
R_VDD22_9627 METAL5_2516400_1217700 METAL5_2513600_1217700 0.0112
R_VDD22_9628 METAL5_2513600_1217700 METAL5_2512000_1217700 0.0064
R_VDD22_9629 METAL5_2512000_1217700 METAL5_2510900_1217700 0.0044
R_VDD22_9630 METAL5_2510900_1217700 METAL5_2505000_1217700 0.0236
R_VDD22_9631 METAL5_2505000_1217700 METAL5_2504400_1217700 0.0024
R_VDD22_9632 METAL5_2504400_1217700 METAL5_2501600_1217700 0.0112
R_VDD22_9633 METAL5_2501600_1217700 METAL5_2500000_1217700 0.0064
R_VDD22_9634 METAL5_2500000_1217700 METAL5_2498900_1217700 0.0044
R_VDD22_9635 METAL5_2498900_1217700 METAL5_2493000_1217700 0.0236
R_VDD22_9636 METAL5_2493000_1217700 METAL5_2493000_1223700 0.024
R_VDD22_9637 METAL5_2493000_1223700 METAL5_2493000_1229700 0.024
R_VDD22_9638 METAL5_2493000_1229700 METAL5_2493000_1235700 0.024
R_VDD22_9639 METAL5_2493000_1235700 METAL5_2489600_1235700 0.0136
R_VDD22_9640 METAL5_2489600_1235700 METAL5_2489600_1238000 0.0092
R_VDD22_9641 METAL5_2489600_1238000 METAL5_2489600_1247700 0.0388
R_VDD22_9642 METAL5_2489600_1247700 METAL5_2488000_1247700 0.0064
R_VDD22_9643 METAL5_2488000_1247700 METAL5_2486900_1247700 0.0044
R_VDD22_9644 METAL5_2486900_1247700 METAL5_2481000_1247700 0.0236
R_VDD22_9645 METAL5_2481000_1247700 METAL5_2481000_1250000 0.0092
R_VDD22_9646 METAL5_2481000_1250000 METAL5_2481000_1259700 0.0388
R_VDD22_9647 METAL5_2481000_1259700 METAL6_2481000_1259700 0.1
R_VDD22_9648 METAL6_2481000_1259700 METAL6_2477600_1259700 0.0068
R_VDD22_9649 METAL6_2477600_1259700 METAL6_2477600_1262000 0.0046
R_VDD22_9650 METAL6_2477600_1262000 METAL6_2477600_1271700 0.0194
R_VDD22_9651 METAL6_2477600_1271700 METAL6_2476000_1271700 0.0032
R_VDD22_9652 METAL6_2476000_1271700 METAL6_2472600_1271700 0.0068
R_VDD22_9653 METAL6_2472600_1271700 METAL6_2469000_1271700 0.0072
R_VDD22_9654 METAL6_2469000_1271700 METAL6_2464000_1271700 0.01
R_VDD22_9655 METAL6_2464000_1271700 METAL6_2460600_1271700 0.0068
R_VDD22_9656 METAL6_2460600_1271700 METAL6_2460600_1273000 0.0026
R_VDD22_9657 METAL6_2460600_1273000 METAL6_2460600_1283700 0.0214
R_VDD22_9658 METAL6_2460600_1283700 METAL6_2460600_1295700 0.024
R_VDD22_9659 METAL6_2460600_1295700 METAL6_2448600_1295700 0.024
R_VDD22_9660 METAL6_2448600_1295700 METAL6_2448600_1302000 0.0126
R_VDD22_9661 METAL6_2448600_1302000 METAL6_2448600_1314000 0.024
R_VDD22_9662 METAL6_2448600_1314000 METAL6_2448600_1326000 0.024
R_VDD22_9663 METAL6_2448600_1326000 METAL6_2448600_1338000 0.024
R_VDD22_9664 METAL6_2448600_1338000 METAL6_2448600_1350000 0.024
R_VDD22_9665 METAL6_2448600_1350000 METAL6_2448600_1357000 0.014
R_VDD22_9666 METAL6_2448600_1357000 METAL6_2448600_1362000 0.01
R_VDD22_9667 METAL6_2448600_1362000 METAL6_2448600_1369000 0.014
R_VDD22_9668 METAL6_2448600_1369000 METAL6_2448600_1374000 0.01
R_VDD22_9669 METAL6_2448600_1374000 METAL6_2448600_1381000 0.014
R_VDD22_9670 METAL6_2448600_1381000 METAL6_2448600_1386600 0.0112
R_VDD22_9671 METAL6_2448600_1386600 METAL6_2448600_1393000 0.0128
R_VDD22_9672 METAL6_2448600_1393000 METAL6_2448600_1405000 0.024
R_VDD22_9673 METAL6_2448600_1405000 METAL6_2448600_1437700 0.0654
R_VDD22_9674 METAL6_2448600_1437700 METAL6_2448600_1449700 0.024
R_VDD22_9675 METAL6_2448600_1449700 METAL6_2448600_1461700 0.024
R_VDD22_9676 METAL6_2448600_1461700 METAL6_2448600_1492300 0.0612
R_VDD22_9677 METAL6_2448600_1492300 METAL6_2448600_1504300 0.024
R_VDD22_9678 METAL6_2448600_1504300 METAL6_2448600_1516300 0.024
R_VDD22_9679 METAL6_2448600_1516300 METAL6_2448600_1528300 0.024
R_VDD22_9680 METAL6_2448600_1528300 METAL6_2448600_1540300 0.024
R_VDD22_9681 METAL6_2448600_1540300 METAL6_2448600_1552300 0.024
R_VDD22_9682 METAL6_2448600_1552300 METAL6_2448600_1554500 0.0044
R_VDD22_9683 METAL6_2448600_1554500 METAL6_2448600_1564300 0.0196
R_VDD22_9684 METAL6_2448600_1564300 METAL6_2448600_1571300 0.014
R_VDD22_9685 METAL6_2448600_1571300 METAL6_2448600_1576300 0.01
R_VDD22_9686 METAL6_2448600_1576300 METAL6_2448600_1714500 0.2764
R_VDD22_9687 METAL6_2448600_1714500 METAL6_2448600_1720500 0.012
R_VDD22_9688 METAL6_2448600_1720500 METAL6_2448600_1726500 0.012
R_VDD22_9689 METAL6_2448600_1726500 METAL6_2448600_1731700 0.0104
R_VDD22_9690 METAL6_2448600_1731700 METAL6_2448600_1738500 0.0136
R_VDD22_9691 METAL6_2448600_1738500 METAL6_2448600_1750500 0.024
R_VDD22_9692 METAL6_2448600_1750500 METAL6_2448600_1762500 0.024
R_VDD22_9693 METAL6_2448600_1762500 METAL6_2448600_1774500 0.024
R_VDD22_9694 METAL6_2448600_1774500 METAL6_2448600_1802500 0.056
R_VDD22_9695 METAL6_2448600_1802500 METAL6_2448600_1814500 0.024
R_VDD22_9696 METAL6_2448600_1814500 METAL6_2448600_1826500 0.024
R_VDD22_9697 METAL6_2448600_1826500 METAL6_2448600_1838500 0.024
R_VDD22_9698 METAL6_2448600_1838500 METAL6_2448600_1852300 0.0276
R_VDD22_9699 METAL6_2448600_1852300 METAL6_2448600_1866300 0.028
R_VDD22_9700 METAL6_2448600_1866300 METAL6_2448600_1902500 0.0724
R_VDD22_9701 METAL6_2448600_1902500 METAL6_2448600_1914500 0.024
R_VDD22_9702 METAL6_2448600_1914500 METAL6_2448600_1926500 0.024
R_VDD22_9703 METAL6_2448600_1926500 METAL6_2448600_1938500 0.024
R_VDD22_9704 METAL6_2448600_1938500 METAL6_2448600_1940500 0.004
R_VDD22_9705 METAL6_2448600_1940500 METAL6_2448600_1950500 0.02
R_VDD22_9706 METAL6_2448600_1950500 METAL6_2446600_1950500 0.004
R_VDD22_9707 METAL6_2446600_1950500 METAL6_2436600_1950500 0.02
R_VDD22_9708 METAL6_2436600_1950500 METAL6_2419100_1950500 0.035
R_VDD22_9709 METAL6_2419100_1950500 METAL6_2407100_1950500 0.024
R_VDD22_9710 METAL6_2407100_1950500 METAL5_2407100_1950500 0.1
R_VDD22_9711 METAL5_2407100_1950500 METAL5_2405600_1950500 0.006
R_VDD22_9712 METAL5_2405600_1950500 METAL5_2402100_1950500 0.014
R_VDD22_9713 METAL5_2402100_1950500 METAL5_2395100_1950500 0.028
R_VDD22_9714 METAL5_2395100_1950500 METAL5_2393600_1950500 0.006
R_VDD22_9715 METAL5_2393600_1950500 METAL5_2383100_1950500 0.042
R_VDD22_9716 METAL5_2383100_1950500 METAL6_2383100_1950500 0.1
R_VDD22_9717 METAL6_2383100_1950500 METAL6_2381600_1950500 0.003
R_VDD22_9718 METAL6_2381600_1950500 METAL6_2371100_1950500 0.021
R_VDD22_9719 METAL6_2371100_1950500 METAL6_2369600_1950500 0.003
R_VDD22_9720 METAL6_2369600_1950500 METAL6_2365900_1950500 0.0074
R_VDD22_9721 METAL6_2365900_1950500 METAL6_2357600_1950500 0.0166
R_VDD22_9722 METAL6_2357600_1950500 METAL6_2351900_1950500 0.0114
R_VDD22_9723 METAL6_2351900_1950500 METAL6_2343700_1950500 0.0164
R_VDD22_9724 METAL6_2343700_1950500 METAL6_2310900_1950500 0.0656
R_VDD22_9725 METAL6_2310900_1950500 METAL6_2298900_1950500 0.024
R_VDD22_9726 METAL6_2298900_1950500 METAL6_2296600_1950500 0.0046
R_VDD22_9727 METAL6_2296600_1950500 METAL6_2296600_1951000 0.001
R_VDD22_9728 METAL6_2296600_1951000 METAL6_2296600_1952500 0.003
R_VDD22_9729 METAL6_2296600_1952500 METAL6_2296600_1962500 0.02
R_VDD22_9730 METAL6_2296600_1962500 METAL6_2296600_1963000 0.001
R_VDD22_9731 METAL6_2296600_1963000 METAL6_2296600_1964500 0.003
R_VDD22_9732 METAL6_2296600_1964500 METAL6_2296600_1975000 0.021
R_VDD22_9733 METAL6_2296600_1975000 METAL6_2296600_1976500 0.003
R_VDD22_9734 METAL6_2296600_1976500 METAL6_2296600_1987000 0.021
R_VDD22_9735 METAL6_2296600_1987000 METAL6_2296600_2014500 0.055
R_VDD22_9736 METAL6_2296600_2014500 METAL6_2296600_2026500 0.024
R_VDD22_9737 METAL6_2296600_2026500 METAL6_2296600_2038500 0.024
R_VDD22_9738 METAL6_2296600_2038500 METAL6_2296600_2114500 0.152
R_VDD22_9739 METAL6_2296600_2114500 METAL6_2296600_2126500 0.024
R_VDD22_9740 METAL6_2296600_2126500 METAL6_2296600_2138500 0.024
R_VDD22_9741 METAL6_2296600_2138500 METAL6_2296600_2147300 0.0176
R_VDD22_9742 METAL6_2296600_2147300 METAL6_2296600_2154300 0.014
R_VDD22_9743 METAL6_2296600_2154300 METAL6_2296600_2163000 0.0174
R_VDD22_9744 METAL6_2296600_2163000 METAL6_2296600_2166300 0.0066
R_VDD22_9745 METAL6_2296600_2166300 METAL6_2296600_2175000 0.0174
R_VDD22_9746 METAL6_2296600_2175000 METAL6_2296600_2178300 0.0066
R_VDD22_9747 METAL6_2296600_2178300 METAL6_2296600_2187000 0.0174
R_VDD22_9748 METAL6_2296600_2187000 METAL6_2296600_2190300 0.0066
R_VDD22_9749 METAL6_2296600_2190300 METAL5_2296600_2190300 0.1
R_VDD22_9750 METAL5_2296600_2190300 METAL5_2286900_2190300 0.0388
R_VDD22_9751 METAL5_2286900_2190300 METAL5_2284600_2190300 0.0092
R_VDD22_9752 METAL5_2284600_2190300 METAL5_2284400_2190300 0.0008
R_VDD22_9753 METAL5_2284400_2190300 METAL5_2272600_2190300 0.0472
R_VDD22_9754 METAL5_2272600_2190300 METAL5_2272400_2190300 0.0008
R_VDD22_9755 METAL5_2272400_2190300 METAL5_2260600_2190300 0.0472
R_VDD22_9756 METAL5_2260600_2190300 METAL5_2260400_2190300 0.0008
R_VDD22_9757 METAL5_2260400_2190300 METAL5_2258600_2190300 0.0072
R_VDD22_9758 METAL5_2258600_2190300 METAL5_2248700_2190300 0.0396
R_VDD22_9759 METAL5_2248700_2190300 METAL5_2248600_2190300 0.0004
R_VDD22_9760 METAL5_2248600_2190300 METAL5_2248400_2190300 0.0008
R_VDD22_9761 METAL5_2248400_2190300 METAL5_2246600_2190300 0.0072
R_VDD22_9762 METAL5_2246600_2190300 METAL5_2236700_2190300 0.0396
R_VDD22_9763 METAL5_2236700_2190300 METAL5_2236600_2190300 0.0004
R_VDD22_9764 METAL5_2236600_2190300 METAL5_2234600_2190300 0.008
R_VDD22_9765 METAL5_2234600_2190300 METAL5_2233900_2190300 0.0028
R_VDD22_9766 METAL5_2233900_2190300 METAL5_2224700_2190300 0.0368
R_VDD22_9767 METAL5_2224700_2190300 METAL5_2222600_2190300 0.0084
R_VDD22_9768 METAL5_2222600_2190300 METAL5_2221900_2190300 0.0028
R_VDD22_9769 METAL5_2221900_2190300 METAL5_2212700_2190300 0.0368
R_VDD22_9770 METAL5_2212700_2190300 METAL5_2210600_2190300 0.0084
R_VDD22_9771 METAL5_2210600_2190300 METAL5_2209900_2190300 0.0028
R_VDD22_9772 METAL5_2209900_2190300 METAL5_2200700_2190300 0.0368
R_VDD22_9773 METAL5_2200700_2190300 METAL5_2189900_2190300 0.0432
R_VDD22_9774 METAL5_2189900_2190300 METAL5_2188700_2190300 0.0048
R_VDD22_9775 METAL5_2188700_2190300 METAL5_2177900_2190300 0.0432
R_VDD22_9776 METAL5_2177900_2190300 METAL5_2176700_2190300 0.0048
R_VDD22_9777 METAL5_2176700_2190300 METAL5_2165900_2190300 0.0432
R_VDD22_9778 METAL5_2165900_2190300 METAL5_2165400_2190300 0.002
R_VDD22_9779 METAL5_2165400_2190300 METAL5_2153900_2190300 0.046
R_VDD22_9780 METAL5_2153900_2190300 METAL5_2153400_2190300 0.002
R_VDD22_9781 METAL5_2153400_2190300 METAL5_2151900_2190300 0.006
R_VDD22_9782 METAL5_2151900_2190300 METAL5_2141900_2190300 0.04
R_VDD22_9783 METAL5_2141900_2190300 METAL5_2141400_2190300 0.002
R_VDD22_9784 METAL5_2141400_2190300 METAL5_2129900_2190300 0.046
R_VDD22_9785 METAL5_2129900_2190300 METAL6_2129900_2190300 0.1
R_VDD22_9786 METAL6_2129900_2190300 METAL6_2129900_2222500 0.0644
R_VDD22_9787 METAL6_2129900_2222500 METAL6_2129900_2234500 0.024
R_VDD22_9788 METAL6_2129900_2234500 METAL6_2129900_2246500 0.024
R_VDD22_9789 METAL6_2129900_2246500 METAL6_2129900_2268500 0.044
R_VDD22_9790 METAL6_2129900_2268500 METAL6_2129900_2288000 0.039
R_VDD22_9791 METAL6_2129900_2288000 METAL6_2129900_2300000 0.024
R_VDD22_9792 METAL6_2129900_2300000 METAL6_2129900_2312000 0.024
R_VDD22_9793 METAL6_2129900_2312000 METAL6_2129900_2326000 0.028
R_VDD22_9794 METAL6_2129900_2326000 METAL6_2129900_2328000 0.004
R_VDD22_9795 METAL6_2129900_2328000 METAL6_2129700_2328000 0.0004
R_VDD22_9796 METAL6_2129700_2328000 METAL6_2125600_2328000 0.0082
R_VDD22_9797 METAL6_2125600_2328000 METAL6_2121400_2328000 0.0084
R_VDD22_9798 METAL6_2121400_2328000 METAL6_2117900_2328000 0.007
R_VDD22_9799 METAL6_2117900_2328000 METAL6_2113900_2328000 0.008
R_VDD22_9800 METAL6_2113900_2328000 METAL6_2113600_2328000 0.0006
R_VDD22_9801 METAL6_2113600_2328000 METAL6_2101900_2328000 0.0234
R_VDD22_9802 METAL6_2101900_2328000 METAL6_2101600_2328000 0.0006
R_VDD22_9803 METAL6_2101600_2328000 METAL6_2089900_2328000 0.0234
R_VDD22_9804 METAL6_2089900_2328000 METAL6_2079700_2328000 0.0204
R_VDD22_9805 METAL6_2079700_2328000 METAL6_2077900_2328000 0.0036
R_VDD22_9806 METAL6_2077900_2328000 METAL6_2067700_2328000 0.0204
R_VDD22_9807 METAL6_2067700_2328000 METAL6_2060600_2328000 0.0142
R_VDD22_9808 METAL6_2060600_2328000 METAL6_2058800_2328000 0.0036
R_VDD22_9809 METAL6_2058800_2328000 METAL6_2055700_2328000 0.0062
R_VDD22_9810 METAL6_2055700_2328000 METAL6_2046800_2328000 0.0178
R_VDD22_9811 METAL6_2046800_2328000 METAL6_2046600_2328000 0.0004
R_VDD22_9812 METAL6_2046600_2328000 METAL6_2046400_2328000 0.0004
R_VDD22_9813 METAL6_2046400_2328000 METAL6_2043700_2328000 0.0054
R_VDD22_9814 METAL6_2043700_2328000 METAL6_2034800_2328000 0.0178
R_VDD22_9815 METAL6_2034800_2328000 METAL6_2031700_2328000 0.0062
R_VDD22_9816 METAL6_2031700_2328000 METAL6_2031700_2329000 0.002
R_VDD22_9817 METAL6_2031700_2329000 METAL6_2030900_2329000 0.0016
R_VDD22_9818 METAL6_2030900_2329000 METAL6_2026400_2329000 0.009
R_VDD22_9819 METAL6_2026400_2329000 METAL6_2021200_2329000 0.0104
R_VDD22_9820 METAL6_2021200_2329000 METAL6_2019700_2329000 0.003
R_VDD22_9821 METAL6_2019700_2329000 METAL6_2018900_2329000 0.0016
R_VDD22_9822 METAL6_2018900_2329000 METAL6_2014400_2329000 0.009
R_VDD22_9823 METAL6_2014400_2329000 METAL6_2012000_2329000 0.0048
R_VDD22_9824 METAL6_2012000_2329000 METAL6_2006900_2329000 0.0102
R_VDD22_9825 METAL6_2006900_2329000 METAL6_2002400_2329000 0.009
R_VDD22_9826 METAL6_2002400_2329000 METAL6_2000000_2329000 0.0048
R_VDD22_9827 METAL6_2000000_2329000 METAL6_1988000_2329000 0.024
R_VDD22_9828 METAL6_1988000_2329000 METAL6_1951900_2329000 0.0722
R_VDD22_9829 METAL6_1951900_2329000 METAL6_1951800_2329000 0.0002
R_VDD22_9830 METAL6_1951800_2329000 METAL6_1939800_2329000 0.024
R_VDD22_9831 METAL6_1939800_2329000 METAL6_1931200_2329000 0.0172
R_VDD22_9832 METAL6_1931200_2329000 METAL6_1927800_2329000 0.0068
R_VDD22_9833 METAL6_1927800_2329000 METAL6_1926200_2329000 0.0032
R_VDD22_9834 METAL6_1926200_2329000 METAL6_1925600_2329000 0.0012
R_VDD22_9835 METAL6_1925600_2329000 METAL6_1919200_2329000 0.0128
R_VDD22_9836 METAL6_1919200_2329000 METAL6_1913600_2329000 0.0112
R_VDD22_9837 METAL6_1913600_2329000 METAL6_1907400_2329000 0.0124
R_VDD22_9838 METAL6_1907400_2329000 METAL6_1907200_2329000 0.0004
R_VDD22_9839 METAL6_1907200_2329000 METAL6_1901600_2329000 0.0112
R_VDD22_9840 METAL6_1901600_2329000 METAL6_1900700_2329000 0.0018
R_VDD22_9841 METAL6_1900700_2329000 METAL6_1895200_2329000 0.011
R_VDD22_9842 METAL6_1895200_2329000 METAL6_1895200_2338000 0.018
R_VDD22_9843 METAL6_1895200_2338000 METAL6_1889600_2338000 0.0112
R_VDD22_9844 METAL6_1889600_2338000 METAL6_1889600_2340000 0.004
R_VDD22_9845 METAL6_1889600_2340000 METAL6_1889600_2341000 0.002
R_VDD22_9846 METAL6_1889600_2341000 METAL6_1889400_2341000 0.0004
R_VDD22_9847 METAL6_1889400_2341000 METAL6_1888700_2341000 0.0014
R_VDD22_9848 METAL6_1888700_2341000 METAL6_1883200_2341000 0.011
R_VDD22_9849 METAL6_1883200_2341000 METAL6_1877400_2341000 0.0116
R_VDD22_9850 METAL6_1877400_2341000 METAL6_1876700_2341000 0.0014
R_VDD22_9851 METAL6_1876700_2341000 METAL6_1874700_2341000 0.004
R_VDD22_9852 METAL6_1874700_2341000 METAL6_1871200_2341000 0.007
R_VDD22_9853 METAL6_1871200_2341000 METAL6_1871200_2350000 0.018
R_VDD22_9854 METAL6_1871200_2350000 METAL6_1870600_2350000 0.0012
R_VDD22_9855 METAL6_1870600_2350000 METAL6_1865400_2350000 0.0104
R_VDD22_9856 METAL6_1865400_2350000 METAL6_1865400_2352000 0.004
R_VDD22_9857 METAL6_1865400_2352000 METAL6_1865400_2353000 0.002
R_VDD22_9858 METAL6_1865400_2353000 METAL6_1864700_2353000 0.0014
R_VDD22_9859 METAL6_1864700_2353000 METAL6_1858600_2353000 0.0122
R_VDD22_9860 METAL6_1858600_2353000 METAL6_1858400_2353000 0.0004
R_VDD22_9861 METAL6_1858400_2353000 METAL6_1853400_2353000 0.01
R_VDD22_9862 METAL6_1853400_2353000 METAL6_1852700_2353000 0.0014
R_VDD22_9863 METAL6_1852700_2353000 METAL6_1846800_2353000 0.0118
R_VDD22_9864 METAL6_1846800_2353000 METAL6_1846600_2353000 0.0004
R_VDD22_9865 METAL6_1846600_2353000 METAL6_1846400_2353000 0.0004
R_VDD22_9866 METAL6_1846400_2353000 METAL6_1844800_2353000 0.0032
R_VDD22_9867 METAL6_1844800_2353000 METAL6_1834600_2353000 0.0204
R_VDD22_9868 METAL6_1834600_2353000 METAL6_1834400_2353000 0.0004
R_VDD22_9869 METAL6_1834400_2353000 METAL6_1832800_2353000 0.0032
R_VDD22_9870 METAL6_1832800_2353000 METAL6_1822600_2353000 0.0204
R_VDD22_9871 METAL6_1822600_2353000 METAL6_1822400_2353000 0.0004
R_VDD22_9872 METAL6_1822400_2353000 METAL6_1820800_2353000 0.0032
R_VDD22_9873 METAL6_1820800_2353000 METAL6_1812000_2353000 0.0176
R_VDD22_9874 METAL6_1812000_2353000 METAL6_1800000_2353000 0.024
R_VDD22_9875 METAL6_1800000_2353000 METAL6_1788000_2353000 0.024
R_VDD22_9876 METAL6_1788000_2353000 METAL6_1755700_2353000 0.0646
R_VDD22_9877 METAL6_1755700_2353000 METAL6_1753800_2353000 0.0038
R_VDD22_9878 METAL6_1753800_2353000 METAL6_1751800_2353000 0.004
R_VDD22_9879 METAL6_1751800_2353000 METAL6_1751400_2353000 0.0008
R_VDD22_9880 METAL6_1751400_2353000 METAL6_1744000_2353000 0.0148
R_VDD22_9881 METAL6_1744000_2353000 METAL6_1743700_2353000 0.0006
R_VDD22_9882 METAL6_1743700_2353000 METAL6_1741800_2353000 0.0038
R_VDD22_9883 METAL6_1741800_2353000 METAL6_1739800_2353000 0.004
R_VDD22_9884 METAL6_1739800_2353000 METAL6_1731700_2353000 0.0162
R_VDD22_9885 METAL6_1731700_2353000 METAL6_1729800_2353000 0.0038
R_VDD22_9886 METAL6_1729800_2353000 METAL6_1727800_2353000 0.004
R_VDD22_9887 METAL6_1727800_2353000 METAL6_1719700_2353000 0.0162
R_VDD22_9888 METAL6_1719700_2353000 METAL6_1717800_2353000 0.0038
R_VDD22_9889 METAL6_1717800_2353000 METAL6_1710800_2353000 0.014
R_VDD22_9890 METAL6_1710800_2353000 METAL6_1707700_2353000 0.0062
R_VDD22_9891 METAL6_1707700_2353000 METAL6_1699000_2353000 0.0174
R_VDD22_9892 METAL6_1699000_2353000 METAL6_1692000_2353000 0.014
R_VDD22_9893 METAL6_1692000_2353000 METAL6_1680000_2353000 0.024
R_VDD22_9894 METAL6_1680000_2353000 METAL6_1670800_2353000 0.0184
R_VDD22_9895 METAL6_1670800_2353000 METAL6_1668000_2353000 0.0056
R_VDD22_9896 METAL6_1668000_2353000 METAL6_1658800_2353000 0.0184
R_VDD22_9897 METAL6_1658800_2353000 METAL6_1646800_2353000 0.024
R_VDD22_9898 METAL6_1646800_2353000 METAL6_1634800_2353000 0.024
R_VDD22_9899 METAL6_1634800_2353000 METAL6_1632800_2353000 0.004
R_VDD22_9900 METAL6_1632800_2353000 METAL6_1627800_2353000 0.01
R_VDD22_9901 METAL6_1627800_2353000 METAL6_1615800_2353000 0.024
R_VDD22_9902 METAL6_1615800_2353000 METAL6_1612700_2353000 0.0062
R_VDD22_9903 METAL6_1612700_2353000 METAL6_1612000_2353000 0.0014
R_VDD22_9904 METAL6_1612000_2353000 METAL6_1607900_2353000 0.0082
R_VDD22_9905 METAL6_1607900_2353000 METAL6_1603800_2353000 0.0082
R_VDD22_9906 METAL6_1603800_2353000 METAL5_1603800_2353000 0.1
R_VDD22_9907 METAL5_1603800_2353000 METAL5_1603800_2362000 0.036
R_VDD22_9908 METAL5_1603800_2362000 METAL5_1603800_2364000 0.008
R_VDD22_9909 METAL5_1603800_2364000 METAL5_1603800_2365000 0.004
R_VDD22_9910 METAL5_1603800_2365000 METAL5_1603800_2374000 0.036
R_VDD22_9911 METAL5_1603800_2374000 METAL5_1603800_2376000 0.008
R_VDD22_9912 METAL5_1603800_2376000 METAL5_1603800_2377000 0.004
R_VDD22_9913 METAL5_1603800_2377000 METAL5_1603800_2388000 0.044
R_VDD22_9914 METAL5_1603800_2388000 METAL5_1603800_2389000 0.004
R_VDD22_9915 METAL5_1603800_2389000 METAL5_1603800_2395000 0.024
R_VDD22_9916 METAL5_1603800_2395000 METAL5_1603800_2400000 0.02
R_VDD22_9917 METAL5_1603800_2400000 METAL5_1603800_2401000 0.004
R_VDD22_9918 METAL5_1603800_2401000 METAL6_1603800_2401000 0.1
R_VDD22_9919 METAL6_1603800_2401000 METAL6_1603800_2407000 0.012
R_VDD22_9920 METAL6_1603800_2407000 METAL6_1603800_2412000 0.01
R_VDD22_9921 METAL6_1603800_2412000 METAL6_1600700_2412000 0.0062
R_VDD22_9922 METAL6_1600700_2412000 METAL6_1600700_2413000 0.002
R_VDD22_9923 METAL6_1600700_2413000 METAL6_1600700_2419000 0.012
R_VDD22_9924 METAL6_1600700_2419000 METAL6_1600700_2424000 0.01
R_VDD22_9925 METAL6_1600700_2424000 METAL6_1600700_2436000 0.024
R_VDD22_9926 METAL6_1600700_2436000 METAL6_1600700_2438000 0.004
R_VDD22_9927 METAL6_1600700_2438000 METAL6_1600700_2444000 0.012
R_VDD22_9928 METAL6_1600700_2444000 METAL6_1600700_2450000 0.012
R_VDD22_9929 METAL6_1600700_2450000 METAL6_1600700_2456000 0.012
R_VDD22_9930 METAL6_1600700_2456000 METAL6_1600700_2462000 0.012
R_VDD22_9931 METAL6_1600700_2462000 METAL6_1600700_2468000 0.012
R_VDD22_9932 METAL6_1600700_2468000 METAL6_1600700_2481000 0.026
R_VDD22_9933 METAL6_1600700_2481000 METAL6_1600700_2493000 0.024
R_VDD22_9934 METAL6_1600700_2493000 METAL6_1600700_2505000 0.024
R_VDD22_9935 METAL6_1600700_2505000 METAL6_1600700_2512000 0.014
R_VDD22_9936 METAL6_1600700_2512000 METAL6_1600700_2524000 0.024
R_VDD22_9937 METAL6_1600700_2524000 METAL6_1600700_2529700 0.0114
R_VDD22_9938 METAL6_1600700_2529700 METAL6_1600000_2529700 0.0014
R_VDD22_9939 METAL6_1600000_2529700 METAL6_1588700_2529700 0.0226
R_VDD22_9940 METAL6_1588700_2529700 METAL6_1588000_2529700 0.0014
R_VDD22_9941 METAL6_1588000_2529700 METAL6_1576700_2529700 0.0226
R_VDD22_9942 METAL6_1576700_2529700 METAL6_1576000_2529700 0.0014
R_VDD22_9943 METAL6_1576000_2529700 METAL6_1574700_2529700 0.0026
R_VDD22_9944 METAL6_1574700_2529700 METAL6_1557000_2529700 0.0354
R_VDD22_9945 METAL6_1557000_2529700 METAL6_1555400_2529700 0.0032
R_VDD22_9946 METAL6_1555400_2529700 METAL6_1551800_2529700 0.0072
R_VDD22_9947 METAL6_1551800_2529700 METAL6_1539800_2529700 0.024
R_VDD22_9948 METAL6_1539800_2529700 METAL6_1527800_2529700 0.024
R_VDD22_9949 METAL6_1527800_2529700 METAL6_1512000_2529700 0.0316
R_VDD22_9950 METAL6_1512000_2529700 METAL6_1510400_2529700 0.0032
R_VDD22_9951 METAL6_1510400_2529700 METAL6_1503400_2529700 0.014
R_VDD22_9952 METAL6_1503400_2529700 METAL6_1500000_2529700 0.0068
R_VDD22_9953 METAL6_1500000_2529700 METAL6_1498300_2529700 0.0034
R_VDD22_9954 METAL6_1498300_2529700 METAL6_1491400_2529700 0.0138
R_VDD22_9955 METAL6_1491400_2529700 METAL6_1488000_2529700 0.0068
R_VDD22_9956 METAL6_1488000_2529700 METAL6_1479400_2529700 0.0172
R_VDD22_9957 METAL6_1479400_2529700 METAL6_1443700_2529700 0.0714
R_VDD22_9958 METAL6_1443700_2529700 METAL6_1432800_2529700 0.0218
R_VDD22_9959 METAL6_1432800_2529700 METAL6_1431700_2529700 0.0022
R_VDD22_9960 METAL6_1431700_2529700 METAL6_1424000_2529700 0.0154
R_VDD22_9961 METAL6_1424000_2529700 METAL6_1419700_2529700 0.0086
R_VDD22_9962 METAL6_1419700_2529700 METAL6_1412000_2529700 0.0154
R_VDD22_9963 METAL6_1412000_2529700 METAL6_1400000_2529700 0.024
R_VDD22_9964 METAL6_1400000_2529700 METAL6_1388000_2529700 0.024
R_VDD22_9965 METAL6_1388000_2529700 METAL6_1337000_2529700 0.102
R_VDD22_9966 METAL6_1337000_2529700 METAL6_1325000_2529700 0.024
R_VDD22_9967 METAL6_1325000_2529700 METAL6_1324000_2529700 0.002
R_VDD22_9968 METAL6_1324000_2529700 METAL6_1323800_2529700 0.0004
R_VDD22_9969 METAL6_1323800_2529700 METAL6_1313000_2529700 0.0216
R_VDD22_9970 METAL6_1313000_2529700 METAL6_1312000_2529700 0.002
R_VDD22_9971 METAL6_1312000_2529700 METAL6_1311800_2529700 0.0004
R_VDD22_9972 METAL6_1311800_2529700 METAL6_1301000_2529700 0.0216
R_VDD22_9973 METAL6_1301000_2529700 METAL6_1300000_2529700 0.002
R_VDD22_9974 METAL6_1300000_2529700 METAL6_1299800_2529700 0.0004
R_VDD22_9975 METAL6_1299800_2529700 METAL6_1289000_2529700 0.0216
R_VDD22_9976 METAL6_1289000_2529700 METAL6_1288000_2529700 0.002
R_VDD22_9977 METAL6_1288000_2529700 METAL6_1287800_2529700 0.0004
R_VDD22_9978 METAL6_1287800_2529700 METAL6_1286700_2529700 0.0022
R_VDD22_9979 METAL6_1286700_2529700 METAL6_1274700_2529700 0.024
R_VDD22_9980 METAL6_1274700_2529700 METAL6_1266800_2529700 0.0158
R_VDD22_9981 METAL6_1266800_2529700 METAL6_1262700_2529700 0.0082
R_VDD22_9982 METAL6_1262700_2529700 METAL6_1259800_2529700 0.0058
R_VDD22_9983 METAL6_1259800_2529700 METAL6_1258300_2529700 0.003
R_VDD22_9984 METAL6_1258300_2529700 METAL6_1253300_2529700 0.01
R_VDD22_9985 METAL6_1253300_2529700 METAL6_1247800_2529700 0.011
R_VDD22_9986 METAL6_1247800_2529700 METAL6_1246300_2529700 0.003
R_VDD22_9987 METAL6_1246300_2529700 METAL6_1242700_2529700 0.0072
R_VDD22_9988 METAL6_1242700_2529700 METAL6_1235800_2529700 0.0138
R_VDD22_9989 METAL6_1235800_2529700 METAL6_1234300_2529700 0.003
R_VDD22_9990 METAL6_1234300_2529700 METAL6_1230700_2529700 0.0072
R_VDD22_9991 METAL6_1230700_2529700 METAL6_1222300_2529700 0.0168
R_VDD22_9992 METAL6_1222300_2529700 METAL6_1222300_2536000 0.0126
R_VDD22_9993 METAL6_1222300_2536000 METAL6_1222300_2541700 0.0114
R_VDD22_9994 METAL6_1222300_2541700 METAL6_1222300_2548000 0.0126
R_VDD22_9995 METAL6_1222300_2548000 METAL6_1222300_2553700 0.0114
R_VDD22_9996 METAL6_1222300_2553700 METAL6_1222300_2589000 0.0706
R_VDD22_9997 METAL6_1222300_2589000 METAL6_1222300_2603000 0.028
R_VDD22_9998 METAL6_1222300_2603000 METAL6_1222300_2644000 0.082
R_VDD22_9999 METAL6_1222300_2644000 METAL6_1222300_2656000 0.024
R_VDD22_10000 METAL6_1222300_2656000 METAL6_1222300_2665700 0.0194
R_VDD22_10001 METAL6_1222300_2665700 METAL6_1222300_2668000 0.0046
R_VDD22_10002 METAL6_1222300_2668000 METAL6_1222300_2701000 0.066
R_VDD22_10003 METAL6_1222300_2701000 METAL6_1222300_2701700 0.0014
R_VDD22_10004 METAL6_1222300_2701700 METAL6_1222300_2713000 0.0226
R_VDD22_10005 METAL6_1222300_2713000 METAL6_1222300_2713700 0.0014
R_VDD22_10006 METAL6_1222300_2713700 METAL6_1222300_2724000 0.0206
R_VDD22_10007 METAL6_1222300_2724000 METAL6_1222300_2725000 0.002
R_VDD22_10008 METAL6_1222300_2725000 METAL6_1222300_2725700 0.0014
R_VDD22_10009 METAL6_1222300_2725700 METAL6_1222300_2736000 0.0206
R_VDD22_10010 METAL6_1222300_2736000 METAL6_1222300_2737000 0.002
R_VDD22_10011 METAL6_1222300_2737000 METAL6_1222300_2748000 0.022
R_VDD22_10012 METAL6_1222300_2748000 METAL6_1222300_2777000 0.058
R_VDD22_10013 METAL6_1222300_2777000 METAL6_1222300_2789000 0.024
R_VDD22_10014 METAL6_1222300_2789000 METAL6_1222300_2801000 0.024
R_VDD22_10015 METAL6_1222300_2801000 METAL6_1222300_2801700 0.0014
R_VDD22_10016 METAL6_1222300_2801700 METAL6_1222300_2803000 0.0026
R_VDD22_10017 METAL6_1222300_2803000 METAL6_1222300_2808000 0.01
R_VDD22_10018 METAL6_1222300_2808000 METAL6_1222300_2813700 0.0114
R_VDD22_10019 METAL6_1222300_2813700 METAL6_1222300_2825700 0.024
R_VDD22_10020 METAL6_1222300_2825700 METAL6_1222300_2901700 0.152
R_VDD22_10021 METAL6_1222300_2901700 METAL6_1222300_2913000 0.0226
R_VDD22_10022 METAL6_1222300_2913000 METAL6_1222300_2913700 0.0014
R_VDD22_10023 METAL6_1222300_2913700 METAL6_1230700_2913700 0.0168
R_VDD22_10024 METAL6_1230700_2913700 METAL6_1234300_2913700 0.0072
R_VDD22_10025 METAL6_1246300_2913700 METAL6_1234300_2913700 0.024
I_VDD22_36 METAL6_1246300_2913700 gnd 0.0022

V_VDD23_16 METAL5_3500000_1000000 gnd 1
R_VDD23_10026 METAL5_3500000_1000000 METAL5_3490500_1000000 0.038
R_VDD23_10027 METAL5_3490500_1000000 METAL6_3490500_1000000 0.1
R_VDD23_10028 METAL6_3490500_1000000 METAL6_3478500_1000000 0.024
R_VDD23_10029 METAL6_3478500_1000000 METAL6_3478500_1007000 0.014
R_VDD23_10030 METAL6_3478500_1007000 METAL6_3478500_1012000 0.01
R_VDD23_10031 METAL6_3478500_1012000 METAL6_3478500_1014000 0.004
R_VDD23_10032 METAL6_3478500_1014000 METAL6_3478500_1019000 0.01
R_VDD23_10033 METAL6_3478500_1019000 METAL6_3478500_1023700 0.0094
R_VDD23_10034 METAL6_3478500_1023700 METAL6_3478500_1025400 0.0034
R_VDD23_10035 METAL6_3478500_1025400 METAL6_3477000_1025400 0.003
R_VDD23_10036 METAL6_3477000_1025400 METAL6_3466500_1025400 0.021
R_VDD23_10037 METAL6_3466500_1025400 METAL6_3465000_1025400 0.003
R_VDD23_10038 METAL6_3465000_1025400 METAL6_3454500_1025400 0.021
R_VDD23_10039 METAL6_3454500_1025400 METAL6_3453000_1025400 0.003
R_VDD23_10040 METAL6_3453000_1025400 METAL6_3442500_1025400 0.021
R_VDD23_10041 METAL6_3442500_1025400 METAL6_3360400_1025400 0.1642
R_VDD23_10042 METAL6_3360400_1025400 METAL6_3360400_1026000 0.0012
R_VDD23_10043 METAL6_3360400_1026000 METAL6_3360400_1029800 0.0076
R_VDD23_10044 METAL6_3360400_1029800 METAL6_3360400_1031000 0.0024
R_VDD23_10045 METAL6_3360400_1031000 METAL6_3360400_1035700 0.0094
R_VDD23_10046 METAL6_3360400_1035700 METAL6_3360400_1037400 0.0034
R_VDD23_10047 METAL6_3360400_1037400 METAL6_3360400_1038000 0.0012
R_VDD23_10048 METAL6_3360400_1038000 METAL6_3360400_1041800 0.0076
R_VDD23_10049 METAL6_3360400_1041800 METAL6_3360400_1042700 0.0018
R_VDD23_10050 METAL6_3360400_1042700 METAL6_3360400_1043000 0.0006
R_VDD23_10051 METAL6_3360400_1043000 METAL6_3360400_1047700 0.0094
R_VDD23_10052 METAL6_3360400_1047700 METAL6_3360400_1049400 0.0034
R_VDD23_10053 METAL6_3360400_1049400 METAL6_3360400_1049800 0.0008
R_VDD23_10054 METAL6_3360400_1049800 METAL6_3360400_1053800 0.008
R_VDD23_10055 METAL6_3360400_1053800 METAL6_3360400_1054700 0.0018
R_VDD23_10056 METAL6_3360400_1054700 METAL6_3360400_1061400 0.0134
R_VDD23_10057 METAL6_3360400_1061400 METAL6_3360400_1061800 0.0008
R_VDD23_10058 METAL6_3360400_1061800 METAL6_3360400_1066700 0.0098
R_VDD23_10059 METAL6_3360400_1066700 METAL6_3360400_1073400 0.0134
R_VDD23_10060 METAL6_3360400_1073400 METAL6_3360400_1073800 0.0008
R_VDD23_10061 METAL6_3360400_1073800 METAL6_3360400_1074000 0.0004
R_VDD23_10062 METAL6_3360400_1074000 METAL6_3360400_1074500 0.001
R_VDD23_10063 METAL6_3360400_1074500 METAL6_3360400_1085400 0.0218
R_VDD23_10064 METAL6_3360400_1085400 METAL6_3360400_1085800 0.0008
R_VDD23_10065 METAL6_3360400_1085800 METAL6_3360400_1086000 0.0004
R_VDD23_10066 METAL6_3360400_1086000 METAL6_3360400_1086300 0.0006
R_VDD23_10067 METAL6_3360400_1086300 METAL6_3360400_1086500 0.0004
R_VDD23_10068 METAL6_3360400_1086500 METAL6_3360400_1088000 0.003
R_VDD23_10069 METAL6_3360400_1088000 METAL6_3360400_1096800 0.0176
R_VDD23_10070 METAL6_3360400_1096800 METAL5_3360400_1096800 0.1
R_VDD23_10071 METAL5_3360400_1096800 METAL5_3360400_1097800 0.004
R_VDD23_10072 METAL5_3360400_1097800 METAL5_3360400_1098000 0.0008
R_VDD23_10073 METAL5_3360400_1098000 METAL5_3360400_1098300 0.0012
R_VDD23_10074 METAL5_3360400_1098300 METAL5_3360400_1098500 0.0008
R_VDD23_10075 METAL5_3360400_1098500 METAL5_3360400_1100000 0.006
R_VDD23_10076 METAL5_3360400_1100000 METAL5_3360400_1108800 0.0352
R_VDD23_10077 METAL5_3360400_1108800 METAL5_3360400_1110000 0.0048
R_VDD23_10078 METAL5_3360400_1110000 METAL5_3360400_1110300 0.0012
R_VDD23_10079 METAL5_3360400_1110300 METAL5_3360400_1110500 0.0008
R_VDD23_10080 METAL5_3360400_1110500 METAL5_3360400_1112000 0.006
R_VDD23_10081 METAL5_3360400_1112000 METAL5_3360400_1120800 0.0352
R_VDD23_10082 METAL5_3360400_1120800 METAL5_3348400_1120800 0.048
R_VDD23_10083 METAL5_3348400_1120800 METAL5_3336400_1120800 0.048
R_VDD23_10084 METAL5_3336400_1120800 METAL5_3336400_1122300 0.006
R_VDD23_10085 METAL5_3336400_1122300 METAL5_3336400_1122500 0.0008
R_VDD23_10086 METAL5_3336400_1122500 METAL5_3336400_1129300 0.0272
R_VDD23_10087 METAL5_3336400_1129300 METAL5_3336400_1132800 0.014
R_VDD23_10088 METAL5_3336400_1132800 METAL5_3324400_1132800 0.048
R_VDD23_10089 METAL5_3324400_1132800 METAL5_3312400_1132800 0.048
R_VDD23_10090 METAL5_3312400_1132800 METAL5_3312000_1132800 0.0016
R_VDD23_10091 METAL5_3312000_1132800 METAL5_3305400_1132800 0.0264
R_VDD23_10092 METAL5_3305400_1132800 METAL5_3300400_1132800 0.02
R_VDD23_10093 METAL5_3300400_1132800 METAL5_3300000_1132800 0.0016
R_VDD23_10094 METAL5_3300000_1132800 METAL5_3299000_1132800 0.004
R_VDD23_10095 METAL5_3299000_1132800 METAL5_3288400_1132800 0.0424
R_VDD23_10096 METAL5_3288400_1132800 METAL6_3288400_1132800 0.1
R_VDD23_10097 METAL6_3288400_1132800 METAL6_3288400_1134300 0.003
R_VDD23_10098 METAL6_3288400_1134300 METAL6_3288000_1134300 0.0008
R_VDD23_10099 METAL6_3288000_1134300 METAL6_3287000_1134300 0.002
R_VDD23_10100 METAL6_3287000_1134300 METAL6_3276400_1134300 0.0212
R_VDD23_10101 METAL6_3276400_1134300 METAL6_3275000_1134300 0.0028
R_VDD23_10102 METAL6_3275000_1134300 METAL6_3263000_1134300 0.024
R_VDD23_10103 METAL6_3263000_1134300 METAL6_3260400_1134300 0.0052
R_VDD23_10104 METAL6_3260400_1134300 METAL6_3243500_1134300 0.0338
R_VDD23_10105 METAL6_3243500_1134300 METAL6_3231500_1134300 0.024
R_VDD23_10106 METAL6_3231500_1134300 METAL6_3224500_1134300 0.014
R_VDD23_10107 METAL6_3224500_1134300 METAL6_3219500_1134300 0.01
R_VDD23_10108 METAL6_3219500_1134300 METAL6_3212500_1134300 0.014
R_VDD23_10109 METAL6_3212500_1134300 METAL6_3212000_1134300 0.001
R_VDD23_10110 METAL6_3212000_1134300 METAL6_3207500_1134300 0.009
R_VDD23_10111 METAL6_3207500_1134300 METAL6_3200500_1134300 0.014
R_VDD23_10112 METAL6_3200500_1134300 METAL6_3200000_1134300 0.001
R_VDD23_10113 METAL6_3200000_1134300 METAL6_3188000_1134300 0.024
R_VDD23_10114 METAL6_3188000_1134300 METAL6_3179500_1134300 0.017
R_VDD23_10115 METAL6_3179500_1134300 METAL6_3167500_1134300 0.024
R_VDD23_10116 METAL6_3167500_1134300 METAL6_3165900_1134300 0.0032
R_VDD23_10117 METAL6_3165900_1134300 METAL6_3155500_1134300 0.0208
R_VDD23_10118 METAL6_3155500_1134300 METAL6_3124000_1134300 0.063
R_VDD23_10119 METAL6_3124000_1134300 METAL6_3112000_1134300 0.024
R_VDD23_10120 METAL6_3112000_1134300 METAL6_3111200_1134300 0.0016
R_VDD23_10121 METAL6_3111200_1134300 METAL6_3110900_1134300 0.0006
R_VDD23_10122 METAL6_3110900_1134300 METAL6_3100000_1134300 0.0218
R_VDD23_10123 METAL6_3100000_1134300 METAL6_3099200_1134300 0.0016
R_VDD23_10124 METAL6_3099200_1134300 METAL6_3098900_1134300 0.0006
R_VDD23_10125 METAL6_3098900_1134300 METAL6_3088000_1134300 0.0218
R_VDD23_10126 METAL6_3088000_1134300 METAL6_3087200_1134300 0.0016
R_VDD23_10127 METAL6_3087200_1134300 METAL6_3086900_1134300 0.0006
R_VDD23_10128 METAL6_3086900_1134300 METAL6_3076000_1134300 0.0218
R_VDD23_10129 METAL6_3076000_1134300 METAL6_3075200_1134300 0.0016
R_VDD23_10130 METAL6_3075200_1134300 METAL6_3068200_1134300 0.014
R_VDD23_10131 METAL6_3068200_1134300 METAL6_3064000_1134300 0.0084
R_VDD23_10132 METAL6_3064000_1134300 METAL6_3063200_1134300 0.0016
R_VDD23_10133 METAL6_3063200_1134300 METAL6_3060600_1134300 0.0052
R_VDD23_10134 METAL6_3060600_1134300 METAL6_3052000_1134300 0.0172
R_VDD23_10135 METAL6_3052000_1134300 METAL6_3035200_1134300 0.0336
R_VDD23_10136 METAL6_3035200_1134300 METAL6_3024000_1134300 0.0224
R_VDD23_10137 METAL6_3024000_1134300 METAL6_3023200_1134300 0.0016
R_VDD23_10138 METAL6_3023200_1134300 METAL6_3018200_1134300 0.01
R_VDD23_10139 METAL6_3018200_1134300 METAL6_3012000_1134300 0.0124
R_VDD23_10140 METAL6_3012000_1134300 METAL6_3011200_1134300 0.0016
R_VDD23_10141 METAL6_3011200_1134300 METAL6_3006200_1134300 0.01
R_VDD23_10142 METAL6_3006200_1134300 METAL6_3006200_1134500 0.0004
R_VDD23_10143 METAL6_3006200_1134500 METAL5_3006200_1134500 0.1
R_VDD23_10144 METAL5_3006200_1134500 METAL5_3000000_1134500 0.0248
R_VDD23_10145 METAL5_3000000_1134500 METAL5_2994200_1134500 0.0232
R_VDD23_10146 METAL5_2994200_1134500 METAL5_2993000_1134500 0.0048
R_VDD23_10147 METAL5_2993000_1134500 METAL5_2988000_1134500 0.02
R_VDD23_10148 METAL5_2988000_1134500 METAL5_2982200_1134500 0.0232
R_VDD23_10149 METAL5_2982200_1134500 METAL6_2982200_1134500 0.1
R_VDD23_10150 METAL6_2982200_1134500 METAL6_2975200_1134500 0.014
R_VDD23_10151 METAL6_2975200_1134500 METAL6_2975200_1141300 0.0136
R_VDD23_10152 METAL6_2975200_1141300 METAL6_2970200_1141300 0.01
R_VDD23_10153 METAL6_2970200_1141300 METAL6_2970200_1146300 0.01
R_VDD23_10154 METAL6_2970200_1146300 METAL6_2970200_1153300 0.014
R_VDD23_10155 METAL6_2970200_1153300 METAL6_2965900_1153300 0.0086
R_VDD23_10156 METAL6_2965900_1153300 METAL6_2951900_1153300 0.028
R_VDD23_10157 METAL6_2951900_1153300 METAL6_2942200_1153300 0.0194
R_VDD23_10158 METAL6_2942200_1153300 METAL6_2930200_1153300 0.024
R_VDD23_10159 METAL6_2930200_1153300 METAL6_2925600_1153300 0.0092
R_VDD23_10160 METAL6_2925600_1153300 METAL6_2918200_1153300 0.0148
R_VDD23_10161 METAL6_2918200_1153300 METAL6_2913600_1153300 0.0092
R_VDD23_10162 METAL6_2913600_1153300 METAL6_2910900_1153300 0.0054
R_VDD23_10163 METAL6_2910900_1153300 METAL6_2901600_1153300 0.0186
R_VDD23_10164 METAL6_2901600_1153300 METAL6_2898900_1153300 0.0054
R_VDD23_10165 METAL6_2898900_1153300 METAL6_2897100_1153300 0.0036
R_VDD23_10166 METAL6_2897100_1153300 METAL6_2886900_1153300 0.0204
R_VDD23_10167 METAL6_2886900_1153300 METAL6_2874800_1153300 0.0242
R_VDD23_10168 METAL6_2874800_1153300 METAL6_2862800_1153300 0.024
R_VDD23_10169 METAL6_2862800_1153300 METAL6_2860600_1153300 0.0044
R_VDD23_10170 METAL6_2860600_1153300 METAL6_2850800_1153300 0.0196
R_VDD23_10171 METAL6_2850800_1153300 METAL6_2846600_1153300 0.0084
R_VDD23_10172 METAL6_2846600_1153300 METAL6_2843800_1153300 0.0056
R_VDD23_10173 METAL6_2843800_1153300 METAL6_2817600_1153300 0.0524
R_VDD23_10174 METAL6_2817600_1153300 METAL6_2812000_1153300 0.0112
R_VDD23_10175 METAL6_2812000_1153300 METAL6_2810800_1153300 0.0024
R_VDD23_10176 METAL6_2810800_1153300 METAL6_2805600_1153300 0.0104
R_VDD23_10177 METAL6_2805600_1153300 METAL6_2800000_1153300 0.0112
R_VDD23_10178 METAL6_2800000_1153300 METAL6_2798800_1153300 0.0024
R_VDD23_10179 METAL6_2798800_1153300 METAL6_2793600_1153300 0.0104
R_VDD23_10180 METAL6_2793600_1153300 METAL6_2788000_1153300 0.0112
R_VDD23_10181 METAL6_2788000_1153300 METAL6_2786800_1153300 0.0024
R_VDD23_10182 METAL6_2786800_1153300 METAL6_2781600_1153300 0.0104
R_VDD23_10183 METAL6_2781600_1153300 METAL6_2769600_1153300 0.024
R_VDD23_10184 METAL6_2769600_1153300 METAL6_2765900_1153300 0.0074
R_VDD23_10185 METAL6_2765900_1153300 METAL6_2751900_1153300 0.028
R_VDD23_10186 METAL6_2751900_1153300 METAL6_2728200_1153300 0.0474
R_VDD23_10187 METAL6_2728200_1153300 METAL6_2710900_1153300 0.0346
R_VDD23_10188 METAL6_2710900_1153300 METAL6_2698900_1153300 0.024
R_VDD23_10189 METAL6_2698900_1153300 METAL6_2686900_1153300 0.024
R_VDD23_10190 METAL6_2686900_1153300 METAL6_2683200_1153300 0.0074
R_VDD23_10191 METAL6_2683200_1153300 METAL6_2676200_1153300 0.014
R_VDD23_10192 METAL6_2676200_1153300 METAL6_2664200_1153300 0.024
R_VDD23_10193 METAL6_2664200_1153300 METAL6_2660600_1153300 0.0072
R_VDD23_10194 METAL6_2660600_1153300 METAL6_2652200_1153300 0.0168
R_VDD23_10195 METAL6_2652200_1153300 METAL6_2646600_1153300 0.0112
R_VDD23_10196 METAL6_2646600_1153300 METAL6_2604400_1153300 0.0844
R_VDD23_10197 METAL6_2604400_1153300 METAL6_2592400_1153300 0.024
R_VDD23_10198 METAL6_2592400_1153300 METAL6_2580400_1153300 0.024
R_VDD23_10199 METAL6_2580400_1153300 METAL6_2568400_1153300 0.024
R_VDD23_10200 METAL6_2568400_1153300 METAL6_2565900_1153300 0.005
R_VDD23_10201 METAL6_2565900_1153300 METAL6_2556400_1153300 0.019
R_VDD23_10202 METAL6_2556400_1153300 METAL6_2551900_1153300 0.009
R_VDD23_10203 METAL6_2551900_1153300 METAL6_2548000_1153300 0.0078
R_VDD23_10204 METAL6_2548000_1153300 METAL6_2537600_1153300 0.0208
R_VDD23_10205 METAL6_2537600_1153300 METAL6_2536000_1153300 0.0032
R_VDD23_10206 METAL6_2536000_1153300 METAL5_2536000_1153300 0.1
R_VDD23_10207 METAL5_2536000_1153300 METAL5_2535400_1153300 0.0024
R_VDD23_10208 METAL5_2535400_1153300 METAL5_2529000_1153300 0.0256
R_VDD23_10209 METAL5_2529000_1153300 METAL5_2528400_1153300 0.0024
R_VDD23_10210 METAL5_2528400_1153300 METAL5_2525600_1153300 0.0112
R_VDD23_10211 METAL5_2525600_1153300 METAL5_2524000_1153300 0.0064
R_VDD23_10212 METAL5_2524000_1153300 METAL5_2517000_1153300 0.028
R_VDD23_10213 METAL5_2517000_1153300 METAL5_2516400_1153300 0.0024
R_VDD23_10214 METAL5_2516400_1153300 METAL5_2513600_1153300 0.0112
R_VDD23_10215 METAL5_2513600_1153300 METAL5_2512000_1153300 0.0064
R_VDD23_10216 METAL5_2512000_1153300 METAL5_2510900_1153300 0.0044
R_VDD23_10217 METAL5_2510900_1153300 METAL5_2505000_1153300 0.0236
R_VDD23_10218 METAL5_2505000_1153300 METAL5_2504400_1153300 0.0024
R_VDD23_10219 METAL5_2504400_1153300 METAL5_2501600_1153300 0.0112
R_VDD23_10220 METAL5_2501600_1153300 METAL5_2500000_1153300 0.0064
R_VDD23_10221 METAL5_2500000_1153300 METAL6_2500000_1153300 0.1
R_VDD23_10222 METAL6_2500000_1153300 METAL6_2498900_1153300 0.0022
R_VDD23_10223 METAL6_2498900_1153300 METAL6_2496600_1153300 0.0046
R_VDD23_10224 METAL6_2496600_1153300 METAL6_2493000_1153300 0.0072
R_VDD23_10225 METAL6_2493000_1153300 METAL6_2492400_1153300 0.0012
R_VDD23_10226 METAL6_2492400_1153300 METAL6_2489600_1153300 0.0056
R_VDD23_10227 METAL6_2489600_1153300 METAL6_2488000_1153300 0.0032
R_VDD23_10228 METAL6_2488000_1153300 METAL6_2486900_1153300 0.0022
R_VDD23_10229 METAL6_2486900_1153300 METAL6_2484600_1153300 0.0046
R_VDD23_10230 METAL6_2484600_1153300 METAL6_2481000_1153300 0.0072
R_VDD23_10231 METAL6_2481000_1153300 METAL6_2480400_1153300 0.0012
R_VDD23_10232 METAL6_2480400_1153300 METAL6_2477600_1153300 0.0056
R_VDD23_10233 METAL6_2477600_1153300 METAL6_2476000_1153300 0.0032
R_VDD23_10234 METAL6_2476000_1153300 METAL6_2472600_1153300 0.0068
R_VDD23_10235 METAL6_2472600_1153300 METAL6_2470600_1153300 0.004
R_VDD23_10236 METAL6_2470600_1153300 METAL6_2469000_1153300 0.0032
R_VDD23_10237 METAL6_2469000_1153300 METAL6_2468400_1153300 0.0012
R_VDD23_10238 METAL6_2468400_1153300 METAL6_2465600_1153300 0.0056
R_VDD23_10239 METAL6_2465600_1153300 METAL6_2464000_1153300 0.0032
R_VDD23_10240 METAL6_2464000_1153300 METAL6_2460600_1153300 0.0068
R_VDD23_10241 METAL6_2460600_1153300 METAL6_2458600_1153300 0.004
R_VDD23_10242 METAL6_2458600_1153300 METAL6_2457000_1153300 0.0032
R_VDD23_10243 METAL6_2457000_1153300 METAL6_2448600_1153300 0.0168
R_VDD23_10244 METAL6_2448600_1153300 METAL6_2446600_1153300 0.004
R_VDD23_10245 METAL6_2446600_1153300 METAL6_2436600_1153300 0.02
R_VDD23_10246 METAL6_2436600_1153300 METAL6_2434600_1153300 0.004
R_VDD23_10247 METAL6_2434600_1153300 METAL6_2424600_1153300 0.02
R_VDD23_10248 METAL6_2424600_1153300 METAL6_2422600_1153300 0.004
R_VDD23_10249 METAL6_2422600_1153300 METAL6_2419100_1153300 0.007
R_VDD23_10250 METAL6_2419100_1153300 METAL6_2407100_1153300 0.024
R_VDD23_10251 METAL6_2407100_1153300 METAL6_2405600_1153300 0.003
R_VDD23_10252 METAL6_2405600_1153300 METAL6_2402100_1153300 0.007
R_VDD23_10253 METAL6_2402100_1153300 METAL6_2395100_1153300 0.014
R_VDD23_10254 METAL6_2395100_1153300 METAL6_2393600_1153300 0.003
R_VDD23_10255 METAL6_2393600_1153300 METAL6_2383100_1153300 0.021
R_VDD23_10256 METAL6_2383100_1153300 METAL6_2381600_1153300 0.003
R_VDD23_10257 METAL6_2381600_1153300 METAL6_2371100_1153300 0.021
R_VDD23_10258 METAL6_2371100_1153300 METAL6_2369600_1153300 0.003
R_VDD23_10259 METAL6_2369600_1153300 METAL6_2365900_1153300 0.0074
R_VDD23_10260 METAL6_2365900_1153300 METAL6_2357600_1153300 0.0166
R_VDD23_10261 METAL6_2357600_1153300 METAL6_2351900_1153300 0.0114
R_VDD23_10262 METAL6_2351900_1153300 METAL6_2343700_1153300 0.0164
R_VDD23_10263 METAL6_2343700_1153300 METAL6_2322900_1153300 0.0416
R_VDD23_10264 METAL6_2322900_1153300 METAL6_2320600_1153300 0.0046
R_VDD23_10265 METAL6_2320600_1153300 METAL6_2310900_1153300 0.0194
R_VDD23_10266 METAL6_2310900_1153300 METAL6_2308600_1153300 0.0046
R_VDD23_10267 METAL6_2308600_1153300 METAL6_2298900_1153300 0.0194
R_VDD23_10268 METAL6_2298900_1153300 METAL6_2296600_1153300 0.0046
R_VDD23_10269 METAL6_2296600_1153300 METAL6_2286900_1153300 0.0194
R_VDD23_10270 METAL6_2286900_1153300 METAL6_2284600_1153300 0.0046
R_VDD23_10271 METAL6_2284600_1153300 METAL5_2284600_1153300 0.1
R_VDD23_10272 METAL5_2284600_1153300 METAL5_2284400_1153300 0.0008
R_VDD23_10273 METAL5_2284400_1153300 METAL5_2274900_1153300 0.038
R_VDD23_10274 METAL5_2274900_1153300 METAL5_2272600_1153300 0.0092
R_VDD23_10275 METAL5_2272600_1153300 METAL5_2272400_1153300 0.0008
R_VDD23_10276 METAL5_2272400_1153300 METAL5_2260600_1153300 0.0472
R_VDD23_10277 METAL5_2260600_1153300 METAL5_2260400_1153300 0.0008
R_VDD23_10278 METAL5_2260400_1153300 METAL5_2258600_1153300 0.0072
R_VDD23_10279 METAL5_2258600_1153300 METAL5_2248700_1153300 0.0396
R_VDD23_10280 METAL5_2248700_1153300 METAL5_2248600_1153300 0.0004
R_VDD23_10281 METAL5_2248600_1153300 METAL5_2248400_1153300 0.0008
R_VDD23_10282 METAL5_2248400_1153300 METAL5_2246600_1153300 0.0072
R_VDD23_10283 METAL5_2246600_1153300 METAL5_2236700_1153300 0.0396
R_VDD23_10284 METAL5_2236700_1153300 METAL5_2236600_1153300 0.0004
R_VDD23_10285 METAL5_2236600_1153300 METAL5_2234600_1153300 0.008
R_VDD23_10286 METAL5_2234600_1153300 METAL5_2233900_1153300 0.0028
R_VDD23_10287 METAL5_2233900_1153300 METAL5_2224700_1153300 0.0368
R_VDD23_10288 METAL5_2224700_1153300 METAL5_2224600_1153300 0.0004
R_VDD23_10289 METAL5_2224600_1153300 METAL5_2222600_1153300 0.008
R_VDD23_10290 METAL5_2222600_1153300 METAL5_2221900_1153300 0.0028
R_VDD23_10291 METAL5_2221900_1153300 METAL5_2212700_1153300 0.0368
R_VDD23_10292 METAL5_2212700_1153300 METAL5_2210600_1153300 0.0084
R_VDD23_10293 METAL5_2210600_1153300 METAL5_2209900_1153300 0.0028
R_VDD23_10294 METAL5_2209900_1153300 METAL5_2200700_1153300 0.0368
R_VDD23_10295 METAL5_2200700_1153300 METAL6_2200700_1153300 0.1
R_VDD23_10296 METAL6_2200700_1153300 METAL6_2189900_1153300 0.0216
R_VDD23_10297 METAL6_2189900_1153300 METAL6_2188700_1153300 0.0024
R_VDD23_10298 METAL6_2188700_1153300 METAL6_2177900_1153300 0.0216
R_VDD23_10299 METAL6_2177900_1153300 METAL6_2176700_1153300 0.0024
R_VDD23_10300 METAL6_2176700_1153300 METAL6_2165900_1153300 0.0216
R_VDD23_10301 METAL6_2165900_1153300 METAL6_2165400_1153300 0.001
R_VDD23_10302 METAL6_2165400_1153300 METAL6_2153900_1153300 0.023
R_VDD23_10303 METAL6_2153900_1153300 METAL6_2153400_1153300 0.001
R_VDD23_10304 METAL6_2153400_1153300 METAL6_2151900_1153300 0.003
R_VDD23_10305 METAL6_2151900_1153300 METAL6_2141900_1153300 0.02
R_VDD23_10306 METAL6_2141900_1153300 METAL6_2141400_1153300 0.001
R_VDD23_10307 METAL6_2141400_1153300 METAL6_2129900_1153300 0.023
R_VDD23_10308 METAL6_2129900_1153300 METAL6_2129700_1153300 0.0004
R_VDD23_10309 METAL6_2129700_1153300 METAL6_2125600_1153300 0.0082
R_VDD23_10310 METAL6_2125600_1153300 METAL6_2121400_1153300 0.0084
R_VDD23_10311 METAL6_2121400_1153300 METAL6_2117900_1153300 0.007
R_VDD23_10312 METAL6_2117900_1153300 METAL6_2113900_1153300 0.008
R_VDD23_10313 METAL6_2113900_1153300 METAL6_2113600_1153300 0.0006
R_VDD23_10314 METAL6_2113600_1153300 METAL6_2105900_1153300 0.0154
R_VDD23_10315 METAL6_2105900_1153300 METAL6_2101900_1153300 0.008
R_VDD23_10316 METAL6_2101900_1153300 METAL6_2101600_1153300 0.0006
R_VDD23_10317 METAL6_2101600_1153300 METAL6_2091700_1153300 0.0198
R_VDD23_10318 METAL6_2091700_1153300 METAL6_2089900_1153300 0.0036
R_VDD23_10319 METAL6_2089900_1153300 METAL6_2079700_1153300 0.0204
R_VDD23_10320 METAL6_2079700_1153300 METAL6_2077900_1153300 0.0036
R_VDD23_10321 METAL6_2077900_1153300 METAL6_2067700_1153300 0.0204
R_VDD23_10322 METAL6_2067700_1153300 METAL6_2060600_1153300 0.0142
R_VDD23_10323 METAL6_2060600_1153300 METAL6_2058800_1153300 0.0036
R_VDD23_10324 METAL6_2058800_1153300 METAL6_2055700_1153300 0.0062
R_VDD23_10325 METAL6_2055700_1153300 METAL6_2046800_1153300 0.0178
R_VDD23_10326 METAL6_2046800_1153300 METAL6_2046600_1153300 0.0004
R_VDD23_10327 METAL6_2046600_1153300 METAL6_2046400_1153300 0.0004
R_VDD23_10328 METAL6_2046400_1153300 METAL6_2043700_1153300 0.0054
R_VDD23_10329 METAL6_2043700_1153300 METAL6_2034800_1153300 0.0178
R_VDD23_10330 METAL6_2034800_1153300 METAL6_2031700_1153300 0.0062
R_VDD23_10331 METAL6_2031700_1153300 METAL6_2030900_1153300 0.0016
R_VDD23_10332 METAL6_2030900_1153300 METAL6_2026400_1153300 0.009
R_VDD23_10333 METAL6_2026400_1153300 METAL6_2021200_1153300 0.0104
R_VDD23_10334 METAL6_2021200_1153300 METAL6_2019700_1153300 0.003
R_VDD23_10335 METAL6_2019700_1153300 METAL6_2018900_1153300 0.0016
R_VDD23_10336 METAL6_2018900_1153300 METAL6_2014400_1153300 0.009
R_VDD23_10337 METAL6_2014400_1153300 METAL6_2012000_1153300 0.0048
R_VDD23_10338 METAL6_2012000_1153300 METAL6_2007700_1153300 0.0086
R_VDD23_10339 METAL6_2007700_1153300 METAL6_2006900_1153300 0.0016
R_VDD23_10340 METAL6_2006900_1153300 METAL6_2002400_1153300 0.009
R_VDD23_10341 METAL6_2002400_1153300 METAL6_2000000_1153300 0.0048
R_VDD23_10342 METAL6_2000000_1153300 METAL6_1988000_1153300 0.024
R_VDD23_10343 METAL6_1988000_1153300 METAL6_1963900_1153300 0.0482
R_VDD23_10344 METAL6_1963900_1153300 METAL5_1963900_1153300 0.1
R_VDD23_10345 METAL5_1963900_1153300 METAL5_1963800_1153300 0.0004
R_VDD23_10346 METAL5_1963800_1153300 METAL5_1951900_1153300 0.0476
R_VDD23_10347 METAL5_1951900_1153300 METAL5_1951800_1153300 0.0004
R_VDD23_10348 METAL5_1951800_1153300 METAL5_1939900_1153300 0.0476
R_VDD23_10349 METAL5_1939900_1153300 METAL5_1939800_1153300 0.0004
R_VDD23_10350 METAL5_1939800_1153300 METAL5_1937600_1153300 0.0088
R_VDD23_10351 METAL5_1937600_1153300 METAL5_1931200_1153300 0.0256
R_VDD23_10352 METAL5_1931200_1153300 METAL5_1927800_1153300 0.0136
R_VDD23_10353 METAL5_1927800_1153300 METAL5_1926200_1153300 0.0064
R_VDD23_10354 METAL5_1926200_1153300 METAL5_1925600_1153300 0.0024
R_VDD23_10355 METAL5_1925600_1153300 METAL5_1919200_1153300 0.0256
R_VDD23_10356 METAL5_1919200_1153300 METAL5_1913600_1153300 0.0224
R_VDD23_10357 METAL5_1913600_1153300 METAL5_1907400_1153300 0.0248
R_VDD23_10358 METAL5_1907400_1153300 METAL5_1907200_1153300 0.0008
R_VDD23_10359 METAL5_1907200_1153300 METAL5_1901600_1153300 0.0224
R_VDD23_10360 METAL5_1901600_1153300 METAL5_1900700_1153300 0.0036
R_VDD23_10361 METAL5_1900700_1153300 METAL5_1895200_1153300 0.022
R_VDD23_10362 METAL5_1895200_1153300 METAL5_1889600_1153300 0.0224
R_VDD23_10363 METAL5_1889600_1153300 METAL5_1889400_1153300 0.0008
R_VDD23_10364 METAL5_1889400_1153300 METAL5_1888700_1153300 0.0028
R_VDD23_10365 METAL5_1888700_1153300 METAL5_1883200_1153300 0.022
R_VDD23_10366 METAL5_1883200_1153300 METAL5_1877600_1153300 0.0224
R_VDD23_10367 METAL5_1877600_1153300 METAL5_1877400_1153300 0.0008
R_VDD23_10368 METAL5_1877400_1153300 METAL5_1876700_1153300 0.0028
R_VDD23_10369 METAL5_1876700_1153300 METAL5_1874700_1153300 0.008
R_VDD23_10370 METAL5_1874700_1153300 METAL5_1871200_1153300 0.014
R_VDD23_10371 METAL5_1871200_1153300 METAL5_1870600_1153300 0.0024
R_VDD23_10372 METAL5_1870600_1153300 METAL5_1865600_1153300 0.02
R_VDD23_10373 METAL5_1865600_1153300 METAL5_1865400_1153300 0.0008
R_VDD23_10374 METAL5_1865400_1153300 METAL5_1864700_1153300 0.0028
R_VDD23_10375 METAL5_1864700_1153300 METAL5_1859200_1153300 0.022
R_VDD23_10376 METAL5_1859200_1153300 METAL5_1858600_1153300 0.0024
R_VDD23_10377 METAL5_1858600_1153300 METAL5_1858400_1153300 0.0008
R_VDD23_10378 METAL5_1858400_1153300 METAL5_1853400_1153300 0.02
R_VDD23_10379 METAL5_1853400_1153300 METAL5_1852700_1153300 0.0028
R_VDD23_10380 METAL5_1852700_1153300 METAL5_1847200_1153300 0.022
R_VDD23_10381 METAL5_1847200_1153300 METAL5_1846800_1153300 0.0016
R_VDD23_10382 METAL5_1846800_1153300 METAL5_1846600_1153300 0.0008
R_VDD23_10383 METAL5_1846600_1153300 METAL5_1846400_1153300 0.0008
R_VDD23_10384 METAL5_1846400_1153300 METAL5_1844800_1153300 0.0064
R_VDD23_10385 METAL5_1844800_1153300 METAL5_1841400_1153300 0.0136
R_VDD23_10386 METAL5_1841400_1153300 METAL5_1834600_1153300 0.0272
R_VDD23_10387 METAL5_1834600_1153300 METAL5_1834400_1153300 0.0008
R_VDD23_10388 METAL5_1834400_1153300 METAL6_1834400_1153300 0.1
R_VDD23_10389 METAL6_1834400_1153300 METAL6_1832800_1153300 0.0032
R_VDD23_10390 METAL6_1832800_1153300 METAL6_1822600_1153300 0.0204
R_VDD23_10391 METAL6_1822600_1153300 METAL6_1822400_1153300 0.0004
R_VDD23_10392 METAL6_1822400_1153300 METAL6_1820800_1153300 0.0032
R_VDD23_10393 METAL6_1820800_1153300 METAL6_1812000_1153300 0.0176
R_VDD23_10394 METAL6_1812000_1153300 METAL6_1810600_1153300 0.0028
R_VDD23_10395 METAL6_1810600_1153300 METAL6_1800000_1153300 0.0212
R_VDD23_10396 METAL6_1800000_1153300 METAL6_1788000_1153300 0.024
R_VDD23_10397 METAL6_1788000_1153300 METAL6_1787400_1153300 0.0012
R_VDD23_10398 METAL6_1787400_1153300 METAL6_1775400_1153300 0.024
R_VDD23_10399 METAL6_1775400_1153300 METAL6_1768000_1153300 0.0148
R_VDD23_10400 METAL6_1768000_1153300 METAL6_1767700_1153300 0.0006
R_VDD23_10401 METAL6_1767700_1153300 METAL6_1763800_1153300 0.0078
R_VDD23_10402 METAL6_1763800_1153300 METAL6_1763400_1153300 0.0008
R_VDD23_10403 METAL6_1763400_1153300 METAL6_1756000_1153300 0.0148
R_VDD23_10404 METAL6_1756000_1153300 METAL6_1755700_1153300 0.0006
R_VDD23_10405 METAL6_1755700_1153300 METAL6_1753800_1153300 0.0038
R_VDD23_10406 METAL6_1753800_1153300 METAL6_1751800_1153300 0.004
R_VDD23_10407 METAL6_1751800_1153300 METAL6_1751400_1153300 0.0008
R_VDD23_10408 METAL6_1751400_1153300 METAL6_1744000_1153300 0.0148
R_VDD23_10409 METAL6_1744000_1153300 METAL6_1743700_1153300 0.0006
R_VDD23_10410 METAL6_1743700_1153300 METAL6_1741800_1153300 0.0038
R_VDD23_10411 METAL6_1741800_1153300 METAL6_1739800_1153300 0.004
R_VDD23_10412 METAL6_1739800_1153300 METAL6_1739400_1153300 0.0008
R_VDD23_10413 METAL6_1739400_1153300 METAL6_1732000_1153300 0.0148
R_VDD23_10414 METAL6_1732000_1153300 METAL6_1731700_1153300 0.0006
R_VDD23_10415 METAL6_1731700_1153300 METAL6_1729800_1153300 0.0038
R_VDD23_10416 METAL6_1729800_1153300 METAL6_1727800_1153300 0.004
R_VDD23_10417 METAL6_1727800_1153300 METAL6_1719700_1153300 0.0162
R_VDD23_10418 METAL6_1719700_1153300 METAL6_1719700_1146300 0.014
R_VDD23_10419 METAL6_1719700_1146300 METAL6_1719700_1141300 0.01
R_VDD23_10420 METAL6_1719700_1141300 METAL6_1719700_1134500 0.0136
R_VDD23_10421 METAL6_1719700_1134500 METAL6_1717800_1134500 0.0038
R_VDD23_10422 METAL6_1717800_1134500 METAL6_1710800_1134500 0.014
R_VDD23_10423 METAL6_1710800_1134500 METAL6_1707700_1134500 0.0062
R_VDD23_10424 METAL6_1707700_1134500 METAL6_1699000_1134500 0.0174
R_VDD23_10425 METAL6_1699000_1134500 METAL6_1692000_1134500 0.014
R_VDD23_10426 METAL6_1692000_1134500 METAL6_1682800_1134500 0.0184
R_VDD23_10427 METAL6_1682800_1134500 METAL6_1680000_1134500 0.0056
R_VDD23_10428 METAL6_1680000_1134500 METAL6_1670800_1134500 0.0184
R_VDD23_10429 METAL6_1670800_1134500 METAL6_1668000_1134500 0.0056
R_VDD23_10430 METAL6_1668000_1134500 METAL6_1658800_1134500 0.0184
R_VDD23_10431 METAL6_1658800_1134500 METAL6_1646800_1134500 0.024
R_VDD23_10432 METAL6_1646800_1134500 METAL6_1636700_1134500 0.0202
R_VDD23_10433 METAL6_1636700_1134500 METAL6_1636700_1134300 0.0004
R_VDD23_10434 METAL6_1636700_1134300 METAL6_1636700_1132800 0.003
R_VDD23_10435 METAL6_1636700_1132800 METAL6_1636700_1129300 0.007
R_VDD23_10436 METAL6_1636700_1129300 METAL6_1636700_1122500 0.0136
R_VDD23_10437 METAL6_1636700_1122500 METAL6_1636700_1122300 0.0004
R_VDD23_10438 METAL6_1636700_1122300 METAL6_1636700_1120800 0.003
R_VDD23_10439 METAL6_1636700_1120800 METAL6_1636700_1112000 0.0176
R_VDD23_10440 METAL6_1636700_1112000 METAL6_1636700_1110500 0.003
R_VDD23_10441 METAL6_1636700_1110500 METAL6_1636700_1110300 0.0004
R_VDD23_10442 METAL6_1636700_1110300 METAL6_1636700_1110000 0.0006
R_VDD23_10443 METAL6_1636700_1110000 METAL6_1636700_1108800 0.0024
R_VDD23_10444 METAL6_1636700_1108800 METAL6_1636700_1100000 0.0176
R_VDD23_10445 METAL6_1636700_1100000 METAL6_1636700_1098500 0.003
R_VDD23_10446 METAL6_1636700_1098500 METAL6_1636700_1098300 0.0004
R_VDD23_10447 METAL6_1636700_1098300 METAL6_1636700_1098000 0.0006
R_VDD23_10448 METAL6_1636700_1098000 METAL6_1636700_1097800 0.0004
R_VDD23_10449 METAL6_1636700_1097800 METAL6_1636700_1096800 0.002
R_VDD23_10450 METAL6_1636700_1096800 METAL6_1636700_1088000 0.0176
R_VDD23_10451 METAL6_1636700_1088000 METAL6_1636700_1086500 0.003
R_VDD23_10452 METAL6_1636700_1086500 METAL6_1636700_1086300 0.0004
R_VDD23_10453 METAL6_1636700_1086300 METAL6_1636700_1086000 0.0006
R_VDD23_10454 METAL6_1636700_1086000 METAL6_1636700_1085800 0.0004
R_VDD23_10455 METAL6_1636700_1085800 METAL6_1636700_1085400 0.0008
R_VDD23_10456 METAL6_1636700_1085400 METAL6_1636700_1074500 0.0218
R_VDD23_10457 METAL6_1636700_1074500 METAL6_1636700_1074000 0.001
R_VDD23_10458 METAL6_1636700_1074000 METAL6_1636700_1073800 0.0004
R_VDD23_10459 METAL6_1636700_1073800 METAL6_1636700_1073400 0.0008
R_VDD23_10460 METAL6_1636700_1073400 METAL6_1636700_1066700 0.0134
R_VDD23_10461 METAL6_1636700_1066700 METAL6_1636700_1061800 0.0098
R_VDD23_10462 METAL6_1636700_1061800 METAL6_1636700_1061400 0.0008
R_VDD23_10463 METAL6_1636700_1061400 METAL6_1636700_1054700 0.0134
R_VDD23_10464 METAL6_1636700_1054700 METAL6_1636700_1053800 0.0018
R_VDD23_10465 METAL6_1636700_1053800 METAL6_1636700_1049800 0.008
R_VDD23_10466 METAL6_1636700_1049800 METAL6_1636700_1049400 0.0008
R_VDD23_10467 METAL6_1636700_1049400 METAL6_1636700_1047700 0.0034
R_VDD23_10468 METAL6_1636700_1047700 METAL6_1636700_1043000 0.0094
R_VDD23_10469 METAL6_1636700_1043000 METAL6_1636700_1042700 0.0006
R_VDD23_10470 METAL6_1636700_1042700 METAL6_1636700_1041800 0.0018
R_VDD23_10471 METAL6_1636700_1041800 METAL6_1636700_1038000 0.0076
R_VDD23_10472 METAL6_1636700_1038000 METAL6_1636700_1037400 0.0012
R_VDD23_10473 METAL6_1636700_1037400 METAL6_1636700_1035700 0.0034
R_VDD23_10474 METAL6_1636700_1035700 METAL6_1636700_1031000 0.0094
R_VDD23_10475 METAL6_1636700_1031000 METAL6_1636700_1029800 0.0024
R_VDD23_10476 METAL6_1636700_1029800 METAL6_1636700_1026000 0.0076
R_VDD23_10477 METAL6_1636700_1026000 METAL6_1636700_1025400 0.0012
R_VDD23_10478 METAL6_1636700_1025400 METAL6_1636700_1023700 0.0034
R_VDD23_10479 METAL6_1636700_1023700 METAL6_1636700_1019000 0.0094
R_VDD23_10480 METAL6_1636700_1019000 METAL6_1636700_1014000 0.01
R_VDD23_10481 METAL6_1636700_1014000 METAL6_1636700_1012000 0.004
R_VDD23_10482 METAL6_1636700_1012000 METAL6_1636700_1007000 0.01
R_VDD23_10483 METAL6_1636700_1007000 METAL6_1636700_1000000 0.014
R_VDD23_10484 METAL6_1636700_1000000 METAL6_1636700_995000 0.01
R_VDD23_10485 METAL6_1636700_995000 METAL6_1636700_988000 0.014
R_VDD23_10486 METAL6_1636700_988000 METAL6_1636700_983000 0.01
R_VDD23_10487 METAL6_1636700_983000 METAL6_1636700_976000 0.014
R_VDD23_10488 METAL6_1636700_976000 METAL6_1636700_971000 0.01
R_VDD23_10489 METAL6_1636700_971000 METAL6_1636700_959000 0.024
R_VDD23_10490 METAL6_1636700_959000 METAL5_1636700_959000 0.1
R_VDD23_10491 METAL5_1636700_959000 METAL5_1636000_959000 0.0028
R_VDD23_10492 METAL5_1636000_959000 METAL5_1634800_959000 0.0048
R_VDD23_10493 METAL5_1634800_959000 METAL5_1632800_959000 0.008
R_VDD23_10494 METAL5_1632800_959000 METAL5_1627800_959000 0.02
R_VDD23_10495 METAL5_1627800_959000 METAL5_1624700_959000 0.0124
R_VDD23_10496 METAL5_1624700_959000 METAL5_1624000_959000 0.0028
R_VDD23_10497 METAL5_1624000_959000 METAL5_1615800_959000 0.0328
R_VDD23_10498 METAL5_1615800_959000 METAL5_1612700_959000 0.0124
R_VDD23_10499 METAL5_1612700_959000 METAL5_1612000_959000 0.0028
R_VDD23_10500 METAL5_1612000_959000 METAL5_1607900_959000 0.0164
R_VDD23_10501 METAL5_1607900_959000 METAL5_1603800_959000 0.0164
R_VDD23_10502 METAL5_1603800_959000 METAL5_1600700_959000 0.0124
R_VDD23_10503 METAL5_1600700_959000 METAL5_1600000_959000 0.0028
R_VDD23_10504 METAL5_1600000_959000 METAL5_1591800_959000 0.0328
R_VDD23_10505 METAL5_1591800_959000 METAL5_1588700_959000 0.0124
R_VDD23_10506 METAL5_1588700_959000 METAL6_1588700_959000 0.1
R_VDD23_10507 METAL6_1588700_959000 METAL6_1588700_947000 0.024
R_VDD23_10508 METAL6_1588700_947000 METAL6_1588700_935000 0.024
R_VDD23_10509 METAL6_1588700_935000 METAL6_1588700_927300 0.0154
R_VDD23_10510 METAL6_1588700_927300 METAL6_1588700_923000 0.0086
R_VDD23_10511 METAL6_1588700_923000 METAL6_1588700_912000 0.022
R_VDD23_10512 METAL6_1588700_912000 METAL6_1588000_912000 0.0014
R_VDD23_10513 METAL6_1588000_912000 METAL6_1579800_912000 0.0164
R_VDD23_10514 METAL6_1579800_912000 METAL6_1576700_912000 0.0062
R_VDD23_10515 METAL6_1576700_912000 METAL6_1576000_912000 0.0014
R_VDD23_10516 METAL6_1576000_912000 METAL6_1574700_912000 0.0026
R_VDD23_10517 METAL6_1574700_912000 METAL6_1569000_912000 0.0114
R_VDD23_10518 METAL6_1569000_912000 METAL6_1567800_912000 0.0024
R_VDD23_10519 METAL6_1567800_912000 METAL6_1564000_912000 0.0076
R_VDD23_10520 METAL6_1564000_912000 METAL6_1557000_912000 0.014
R_VDD23_10521 METAL6_1557000_912000 METAL6_1555400_912000 0.0032
R_VDD23_10522 METAL6_1555400_912000 METAL6_1552000_912000 0.0068
R_VDD23_10523 METAL6_1552000_912000 METAL6_1551800_912000 0.0004
R_VDD23_10524 METAL6_1551800_912000 METAL6_1545000_912000 0.0136
R_VDD23_10525 METAL6_1545000_912000 METAL6_1540000_912000 0.01
R_VDD23_10526 METAL6_1540000_912000 METAL6_1539800_912000 0.0004
R_VDD23_10527 METAL6_1539800_912000 METAL6_1527800_912000 0.024
R_VDD23_10528 METAL6_1527800_912000 METAL6_1512000_912000 0.0316
R_VDD23_10529 METAL6_1512000_912000 METAL6_1510400_912000 0.0032
R_VDD23_10530 METAL6_1510400_912000 METAL6_1503400_912000 0.014
R_VDD23_10531 METAL6_1503400_912000 METAL6_1500000_912000 0.0068
R_VDD23_10532 METAL6_1500000_912000 METAL6_1498300_912000 0.0034
R_VDD23_10533 METAL6_1498300_912000 METAL6_1491400_912000 0.0138
R_VDD23_10534 METAL6_1491400_912000 METAL6_1488000_912000 0.0068
R_VDD23_10535 METAL6_1488000_912000 METAL6_1479400_912000 0.0172
R_VDD23_10536 METAL6_1479400_912000 METAL6_1444800_912000 0.0692
R_VDD23_10537 METAL6_1444800_912000 METAL6_1443700_912000 0.0022
R_VDD23_10538 METAL6_1443700_912000 METAL6_1432800_912000 0.0218
R_VDD23_10539 METAL6_1432800_912000 METAL6_1431700_912000 0.0022
R_VDD23_10540 METAL6_1431700_912000 METAL6_1424000_912000 0.0154
R_VDD23_10541 METAL6_1424000_912000 METAL6_1420800_912000 0.0064
R_VDD23_10542 METAL6_1420800_912000 METAL6_1419700_912000 0.0022
R_VDD23_10543 METAL6_1419700_912000 METAL6_1412000_912000 0.0154
R_VDD23_10544 METAL6_1412000_912000 METAL6_1408800_912000 0.0064
R_VDD23_10545 METAL6_1408800_912000 METAL6_1400000_912000 0.0176
R_VDD23_10546 METAL6_1400000_912000 METAL6_1396800_912000 0.0064
R_VDD23_10547 METAL6_1396800_912000 METAL6_1388000_912000 0.0176
R_VDD23_10548 METAL6_1388000_912000 METAL6_1349000_912000 0.078
R_VDD23_10549 METAL6_1349000_912000 METAL6_1348000_912000 0.002
R_VDD23_10550 METAL6_1348000_912000 METAL6_1337000_912000 0.022
R_VDD23_10551 METAL6_1337000_912000 METAL6_1336000_912000 0.002
R_VDD23_10552 METAL6_1336000_912000 METAL6_1325000_912000 0.022
R_VDD23_10553 METAL6_1325000_912000 METAL6_1324000_912000 0.002
R_VDD23_10554 METAL6_1324000_912000 METAL5_1324000_912000 0.1
R_VDD23_10555 METAL5_1324000_912000 METAL5_1323800_912000 0.0008
R_VDD23_10556 METAL5_1323800_912000 METAL5_1313000_912000 0.0432
R_VDD23_10557 METAL5_1313000_912000 METAL5_1312000_912000 0.004
R_VDD23_10558 METAL5_1312000_912000 METAL5_1311800_912000 0.0008
R_VDD23_10559 METAL5_1311800_912000 METAL5_1301000_912000 0.0432
R_VDD23_10560 METAL5_1301000_912000 METAL5_1300000_912000 0.004
R_VDD23_10561 METAL5_1300000_912000 METAL6_1300000_912000 0.1
R_VDD23_10562 METAL6_1300000_912000 METAL6_1300000_911000 0.002
R_VDD23_10563 METAL6_1300000_911000 METAL6_1300000_900400 0.0212
R_VDD23_10564 METAL6_1300000_900400 METAL6_1299800_900400 0.0004
R_VDD23_10565 METAL6_1299800_900400 METAL6_1294300_900400 0.011
R_VDD23_10566 METAL6_1294300_900400 METAL6_1289000_900400 0.0106
R_VDD23_10567 METAL6_1289000_900400 METAL6_1288000_900400 0.002
R_VDD23_10568 METAL6_1288000_900400 METAL6_1287800_900400 0.0004
R_VDD23_10569 METAL6_1287800_900400 METAL6_1286700_900400 0.0022
R_VDD23_10570 METAL6_1286700_900400 METAL6_1282300_900400 0.0088
R_VDD23_10571 METAL6_1282300_900400 METAL6_1276000_900400 0.0126
R_VDD23_10572 METAL6_1276000_900400 METAL6_1274700_900400 0.0026
R_VDD23_10573 METAL6_1274700_900400 METAL6_1270300_900400 0.0088
R_VDD23_10574 METAL6_1270300_900400 METAL6_1266800_900400 0.007
R_VDD23_10575 METAL6_1266800_900400 METAL6_1262700_900400 0.0082
R_VDD23_10576 METAL6_1262700_900400 METAL6_1259800_900400 0.0058
R_VDD23_10577 METAL6_1259800_900400 METAL6_1258300_900400 0.003
R_VDD23_10578 METAL6_1258300_900400 METAL6_1254700_900400 0.0072
R_VDD23_10579 METAL6_1254700_900400 METAL6_1253300_900400 0.0028
R_VDD23_10580 METAL6_1253300_900400 METAL6_1248000_900400 0.0106
R_VDD23_10581 METAL6_1248000_900400 METAL6_1247800_900400 0.0004
R_VDD23_10582 METAL6_1247800_900400 METAL6_1247800_900000 0.0008
R_VDD23_10583 METAL6_1247800_900000 METAL6_1247800_899000 0.002
R_VDD23_10584 METAL6_1247800_899000 METAL6_1247800_888000 0.022
R_VDD23_10585 METAL6_1247800_888000 METAL6_1247800_887000 0.002
R_VDD23_10586 METAL6_1247800_887000 METAL6_1247800_875000 0.024
R_VDD23_10587 METAL6_1247800_875000 METAL6_1247800_863500 0.023
R_VDD23_10588 METAL6_1247800_863500 METAL6_1247800_858200 0.0106
R_VDD23_10589 METAL6_1247800_858200 METAL6_1247800_854400 0.0076
R_VDD23_10590 METAL6_1247800_854400 METAL6_1247800_852700 0.0034
R_VDD23_10591 METAL6_1247800_852700 METAL6_1247800_851500 0.0024
R_VDD23_10592 METAL6_1247800_851500 METAL6_1247800_842400 0.0182
R_VDD23_10593 METAL6_1247800_842400 METAL6_1247800_840700 0.0034
R_VDD23_10594 METAL6_1247800_840700 METAL6_1247800_839500 0.0024
R_VDD23_10595 METAL6_1247800_839500 METAL6_1247800_832000 0.015
R_VDD23_10596 METAL6_1247800_832000 METAL6_1247800_830400 0.0032
R_VDD23_10597 METAL6_1247800_830400 METAL6_1247800_828700 0.0034
R_VDD23_10598 METAL6_1247800_828700 METAL6_1247800_820000 0.0174
R_VDD23_10599 METAL6_1247800_820000 METAL6_1247800_818400 0.0032
R_VDD23_10600 METAL6_1247800_818400 METAL6_1247800_814400 0.008
R_VDD23_10601 METAL6_1247800_814400 METAL6_1247800_812000 0.0048
R_VDD23_10602 METAL6_1247800_812000 METAL6_1247800_808000 0.008
R_VDD23_10603 METAL6_1247800_808000 METAL6_1247800_806400 0.0032
R_VDD23_10604 METAL6_1247800_806400 METAL6_1247800_803200 0.0064
R_VDD23_10605 METAL6_1247800_803200 METAL6_1247800_802400 0.0016
R_VDD23_10606 METAL6_1247800_802400 METAL6_1247800_800000 0.0048
R_VDD23_10607 METAL6_1247800_800000 METAL6_1247800_794800 0.0104
R_VDD23_10608 METAL6_1247800_794800 METAL6_1247800_794400 0.0008
R_VDD23_10609 METAL6_1247800_794400 METAL6_1247800_791200 0.0064
R_VDD23_10610 METAL6_1247800_791200 METAL6_1247800_790400 0.0016
R_VDD23_10611 METAL6_1247800_790400 METAL6_1247800_788000 0.0048
R_VDD23_10612 METAL6_1247800_788000 METAL6_1247800_784500 0.007
R_VDD23_10613 METAL6_1247800_784500 METAL6_1247800_784000 0.001
R_VDD23_10614 METAL6_1247800_784000 METAL6_1247800_782400 0.0032
R_VDD23_10615 METAL6_1247800_782400 METAL6_1247800_781800 0.0012
R_VDD23_10616 METAL6_1247800_781800 METAL6_1247800_779200 0.0052
R_VDD23_10617 METAL6_1247800_779200 METAL6_1247800_778400 0.0016
R_VDD23_10618 METAL6_1247800_778400 METAL6_1247800_772000 0.0128
R_VDD23_10619 METAL6_1247800_772000 METAL6_1247800_770400 0.0032
R_VDD23_10620 METAL6_1247800_770400 METAL6_1247800_769800 0.0012
R_VDD23_10621 METAL6_1247800_769800 METAL6_1247800_766400 0.0068
R_VDD23_10622 METAL6_1247800_766400 METAL6_1247800_763000 0.0068
R_VDD23_10623 METAL6_1247800_763000 METAL6_1247800_760000 0.006
R_VDD23_10624 METAL6_1247800_760000 METAL6_1247800_758400 0.0032
R_VDD23_10625 METAL6_1247800_758400 METAL6_1247800_757800 0.0012
R_VDD23_10626 METAL6_1247800_757800 METAL6_1247800_754400 0.0068
R_VDD23_10627 METAL6_1247800_754400 METAL6_1247800_746400 0.016
R_VDD23_10628 METAL6_1247800_746400 METAL6_1247800_745800 0.0012
R_VDD23_10629 METAL6_1247800_745800 METAL6_1247800_742400 0.0068
R_VDD23_10630 METAL6_1247800_742400 METAL6_1247800_735400 0.014
R_VDD23_10631 METAL6_1247800_735400 METAL6_1247800_734400 0.002
R_VDD23_10632 METAL6_1247800_734400 METAL6_1247800_733800 0.0012
R_VDD23_10633 METAL6_1247800_733800 METAL6_1247800_722400 0.0228
R_VDD23_10634 METAL6_1247800_722400 METAL6_1247800_721800 0.0012
R_VDD23_10635 METAL6_1247800_721800 METAL6_1247800_716800 0.01
R_VDD23_10636 METAL6_1247800_716800 METAL6_1247800_712000 0.0096
R_VDD23_10637 METAL6_1247800_712000 METAL6_1247800_709800 0.0044
R_VDD23_10638 METAL6_1247800_709800 METAL6_1247800_702800 0.014
R_VDD23_10639 METAL6_1247800_702800 METAL6_1247800_700000 0.0056
R_VDD23_10640 METAL6_1247800_700000 METAL6_1247800_697800 0.0044
R_VDD23_10641 METAL6_1247800_697800 METAL6_1247800_688000 0.0196
R_VDD23_10642 METAL6_1247800_688000 METAL6_1247800_685800 0.0044
R_VDD23_10643 METAL6_1247800_685800 METAL6_1247800_665400 0.0408
R_VDD23_10644 METAL6_1247800_665400 METAL6_1247800_661800 0.0072
R_VDD23_10645 METAL6_1247800_661800 METAL6_1247800_653400 0.0168
R_VDD23_10646 METAL6_1259800_653400 METAL6_1247800_653400 0.024
I_VDD23_37 METAL6_1259800_653400 gnd 0.001

V_VDD24_17 METAL5_3500000_1100000 gnd 1
R_VDD24_10647 METAL5_3500000_1100000 METAL5_3490500_1100000 0.038
R_VDD24_10648 METAL5_3490500_1100000 METAL6_3490500_1100000 0.1
R_VDD24_10649 METAL6_3490500_1100000 METAL6_3478500_1100000 0.024
R_VDD24_10650 METAL6_3478500_1100000 METAL6_3478500_1108800 0.0176
R_VDD24_10651 METAL6_3478500_1108800 METAL6_3477000_1108800 0.003
R_VDD24_10652 METAL6_3477000_1108800 METAL6_3466500_1108800 0.021
R_VDD24_10653 METAL6_3466500_1108800 METAL6_3465000_1108800 0.003
R_VDD24_10654 METAL6_3465000_1108800 METAL6_3454500_1108800 0.021
R_VDD24_10655 METAL6_3454500_1108800 METAL6_3453000_1108800 0.003
R_VDD24_10656 METAL6_3453000_1108800 METAL6_3442500_1108800 0.021
R_VDD24_10657 METAL6_3442500_1108800 METAL6_3348400_1108800 0.1882
R_VDD24_10658 METAL6_3348400_1108800 METAL5_3348400_1108800 0.1
R_VDD24_10659 METAL5_3348400_1108800 METAL5_3336400_1108800 0.048
R_VDD24_10660 METAL5_3336400_1108800 METAL5_3324400_1108800 0.048
R_VDD24_10661 METAL5_3324400_1108800 METAL5_3312400_1108800 0.048
R_VDD24_10662 METAL5_3312400_1108800 METAL5_3312000_1108800 0.0016
R_VDD24_10663 METAL5_3312000_1108800 METAL5_3305400_1108800 0.0264
R_VDD24_10664 METAL5_3305400_1108800 METAL5_3300400_1108800 0.02
R_VDD24_10665 METAL5_3300400_1108800 METAL6_3300400_1108800 0.1
R_VDD24_10666 METAL6_3300400_1108800 METAL6_3300000_1108800 0.0008
R_VDD24_10667 METAL6_3300000_1108800 METAL6_3288400_1108800 0.0232
R_VDD24_10668 METAL6_3288400_1108800 METAL6_3288000_1108800 0.0008
R_VDD24_10669 METAL6_3288000_1108800 METAL6_3287000_1108800 0.002
R_VDD24_10670 METAL6_3287000_1108800 METAL6_3276400_1108800 0.0212
R_VDD24_10671 METAL6_3276400_1108800 METAL6_3275000_1108800 0.0028
R_VDD24_10672 METAL6_3275000_1108800 METAL6_3263000_1108800 0.024
R_VDD24_10673 METAL6_3263000_1108800 METAL6_3260400_1108800 0.0052
R_VDD24_10674 METAL6_3260400_1108800 METAL6_3243500_1108800 0.0338
R_VDD24_10675 METAL6_3243500_1108800 METAL6_3231500_1108800 0.024
R_VDD24_10676 METAL6_3231500_1108800 METAL6_3219500_1108800 0.024
R_VDD24_10677 METAL6_3219500_1108800 METAL6_3219500_1100000 0.0176
R_VDD24_10678 METAL6_3219500_1100000 METAL6_3212500_1100000 0.014
R_VDD24_10679 METAL6_3212500_1100000 METAL6_3212500_1098500 0.003
R_VDD24_10680 METAL6_3212500_1098500 METAL6_3212000_1098500 0.001
R_VDD24_10681 METAL6_3212000_1098500 METAL6_3200000_1098500 0.024
R_VDD24_10682 METAL6_3200000_1098500 METAL6_3188000_1098500 0.024
R_VDD24_10683 METAL6_3188000_1098500 METAL6_3179500_1098500 0.017
R_VDD24_10684 METAL6_3179500_1098500 METAL6_3167500_1098500 0.024
R_VDD24_10685 METAL6_3167500_1098500 METAL6_3165900_1098500 0.0032
R_VDD24_10686 METAL6_3165900_1098500 METAL6_3155500_1098500 0.0208
R_VDD24_10687 METAL6_3155500_1098500 METAL6_3124000_1098500 0.063
R_VDD24_10688 METAL6_3124000_1098500 METAL6_3112000_1098500 0.024
R_VDD24_10689 METAL6_3112000_1098500 METAL6_3110900_1098500 0.0022
R_VDD24_10690 METAL6_3110900_1098500 METAL6_3100000_1098500 0.0218
R_VDD24_10691 METAL6_3100000_1098500 METAL6_3099200_1098500 0.0016
R_VDD24_10692 METAL6_3099200_1098500 METAL6_3098900_1098500 0.0006
R_VDD24_10693 METAL6_3098900_1098500 METAL6_3088000_1098500 0.0218
R_VDD24_10694 METAL6_3088000_1098500 METAL6_3087200_1098500 0.0016
R_VDD24_10695 METAL6_3087200_1098500 METAL6_3086900_1098500 0.0006
R_VDD24_10696 METAL6_3086900_1098500 METAL6_3076000_1098500 0.0218
R_VDD24_10697 METAL6_3076000_1098500 METAL6_3075200_1098500 0.0016
R_VDD24_10698 METAL6_3075200_1098500 METAL6_3068200_1098500 0.014
R_VDD24_10699 METAL6_3068200_1098500 METAL6_3064000_1098500 0.0084
R_VDD24_10700 METAL6_3064000_1098500 METAL6_3060600_1098500 0.0068
R_VDD24_10701 METAL6_3060600_1098500 METAL6_3052000_1098500 0.0172
R_VDD24_10702 METAL6_3052000_1098500 METAL6_3023200_1098500 0.0576
R_VDD24_10703 METAL6_3023200_1098500 METAL6_3012000_1098500 0.0224
R_VDD24_10704 METAL6_3012000_1098500 METAL6_3006200_1098500 0.0116
R_VDD24_10705 METAL6_3006200_1098500 METAL6_3000000_1098500 0.0124
R_VDD24_10706 METAL6_3000000_1098500 METAL6_2994200_1098500 0.0116
R_VDD24_10707 METAL6_2994200_1098500 METAL6_2994200_1098300 0.0004
R_VDD24_10708 METAL6_2994200_1098300 METAL6_2994200_1096800 0.003
R_VDD24_10709 METAL6_2994200_1096800 METAL6_2994200_1088000 0.0176
R_VDD24_10710 METAL6_2994200_1088000 METAL6_2994200_1086500 0.003
R_VDD24_10711 METAL6_2994200_1086500 METAL6_2994200_1086300 0.0004
R_VDD24_10712 METAL6_2994200_1086300 METAL6_2994200_1086000 0.0006
R_VDD24_10713 METAL6_2994200_1086000 METAL6_2994200_1073800 0.0244
R_VDD24_10714 METAL6_2994200_1073800 METAL6_2994200_1066700 0.0142
R_VDD24_10715 METAL6_2994200_1066700 METAL6_2994200_1061800 0.0098
R_VDD24_10716 METAL6_2994200_1061800 METAL6_2994200_1061400 0.0008
R_VDD24_10717 METAL6_2994200_1061400 METAL6_2994200_1054700 0.0134
R_VDD24_10718 METAL6_2994200_1054700 METAL6_2994200_1053800 0.0018
R_VDD24_10719 METAL6_2994200_1053800 METAL6_2994200_1049800 0.008
R_VDD24_10720 METAL6_2994200_1049800 METAL6_2994200_1049400 0.0008
R_VDD24_10721 METAL6_2994200_1049400 METAL6_2994200_1047700 0.0034
R_VDD24_10722 METAL6_2994200_1047700 METAL6_2994200_1042700 0.01
R_VDD24_10723 METAL6_2994200_1042700 METAL6_2994200_1041800 0.0018
R_VDD24_10724 METAL6_2994200_1041800 METAL6_2994200_1038000 0.0076
R_VDD24_10725 METAL6_2994200_1038000 METAL6_2994200_1037400 0.0012
R_VDD24_10726 METAL6_2994200_1037400 METAL6_2994200_1035700 0.0034
R_VDD24_10727 METAL6_2994200_1035700 METAL6_2994200_1031000 0.0094
R_VDD24_10728 METAL6_2994200_1031000 METAL6_2994200_1029800 0.0024
R_VDD24_10729 METAL6_2994200_1029800 METAL6_2994200_1026000 0.0076
R_VDD24_10730 METAL6_2994200_1026000 METAL6_2994200_1025400 0.0012
R_VDD24_10731 METAL6_2994200_1025400 METAL6_2994200_1023700 0.0034
R_VDD24_10732 METAL6_2994200_1023700 METAL6_2994200_1019000 0.0094
R_VDD24_10733 METAL6_2982200_1019000 METAL6_2988000_1019000 0.0116
R_VDD24_10734 METAL6_2988000_1019000 METAL6_2993000_1019000 0.01
R_VDD24_10735 METAL6_2993000_1019000 METAL6_2994200_1019000 0.0024
R_VDD24_10736 METAL6_1246300_3013700 METAL6_1234300_3013700 0.024
R_VDD24_10737 METAL6_3000000_1098500 METAL6_3000000_1100000 0.003
R_VDD24_10738 METAL6_3000000_1100000 METAL6_3000000_1108800 0.0176
R_VDD24_10739 METAL6_3000000_1108800 METAL6_3000000_1110300 0.003
R_VDD24_10740 METAL6_3000000_1110300 METAL6_3000000_1110500 0.0004
R_VDD24_10741 METAL6_3000000_1110500 METAL6_2994200_1110500 0.0116
R_VDD24_10742 METAL6_2994200_1110500 METAL6_2994200_1112000 0.003
R_VDD24_10743 METAL6_2994200_1112000 METAL6_2994200_1120800 0.0176
R_VDD24_10744 METAL6_2994200_1120800 METAL6_2994200_1122300 0.003
R_VDD24_10745 METAL6_2994200_1122300 METAL6_2994200_1129300 0.014
R_VDD24_10746 METAL6_2994200_1129300 METAL6_2994200_1132800 0.007
R_VDD24_10747 METAL6_2994200_1132800 METAL6_2994200_1134300 0.003
R_VDD24_10748 METAL6_2994200_1134300 METAL6_2994200_1141300 0.014
R_VDD24_10749 METAL6_2994200_1141300 METAL6_2994200_1153300 0.024
R_VDD24_10750 METAL6_2994200_1153300 METAL6_2994200_1160600 0.0146
R_VDD24_10751 METAL6_2994200_1160600 METAL6_2994200_1172600 0.024
R_VDD24_10752 METAL6_2994200_1172600 METAL6_2994200_1181700 0.0182
R_VDD24_10753 METAL6_2994200_1181700 METAL6_2993000_1181700 0.0024
R_VDD24_10754 METAL6_2993000_1181700 METAL6_2988000_1181700 0.01
R_VDD24_10755 METAL6_2988000_1181700 METAL6_2982200_1181700 0.0116
R_VDD24_10756 METAL6_2982200_1181700 METAL6_2975200_1181700 0.014
R_VDD24_10757 METAL6_2975200_1181700 METAL6_2965900_1181700 0.0186
R_VDD24_10758 METAL6_2965900_1181700 METAL6_2951900_1181700 0.028
R_VDD24_10759 METAL6_2951900_1181700 METAL6_2942200_1181700 0.0194
R_VDD24_10760 METAL6_2942200_1181700 METAL6_2930200_1181700 0.024
R_VDD24_10761 METAL6_2930200_1181700 METAL6_2925600_1181700 0.0092
R_VDD24_10762 METAL6_2925600_1181700 METAL6_2918200_1181700 0.0148
R_VDD24_10763 METAL6_2918200_1181700 METAL6_2913600_1181700 0.0092
R_VDD24_10764 METAL6_2913600_1181700 METAL6_2910900_1181700 0.0054
R_VDD24_10765 METAL6_2910900_1181700 METAL6_2901600_1181700 0.0186
R_VDD24_10766 METAL6_2901600_1181700 METAL6_2898900_1181700 0.0054
R_VDD24_10767 METAL6_2898900_1181700 METAL6_2897100_1181700 0.0036
R_VDD24_10768 METAL6_2897100_1181700 METAL6_2886900_1181700 0.0204
R_VDD24_10769 METAL6_2886900_1181700 METAL6_2874800_1181700 0.0242
R_VDD24_10770 METAL6_2874800_1181700 METAL6_2862800_1181700 0.024
R_VDD24_10771 METAL6_2862800_1181700 METAL6_2860600_1181700 0.0044
R_VDD24_10772 METAL6_2860600_1181700 METAL6_2850800_1181700 0.0196
R_VDD24_10773 METAL6_2850800_1181700 METAL6_2846600_1181700 0.0084
R_VDD24_10774 METAL6_2846600_1181700 METAL6_2843800_1181700 0.0056
R_VDD24_10775 METAL6_2843800_1181700 METAL6_2812000_1181700 0.0636
R_VDD24_10776 METAL6_2812000_1181700 METAL6_2805600_1181700 0.0128
R_VDD24_10777 METAL6_2805600_1181700 METAL6_2800000_1181700 0.0112
R_VDD24_10778 METAL6_2800000_1181700 METAL6_2798800_1181700 0.0024
R_VDD24_10779 METAL6_2798800_1181700 METAL6_2793600_1181700 0.0104
R_VDD24_10780 METAL6_2793600_1181700 METAL6_2788000_1181700 0.0112
R_VDD24_10781 METAL6_2788000_1181700 METAL6_2781600_1181700 0.0128
R_VDD24_10782 METAL6_2781600_1181700 METAL6_2765900_1181700 0.0314
R_VDD24_10783 METAL6_2765900_1181700 METAL6_2751900_1181700 0.028
R_VDD24_10784 METAL6_2751900_1181700 METAL6_2728200_1181700 0.0474
R_VDD24_10785 METAL6_2728200_1181700 METAL6_2710900_1181700 0.0346
R_VDD24_10786 METAL6_2710900_1181700 METAL6_2698900_1181700 0.024
R_VDD24_10787 METAL6_2698900_1181700 METAL6_2686900_1181700 0.024
R_VDD24_10788 METAL6_2686900_1181700 METAL6_2683200_1181700 0.0074
R_VDD24_10789 METAL6_2683200_1181700 METAL6_2676200_1181700 0.014
R_VDD24_10790 METAL6_2676200_1181700 METAL6_2664200_1181700 0.024
R_VDD24_10791 METAL6_2664200_1181700 METAL6_2660600_1181700 0.0072
R_VDD24_10792 METAL6_2660600_1181700 METAL6_2652200_1181700 0.0168
R_VDD24_10793 METAL6_2652200_1181700 METAL6_2646600_1181700 0.0112
R_VDD24_10794 METAL6_2646600_1181700 METAL6_2592400_1181700 0.1084
R_VDD24_10795 METAL6_2592400_1181700 METAL6_2580400_1181700 0.024
R_VDD24_10796 METAL6_2580400_1181700 METAL6_2568400_1181700 0.024
R_VDD24_10797 METAL6_2568400_1181700 METAL6_2565900_1181700 0.005
R_VDD24_10798 METAL6_2565900_1181700 METAL6_2556400_1181700 0.019
R_VDD24_10799 METAL6_2556400_1181700 METAL6_2551900_1181700 0.009
R_VDD24_10800 METAL6_2551900_1181700 METAL6_2537600_1181700 0.0286
R_VDD24_10801 METAL6_2537600_1181700 METAL6_2536000_1181700 0.0032
R_VDD24_10802 METAL6_2536000_1181700 METAL6_2535400_1181700 0.0012
R_VDD24_10803 METAL6_2535400_1181700 METAL6_2529000_1181700 0.0128
R_VDD24_10804 METAL6_2529000_1181700 METAL6_2528400_1181700 0.0012
R_VDD24_10805 METAL6_2528400_1181700 METAL6_2525600_1181700 0.0056
R_VDD24_10806 METAL6_2525600_1181700 METAL6_2524000_1181700 0.0032
R_VDD24_10807 METAL6_2524000_1181700 METAL5_2524000_1181700 0.1
R_VDD24_10808 METAL5_2524000_1181700 METAL5_2517000_1181700 0.028
R_VDD24_10809 METAL5_2517000_1181700 METAL5_2516400_1181700 0.0024
R_VDD24_10810 METAL5_2516400_1181700 METAL5_2513600_1181700 0.0112
R_VDD24_10811 METAL5_2513600_1181700 METAL5_2512000_1181700 0.0064
R_VDD24_10812 METAL5_2512000_1181700 METAL5_2510900_1181700 0.0044
R_VDD24_10813 METAL5_2510900_1181700 METAL5_2505000_1181700 0.0236
R_VDD24_10814 METAL5_2505000_1181700 METAL5_2504400_1181700 0.0024
R_VDD24_10815 METAL5_2504400_1181700 METAL5_2501600_1181700 0.0112
R_VDD24_10816 METAL5_2501600_1181700 METAL5_2500000_1181700 0.0064
R_VDD24_10817 METAL5_2500000_1181700 METAL6_2500000_1181700 0.1
R_VDD24_10818 METAL6_2500000_1181700 METAL6_2500000_1184600 0.0058
R_VDD24_10819 METAL6_2500000_1184600 METAL6_2500000_1191600 0.014
R_VDD24_10820 METAL6_2500000_1191600 METAL6_2500000_1193700 0.0042
R_VDD24_10821 METAL6_2500000_1193700 METAL6_2498900_1193700 0.0022
R_VDD24_10822 METAL6_2498900_1193700 METAL6_2493000_1193700 0.0118
R_VDD24_10823 METAL6_2493000_1193700 METAL6_2489600_1193700 0.0068
R_VDD24_10824 METAL6_2489600_1193700 METAL6_2488000_1193700 0.0032
R_VDD24_10825 METAL6_2488000_1193700 METAL6_2486900_1193700 0.0022
R_VDD24_10826 METAL6_2486900_1193700 METAL6_2481000_1193700 0.0118
R_VDD24_10827 METAL6_2481000_1193700 METAL6_2477600_1193700 0.0068
R_VDD24_10828 METAL6_2477600_1193700 METAL6_2476000_1193700 0.0032
R_VDD24_10829 METAL6_2476000_1193700 METAL6_2472600_1193700 0.0068
R_VDD24_10830 METAL6_2472600_1193700 METAL6_2469000_1193700 0.0072
R_VDD24_10831 METAL6_2469000_1193700 METAL6_2465600_1193700 0.0068
R_VDD24_10832 METAL6_2465600_1193700 METAL6_2464000_1193700 0.0032
R_VDD24_10833 METAL6_2464000_1193700 METAL6_2460600_1193700 0.0068
R_VDD24_10834 METAL6_2460600_1193700 METAL6_2448600_1193700 0.024
R_VDD24_10835 METAL6_2448600_1193700 METAL6_2446600_1193700 0.004
R_VDD24_10836 METAL6_2446600_1193700 METAL6_2436600_1193700 0.02
R_VDD24_10837 METAL6_2436600_1193700 METAL6_2419100_1193700 0.035
R_VDD24_10838 METAL6_2419100_1193700 METAL6_2407100_1193700 0.024
R_VDD24_10839 METAL6_2407100_1193700 METAL6_2405600_1193700 0.003
R_VDD24_10840 METAL6_2405600_1193700 METAL6_2402100_1193700 0.007
R_VDD24_10841 METAL6_2402100_1193700 METAL6_2395100_1193700 0.014
R_VDD24_10842 METAL6_2395100_1193700 METAL6_2393600_1193700 0.003
R_VDD24_10843 METAL6_2393600_1193700 METAL6_2383100_1193700 0.021
R_VDD24_10844 METAL6_2383100_1193700 METAL6_2381600_1193700 0.003
R_VDD24_10845 METAL6_2381600_1193700 METAL6_2371100_1193700 0.021
R_VDD24_10846 METAL6_2371100_1193700 METAL6_2369600_1193700 0.003
R_VDD24_10847 METAL6_2369600_1193700 METAL6_2365900_1193700 0.0074
R_VDD24_10848 METAL6_2365900_1193700 METAL6_2357600_1193700 0.0166
R_VDD24_10849 METAL6_2357600_1193700 METAL6_2351900_1193700 0.0114
R_VDD24_10850 METAL6_2351900_1193700 METAL6_2343700_1193700 0.0164
R_VDD24_10851 METAL6_2343700_1193700 METAL6_2310900_1193700 0.0656
R_VDD24_10852 METAL6_2310900_1193700 METAL6_2308600_1193700 0.0046
R_VDD24_10853 METAL6_2308600_1193700 METAL6_2298900_1193700 0.0194
R_VDD24_10854 METAL6_2298900_1193700 METAL6_2296600_1193700 0.0046
R_VDD24_10855 METAL6_2296600_1193700 METAL6_2286900_1193700 0.0194
R_VDD24_10856 METAL6_2286900_1193700 METAL6_2284600_1193700 0.0046
R_VDD24_10857 METAL6_2284600_1193700 METAL5_2284600_1193700 0.1
R_VDD24_10858 METAL5_2284600_1193700 METAL5_2284400_1193700 0.0008
R_VDD24_10859 METAL5_2284400_1193700 METAL5_2272600_1193700 0.0472
R_VDD24_10860 METAL5_2272600_1193700 METAL5_2272400_1193700 0.0008
R_VDD24_10861 METAL5_2272400_1193700 METAL5_2260600_1193700 0.0472
R_VDD24_10862 METAL5_2260600_1193700 METAL5_2260400_1193700 0.0008
R_VDD24_10863 METAL5_2260400_1193700 METAL5_2258600_1193700 0.0072
R_VDD24_10864 METAL5_2258600_1193700 METAL5_2248700_1193700 0.0396
R_VDD24_10865 METAL5_2248700_1193700 METAL5_2248600_1193700 0.0004
R_VDD24_10866 METAL5_2248600_1193700 METAL5_2248400_1193700 0.0008
R_VDD24_10867 METAL5_2248400_1193700 METAL5_2246600_1193700 0.0072
R_VDD24_10868 METAL5_2246600_1193700 METAL5_2236700_1193700 0.0396
R_VDD24_10869 METAL5_2236700_1193700 METAL5_2236600_1193700 0.0004
R_VDD24_10870 METAL5_2236600_1193700 METAL5_2234600_1193700 0.008
R_VDD24_10871 METAL5_2234600_1193700 METAL5_2233900_1193700 0.0028
R_VDD24_10872 METAL5_2233900_1193700 METAL5_2224700_1193700 0.0368
R_VDD24_10873 METAL5_2224700_1193700 METAL5_2222600_1193700 0.0084
R_VDD24_10874 METAL5_2222600_1193700 METAL5_2221900_1193700 0.0028
R_VDD24_10875 METAL5_2221900_1193700 METAL5_2212700_1193700 0.0368
R_VDD24_10876 METAL5_2212700_1193700 METAL5_2210600_1193700 0.0084
R_VDD24_10877 METAL5_2210600_1193700 METAL5_2209900_1193700 0.0028
R_VDD24_10878 METAL5_2209900_1193700 METAL5_2200700_1193700 0.0368
R_VDD24_10879 METAL5_2200700_1193700 METAL6_2200700_1193700 0.1
R_VDD24_10880 METAL6_2200700_1193700 METAL6_2189900_1193700 0.0216
R_VDD24_10881 METAL6_2189900_1193700 METAL6_2188700_1193700 0.0024
R_VDD24_10882 METAL6_2188700_1193700 METAL6_2177900_1193700 0.0216
R_VDD24_10883 METAL6_2177900_1193700 METAL6_2176700_1193700 0.0024
R_VDD24_10884 METAL6_2176700_1193700 METAL6_2165900_1193700 0.0216
R_VDD24_10885 METAL6_2165900_1193700 METAL6_2165400_1193700 0.001
R_VDD24_10886 METAL6_2165400_1193700 METAL6_2153900_1193700 0.023
R_VDD24_10887 METAL6_2153900_1193700 METAL6_2153400_1193700 0.001
R_VDD24_10888 METAL6_2153400_1193700 METAL6_2151900_1193700 0.003
R_VDD24_10889 METAL6_2151900_1193700 METAL6_2141900_1193700 0.02
R_VDD24_10890 METAL6_2141900_1193700 METAL6_2141400_1193700 0.001
R_VDD24_10891 METAL6_2141400_1193700 METAL6_2129900_1193700 0.023
R_VDD24_10892 METAL6_2129900_1193700 METAL6_2129700_1193700 0.0004
R_VDD24_10893 METAL6_2129700_1193700 METAL6_2125600_1193700 0.0082
R_VDD24_10894 METAL6_2125600_1193700 METAL6_2121400_1193700 0.0084
R_VDD24_10895 METAL6_2121400_1193700 METAL6_2117900_1193700 0.007
R_VDD24_10896 METAL6_2117900_1193700 METAL6_2113900_1193700 0.008
R_VDD24_10897 METAL6_2113900_1193700 METAL6_2113600_1193700 0.0006
R_VDD24_10898 METAL6_2113600_1193700 METAL6_2101900_1193700 0.0234
R_VDD24_10899 METAL6_2101900_1193700 METAL6_2101600_1193700 0.0006
R_VDD24_10900 METAL6_2101600_1193700 METAL6_2089900_1193700 0.0234
R_VDD24_10901 METAL6_2089900_1193700 METAL6_2079700_1193700 0.0204
R_VDD24_10902 METAL6_2079700_1193700 METAL6_2077900_1193700 0.0036
R_VDD24_10903 METAL6_2077900_1193700 METAL6_2067700_1193700 0.0204
R_VDD24_10904 METAL6_2067700_1193700 METAL6_2060600_1193700 0.0142
R_VDD24_10905 METAL6_2060600_1193700 METAL6_2058800_1193700 0.0036
R_VDD24_10906 METAL6_2058800_1193700 METAL6_2055700_1193700 0.0062
R_VDD24_10907 METAL6_2055700_1193700 METAL6_2046800_1193700 0.0178
R_VDD24_10908 METAL6_2046800_1193700 METAL6_2046600_1193700 0.0004
R_VDD24_10909 METAL6_2046600_1193700 METAL6_2046400_1193700 0.0004
R_VDD24_10910 METAL6_2046400_1193700 METAL6_2043700_1193700 0.0054
R_VDD24_10911 METAL6_2043700_1193700 METAL6_2034800_1193700 0.0178
R_VDD24_10912 METAL6_2034800_1193700 METAL6_2031700_1193700 0.0062
R_VDD24_10913 METAL6_2031700_1193700 METAL6_2030900_1193700 0.0016
R_VDD24_10914 METAL6_2030900_1193700 METAL6_2026400_1193700 0.009
R_VDD24_10915 METAL6_2026400_1193700 METAL6_2021200_1193700 0.0104
R_VDD24_10916 METAL6_2021200_1193700 METAL6_2019700_1193700 0.003
R_VDD24_10917 METAL6_2019700_1193700 METAL6_2018900_1193700 0.0016
R_VDD24_10918 METAL6_2018900_1193700 METAL6_2014400_1193700 0.009
R_VDD24_10919 METAL6_2014400_1193700 METAL6_2012000_1193700 0.0048
R_VDD24_10920 METAL6_2012000_1193700 METAL6_2006900_1193700 0.0102
R_VDD24_10921 METAL6_2006900_1193700 METAL6_2002400_1193700 0.009
R_VDD24_10922 METAL6_2002400_1193700 METAL6_2000000_1193700 0.0048
R_VDD24_10923 METAL6_2000000_1193700 METAL6_1988000_1193700 0.024
R_VDD24_10924 METAL6_1988000_1193700 METAL6_1951900_1193700 0.0722
R_VDD24_10925 METAL6_1951900_1193700 METAL6_1951800_1193700 0.0002
R_VDD24_10926 METAL6_1951800_1193700 METAL6_1939800_1193700 0.024
R_VDD24_10927 METAL6_1939800_1193700 METAL6_1931200_1193700 0.0172
R_VDD24_10928 METAL6_1931200_1193700 METAL6_1927800_1193700 0.0068
R_VDD24_10929 METAL6_1927800_1193700 METAL6_1926200_1193700 0.0032
R_VDD24_10930 METAL6_1926200_1193700 METAL6_1925600_1193700 0.0012
R_VDD24_10931 METAL6_1925600_1193700 METAL6_1919200_1193700 0.0128
R_VDD24_10932 METAL6_1919200_1193700 METAL5_1919200_1193700 0.1
R_VDD24_10933 METAL5_1919200_1193700 METAL5_1913600_1193700 0.0224
R_VDD24_10934 METAL5_1913600_1193700 METAL5_1907400_1193700 0.0248
R_VDD24_10935 METAL5_1907400_1193700 METAL5_1907200_1193700 0.0008
R_VDD24_10936 METAL5_1907200_1193700 METAL5_1901600_1193700 0.0224
R_VDD24_10937 METAL5_1901600_1193700 METAL5_1900700_1193700 0.0036
R_VDD24_10938 METAL5_1900700_1193700 METAL5_1895200_1193700 0.022
R_VDD24_10939 METAL5_1895200_1193700 METAL5_1889600_1193700 0.0224
R_VDD24_10940 METAL5_1889600_1193700 METAL5_1889400_1193700 0.0008
R_VDD24_10941 METAL5_1889400_1193700 METAL5_1888700_1193700 0.0028
R_VDD24_10942 METAL5_1888700_1193700 METAL5_1883200_1193700 0.022
R_VDD24_10943 METAL5_1883200_1193700 METAL5_1877600_1193700 0.0224
R_VDD24_10944 METAL5_1877600_1193700 METAL5_1877400_1193700 0.0008
R_VDD24_10945 METAL5_1877400_1193700 METAL5_1876700_1193700 0.0028
R_VDD24_10946 METAL5_1876700_1193700 METAL5_1874700_1193700 0.008
R_VDD24_10947 METAL5_1874700_1193700 METAL5_1871200_1193700 0.014
R_VDD24_10948 METAL5_1871200_1193700 METAL5_1870600_1193700 0.0024
R_VDD24_10949 METAL5_1870600_1193700 METAL5_1865400_1193700 0.0208
R_VDD24_10950 METAL5_1865400_1193700 METAL5_1864700_1193700 0.0028
R_VDD24_10951 METAL5_1864700_1193700 METAL5_1859200_1193700 0.022
R_VDD24_10952 METAL5_1859200_1193700 METAL5_1858600_1193700 0.0024
R_VDD24_10953 METAL5_1858600_1193700 METAL5_1858400_1193700 0.0008
R_VDD24_10954 METAL5_1858400_1193700 METAL5_1853400_1193700 0.02
R_VDD24_10955 METAL5_1853400_1193700 METAL5_1852700_1193700 0.0028
R_VDD24_10956 METAL5_1852700_1193700 METAL5_1846800_1193700 0.0236
R_VDD24_10957 METAL5_1846800_1193700 METAL5_1846600_1193700 0.0008
R_VDD24_10958 METAL5_1846600_1193700 METAL5_1846400_1193700 0.0008
R_VDD24_10959 METAL5_1846400_1193700 METAL5_1844800_1193700 0.0064
R_VDD24_10960 METAL5_1844800_1193700 METAL5_1834600_1193700 0.0408
R_VDD24_10961 METAL5_1834600_1193700 METAL5_1834400_1193700 0.0008
R_VDD24_10962 METAL5_1834400_1193700 METAL6_1834400_1193700 0.1
R_VDD24_10963 METAL6_1834400_1193700 METAL6_1832800_1193700 0.0032
R_VDD24_10964 METAL6_1832800_1193700 METAL6_1822600_1193700 0.0204
R_VDD24_10965 METAL6_1822600_1193700 METAL6_1822400_1193700 0.0004
R_VDD24_10966 METAL6_1822400_1193700 METAL6_1820800_1193700 0.0032
R_VDD24_10967 METAL6_1820800_1193700 METAL6_1812000_1193700 0.0176
R_VDD24_10968 METAL6_1812000_1193700 METAL6_1800000_1193700 0.024
R_VDD24_10969 METAL6_1800000_1193700 METAL6_1788000_1193700 0.024
R_VDD24_10970 METAL6_1788000_1193700 METAL6_1755700_1193700 0.0646
R_VDD24_10971 METAL6_1755700_1193700 METAL6_1753800_1193700 0.0038
R_VDD24_10972 METAL6_1753800_1193700 METAL6_1751800_1193700 0.004
R_VDD24_10973 METAL6_1751800_1193700 METAL6_1751400_1193700 0.0008
R_VDD24_10974 METAL6_1751400_1193700 METAL6_1744000_1193700 0.0148
R_VDD24_10975 METAL6_1744000_1193700 METAL6_1743700_1193700 0.0006
R_VDD24_10976 METAL6_1743700_1193700 METAL6_1741800_1193700 0.0038
R_VDD24_10977 METAL6_1741800_1193700 METAL6_1739800_1193700 0.004
R_VDD24_10978 METAL6_1739800_1193700 METAL6_1731700_1193700 0.0162
R_VDD24_10979 METAL6_1731700_1193700 METAL6_1729800_1193700 0.0038
R_VDD24_10980 METAL6_1729800_1193700 METAL6_1727800_1193700 0.004
R_VDD24_10981 METAL6_1727800_1193700 METAL6_1719700_1193700 0.0162
R_VDD24_10982 METAL6_1719700_1193700 METAL6_1717800_1193700 0.0038
R_VDD24_10983 METAL6_1717800_1193700 METAL6_1710800_1193700 0.014
R_VDD24_10984 METAL6_1710800_1193700 METAL6_1707700_1193700 0.0062
R_VDD24_10985 METAL6_1707700_1193700 METAL6_1699000_1193700 0.0174
R_VDD24_10986 METAL6_1699000_1193700 METAL6_1692000_1193700 0.014
R_VDD24_10987 METAL6_1692000_1193700 METAL6_1680000_1193700 0.024
R_VDD24_10988 METAL6_1680000_1193700 METAL6_1670800_1193700 0.0184
R_VDD24_10989 METAL6_1670800_1193700 METAL6_1668000_1193700 0.0056
R_VDD24_10990 METAL6_1668000_1193700 METAL6_1658800_1193700 0.0184
R_VDD24_10991 METAL6_1658800_1193700 METAL6_1646800_1193700 0.024
R_VDD24_10992 METAL6_1646800_1193700 METAL6_1634800_1193700 0.024
R_VDD24_10993 METAL6_1634800_1193700 METAL6_1632800_1193700 0.004
R_VDD24_10994 METAL6_1632800_1193700 METAL6_1627800_1193700 0.01
R_VDD24_10995 METAL6_1627800_1193700 METAL6_1615800_1193700 0.024
R_VDD24_10996 METAL6_1615800_1193700 METAL6_1612700_1193700 0.0062
R_VDD24_10997 METAL6_1612700_1193700 METAL6_1612000_1193700 0.0014
R_VDD24_10998 METAL6_1612000_1193700 METAL6_1607900_1193700 0.0082
R_VDD24_10999 METAL6_1607900_1193700 METAL6_1603800_1193700 0.0082
R_VDD24_11000 METAL6_1603800_1193700 METAL6_1600700_1193700 0.0062
R_VDD24_11001 METAL6_1600700_1193700 METAL6_1600000_1193700 0.0014
R_VDD24_11002 METAL6_1600000_1193700 METAL6_1591800_1193700 0.0164
R_VDD24_11003 METAL6_1591800_1193700 METAL6_1588700_1193700 0.0062
R_VDD24_11004 METAL6_1588700_1193700 METAL6_1588000_1193700 0.0014
R_VDD24_11005 METAL6_1588000_1193700 METAL6_1576700_1193700 0.0226
R_VDD24_11006 METAL6_1576700_1193700 METAL6_1576000_1193700 0.0014
R_VDD24_11007 METAL6_1576000_1193700 METAL6_1574700_1193700 0.0026
R_VDD24_11008 METAL6_1574700_1193700 METAL6_1557000_1193700 0.0354
R_VDD24_11009 METAL6_1557000_1193700 METAL6_1555400_1193700 0.0032
R_VDD24_11010 METAL6_1555400_1193700 METAL6_1551800_1193700 0.0072
R_VDD24_11011 METAL6_1551800_1193700 METAL6_1539800_1193700 0.024
R_VDD24_11012 METAL6_1539800_1193700 METAL6_1527800_1193700 0.024
R_VDD24_11013 METAL6_1527800_1193700 METAL6_1512000_1193700 0.0316
R_VDD24_11014 METAL6_1512000_1193700 METAL6_1510400_1193700 0.0032
R_VDD24_11015 METAL6_1510400_1193700 METAL6_1503400_1193700 0.014
R_VDD24_11016 METAL6_1503400_1193700 METAL6_1500000_1193700 0.0068
R_VDD24_11017 METAL6_1500000_1193700 METAL6_1498300_1193700 0.0034
R_VDD24_11018 METAL6_1498300_1193700 METAL6_1491400_1193700 0.0138
R_VDD24_11019 METAL6_1491400_1193700 METAL6_1488000_1193700 0.0068
R_VDD24_11020 METAL6_1488000_1193700 METAL6_1479400_1193700 0.0172
R_VDD24_11021 METAL6_1479400_1193700 METAL6_1443700_1193700 0.0714
R_VDD24_11022 METAL6_1443700_1193700 METAL6_1432800_1193700 0.0218
R_VDD24_11023 METAL6_1432800_1193700 METAL6_1431700_1193700 0.0022
R_VDD24_11024 METAL6_1431700_1193700 METAL6_1424000_1193700 0.0154
R_VDD24_11025 METAL6_1424000_1193700 METAL6_1419700_1193700 0.0086
R_VDD24_11026 METAL6_1419700_1193700 METAL6_1412000_1193700 0.0154
R_VDD24_11027 METAL6_1412000_1193700 METAL6_1400000_1193700 0.024
R_VDD24_11028 METAL6_1400000_1193700 METAL6_1388000_1193700 0.024
R_VDD24_11029 METAL6_1388000_1193700 METAL6_1337000_1193700 0.102
R_VDD24_11030 METAL6_1337000_1193700 METAL6_1325000_1193700 0.024
R_VDD24_11031 METAL6_1325000_1193700 METAL6_1324000_1193700 0.002
R_VDD24_11032 METAL6_1324000_1193700 METAL6_1323800_1193700 0.0004
R_VDD24_11033 METAL6_1323800_1193700 METAL6_1313000_1193700 0.0216
R_VDD24_11034 METAL6_1313000_1193700 METAL6_1312000_1193700 0.002
R_VDD24_11035 METAL6_1312000_1193700 METAL6_1311800_1193700 0.0004
R_VDD24_11036 METAL6_1311800_1193700 METAL6_1301000_1193700 0.0216
R_VDD24_11037 METAL6_1301000_1193700 METAL6_1300000_1193700 0.002
R_VDD24_11038 METAL6_1300000_1193700 METAL6_1299800_1193700 0.0004
R_VDD24_11039 METAL6_1299800_1193700 METAL6_1289000_1193700 0.0216
R_VDD24_11040 METAL6_1289000_1193700 METAL6_1288000_1193700 0.002
R_VDD24_11041 METAL6_1288000_1193700 METAL6_1287800_1193700 0.0004
R_VDD24_11042 METAL6_1287800_1193700 METAL6_1286700_1193700 0.0022
R_VDD24_11043 METAL6_1286700_1193700 METAL6_1274700_1193700 0.024
R_VDD24_11044 METAL6_1274700_1193700 METAL6_1266800_1193700 0.0158
R_VDD24_11045 METAL6_1266800_1193700 METAL6_1262700_1193700 0.0082
R_VDD24_11046 METAL6_1262700_1193700 METAL6_1259800_1193700 0.0058
R_VDD24_11047 METAL6_1259800_1193700 METAL6_1258300_1193700 0.003
R_VDD24_11048 METAL6_1258300_1193700 METAL6_1253300_1193700 0.01
R_VDD24_11049 METAL6_1253300_1193700 METAL6_1247800_1193700 0.011
R_VDD24_11050 METAL6_1247800_1193700 METAL6_1246300_1193700 0.003
R_VDD24_11051 METAL6_1246300_1193700 METAL6_1242700_1193700 0.0072
R_VDD24_11052 METAL6_1242700_1193700 METAL6_1242700_1193800 0.0002
R_VDD24_11053 METAL6_1242700_1193800 METAL6_1242700_1205700 0.0238
R_VDD24_11054 METAL6_1242700_1205700 METAL6_1242700_1217700 0.024
R_VDD24_11055 METAL6_1242700_1217700 METAL6_1242700_1223700 0.012
R_VDD24_11056 METAL6_1242700_1223700 METAL6_1242700_1229700 0.012
R_VDD24_11057 METAL6_1242700_1229700 METAL6_1242700_1235700 0.012
R_VDD24_11058 METAL6_1242700_1235700 METAL6_1242700_1238000 0.0046
R_VDD24_11059 METAL6_1242700_1238000 METAL6_1242700_1247700 0.0194
R_VDD24_11060 METAL6_1242700_1247700 METAL6_1242700_1250000 0.0046
R_VDD24_11061 METAL6_1242700_1250000 METAL6_1242700_1259700 0.0194
R_VDD24_11062 METAL6_1242700_1259700 METAL6_1242700_1262000 0.0046
R_VDD24_11063 METAL6_1242700_1262000 METAL6_1242700_1271700 0.0194
R_VDD24_11064 METAL6_1242700_1271700 METAL6_1242700_1273000 0.0026
R_VDD24_11065 METAL6_1242700_1273000 METAL6_1242700_1283700 0.0214
R_VDD24_11066 METAL6_1242700_1283700 METAL6_1242700_1295700 0.024
R_VDD24_11067 METAL6_1242700_1295700 METAL6_1242700_1302000 0.0126
R_VDD24_11068 METAL6_1242700_1302000 METAL6_1242700_1307700 0.0114
R_VDD24_11069 METAL6_1242700_1307700 METAL6_1242700_1314000 0.0126
R_VDD24_11070 METAL6_1242700_1314000 METAL5_1242700_1314000 0.1
R_VDD24_11071 METAL5_1242700_1314000 METAL5_1242700_1326000 0.048
R_VDD24_11072 METAL5_1242700_1326000 METAL5_1242700_1338000 0.048
R_VDD24_11073 METAL5_1242700_1338000 METAL5_1242700_1350000 0.048
R_VDD24_11074 METAL5_1242700_1350000 METAL5_1242700_1357000 0.028
R_VDD24_11075 METAL5_1242700_1357000 METAL5_1242700_1362000 0.02
R_VDD24_11076 METAL5_1242700_1362000 METAL6_1242700_1362000 0.1
R_VDD24_11077 METAL6_1242700_1362000 METAL6_1242700_1369000 0.014
R_VDD24_11078 METAL6_1242700_1369000 METAL6_1235800_1369000 0.0138
R_VDD24_11079 METAL6_1235800_1369000 METAL6_1235800_1374000 0.01
R_VDD24_11080 METAL6_1235800_1374000 METAL6_1235800_1381000 0.014
R_VDD24_11081 METAL6_1235800_1381000 METAL6_1235800_1386600 0.0112
R_VDD24_11082 METAL6_1235800_1386600 METAL6_1235800_1393000 0.0128
R_VDD24_11083 METAL6_1235800_1393000 METAL6_1235800_1405000 0.024
R_VDD24_11084 METAL6_1235800_1405000 METAL6_1235800_1437700 0.0654
R_VDD24_11085 METAL6_1235800_1437700 METAL6_1235800_1449700 0.024
R_VDD24_11086 METAL6_1235800_1449700 METAL6_1235800_1461700 0.024
R_VDD24_11087 METAL6_1235800_1461700 METAL6_1235800_1492300 0.0612
R_VDD24_11088 METAL6_1235800_1492300 METAL6_1235800_1504300 0.024
R_VDD24_11089 METAL6_1235800_1504300 METAL6_1235800_1516300 0.024
R_VDD24_11090 METAL6_1235800_1516300 METAL6_1235800_1528300 0.024
R_VDD24_11091 METAL6_1235800_1528300 METAL6_1235800_1540300 0.024
R_VDD24_11092 METAL6_1235800_1540300 METAL6_1234300_1540300 0.003
R_VDD24_11093 METAL6_1234300_1540300 METAL6_1230700_1540300 0.0072
R_VDD24_11094 METAL6_1230700_1540300 METAL6_1222300_1540300 0.0168
R_VDD24_11095 METAL6_1222300_1540300 METAL5_1222300_1540300 0.1
R_VDD24_11096 METAL5_1222300_1540300 METAL5_1222300_1552300 0.048
R_VDD24_11097 METAL5_1222300_1552300 METAL5_1222300_1554500 0.0088
R_VDD24_11098 METAL5_1222300_1554500 METAL5_1222300_1564300 0.0392
R_VDD24_11099 METAL5_1222300_1564300 METAL6_1222300_1564300 0.1
R_VDD24_11100 METAL6_1222300_1564300 METAL6_1222300_1571300 0.014
R_VDD24_11101 METAL6_1222300_1571300 METAL6_1222300_1576300 0.01
R_VDD24_11102 METAL6_1222300_1576300 METAL6_1222300_1714500 0.2764
R_VDD24_11103 METAL6_1222300_1714500 METAL6_1222300_1720500 0.012
R_VDD24_11104 METAL6_1222300_1720500 METAL6_1222300_1726500 0.012
R_VDD24_11105 METAL6_1222300_1726500 METAL6_1222300_1731700 0.0104
R_VDD24_11106 METAL6_1222300_1731700 METAL6_1222300_1738500 0.0136
R_VDD24_11107 METAL6_1222300_1738500 METAL6_1222300_1750500 0.024
R_VDD24_11108 METAL6_1222300_1750500 METAL6_1222300_1762500 0.024
R_VDD24_11109 METAL6_1222300_1762500 METAL6_1222300_1774500 0.024
R_VDD24_11110 METAL6_1222300_1774500 METAL6_1222300_1802500 0.056
R_VDD24_11111 METAL6_1222300_1802500 METAL6_1222300_1814500 0.024
R_VDD24_11112 METAL6_1222300_1814500 METAL6_1222300_1826500 0.024
R_VDD24_11113 METAL6_1222300_1826500 METAL6_1222300_1838500 0.024
R_VDD24_11114 METAL6_1222300_1838500 METAL6_1222300_1852300 0.0276
R_VDD24_11115 METAL6_1222300_1852300 METAL6_1222300_1866300 0.028
R_VDD24_11116 METAL6_1222300_1866300 METAL6_1222300_1902500 0.0724
R_VDD24_11117 METAL6_1222300_1902500 METAL6_1222300_1914500 0.024
R_VDD24_11118 METAL6_1222300_1914500 METAL6_1222300_1926500 0.024
R_VDD24_11119 METAL6_1222300_1926500 METAL6_1222300_1938500 0.024
R_VDD24_11120 METAL6_1222300_1938500 METAL6_1218700_1938500 0.0072
R_VDD24_11121 METAL6_1218700_1938500 METAL6_1216400_1938500 0.0046
R_VDD24_11122 METAL6_1216400_1938500 METAL6_1212000_1938500 0.0088
R_VDD24_11123 METAL6_1212000_1938500 METAL6_1212000_1940500 0.004
R_VDD24_11124 METAL6_1212000_1940500 METAL6_1212000_1950500 0.02
R_VDD24_11125 METAL6_1212000_1950500 METAL6_1210300_1950500 0.0034
R_VDD24_11126 METAL6_1210300_1950500 METAL6_1210300_1951000 0.001
R_VDD24_11127 METAL6_1210300_1951000 METAL6_1210300_1952500 0.003
R_VDD24_11128 METAL6_1210300_1952500 METAL6_1210300_1962500 0.02
R_VDD24_11129 METAL6_1210300_1962500 METAL6_1210300_1963000 0.001
R_VDD24_11130 METAL6_1210300_1963000 METAL6_1210300_1964500 0.003
R_VDD24_11131 METAL6_1210300_1964500 METAL6_1210300_1975000 0.021
R_VDD24_11132 METAL6_1210300_1975000 METAL6_1210300_1976500 0.003
R_VDD24_11133 METAL6_1210300_1976500 METAL6_1210300_1987000 0.021
R_VDD24_11134 METAL6_1210300_1987000 METAL6_1210300_2014500 0.055
R_VDD24_11135 METAL6_1210300_2014500 METAL6_1210300_2026500 0.024
R_VDD24_11136 METAL6_1210300_2026500 METAL6_1210300_2038500 0.024
R_VDD24_11137 METAL6_1210300_2038500 METAL6_1210300_2114500 0.152
R_VDD24_11138 METAL6_1210300_2114500 METAL6_1210300_2126500 0.024
R_VDD24_11139 METAL6_1210300_2126500 METAL6_1210300_2138500 0.024
R_VDD24_11140 METAL6_1210300_2138500 METAL6_1210300_2147300 0.0176
R_VDD24_11141 METAL6_1210300_2147300 METAL6_1210300_2154300 0.014
R_VDD24_11142 METAL6_1210300_2154300 METAL6_1210300_2163000 0.0174
R_VDD24_11143 METAL6_1210300_2163000 METAL6_1210300_2166300 0.0066
R_VDD24_11144 METAL6_1210300_2166300 METAL6_1210300_2175000 0.0174
R_VDD24_11145 METAL6_1210300_2175000 METAL6_1210300_2178300 0.0066
R_VDD24_11146 METAL6_1210300_2178300 METAL6_1210300_2187000 0.0174
R_VDD24_11147 METAL6_1210300_2187000 METAL6_1210300_2190300 0.0066
R_VDD24_11148 METAL6_1210300_2190300 METAL6_1210300_2202300 0.024
R_VDD24_11149 METAL6_1210300_2202300 METAL6_1210300_2222500 0.0404
R_VDD24_11150 METAL6_1210300_2222500 METAL6_1210300_2234500 0.024
R_VDD24_11151 METAL6_1210300_2234500 METAL6_1210300_2246500 0.024
R_VDD24_11152 METAL6_1210300_2246500 METAL6_1210300_2268500 0.044
R_VDD24_11153 METAL6_1210300_2268500 METAL6_1210300_2288000 0.039
R_VDD24_11154 METAL6_1210300_2288000 METAL6_1210300_2300000 0.024
R_VDD24_11155 METAL6_1210300_2300000 METAL6_1210300_2312000 0.024
R_VDD24_11156 METAL6_1210300_2312000 METAL6_1210300_2316000 0.008
R_VDD24_11157 METAL6_1210300_2316000 METAL6_1210300_2317000 0.002
R_VDD24_11158 METAL6_1210300_2317000 METAL6_1210300_2326000 0.018
R_VDD24_11159 METAL6_1210300_2326000 METAL6_1210300_2328000 0.004
R_VDD24_11160 METAL6_1210300_2328000 METAL6_1210300_2329000 0.002
R_VDD24_11161 METAL6_1210300_2329000 METAL6_1210300_2338000 0.018
R_VDD24_11162 METAL6_1210300_2338000 METAL6_1210300_2340000 0.004
R_VDD24_11163 METAL6_1210300_2340000 METAL6_1210300_2341000 0.002
R_VDD24_11164 METAL6_1210300_2341000 METAL6_1210300_2350000 0.018
R_VDD24_11165 METAL6_1210300_2350000 METAL6_1210300_2352000 0.004
R_VDD24_11166 METAL6_1210300_2352000 METAL6_1210300_2353000 0.002
R_VDD24_11167 METAL6_1210300_2353000 METAL6_1210300_2362000 0.018
R_VDD24_11168 METAL6_1210300_2362000 METAL6_1210300_2364000 0.004
R_VDD24_11169 METAL6_1210300_2364000 METAL6_1210300_2365000 0.002
R_VDD24_11170 METAL6_1210300_2365000 METAL6_1210300_2374000 0.018
R_VDD24_11171 METAL6_1210300_2374000 METAL6_1210300_2376000 0.004
R_VDD24_11172 METAL6_1210300_2376000 METAL6_1210300_2377000 0.002
R_VDD24_11173 METAL6_1210300_2377000 METAL6_1210300_2388000 0.022
R_VDD24_11174 METAL6_1210300_2388000 METAL6_1210300_2389000 0.002
R_VDD24_11175 METAL6_1210300_2389000 METAL6_1210300_2395000 0.012
R_VDD24_11176 METAL6_1210300_2395000 METAL6_1210300_2400000 0.01
R_VDD24_11177 METAL6_1210300_2400000 METAL6_1210300_2401000 0.002
R_VDD24_11178 METAL6_1210300_2401000 METAL6_1210300_2407000 0.012
R_VDD24_11179 METAL6_1210300_2407000 METAL6_1210300_2412000 0.01
R_VDD24_11180 METAL6_1210300_2412000 METAL6_1210300_2413000 0.002
R_VDD24_11181 METAL6_1210300_2413000 METAL6_1210300_2419000 0.012
R_VDD24_11182 METAL6_1210300_2419000 METAL6_1210300_2424000 0.01
R_VDD24_11183 METAL6_1210300_2424000 METAL6_1210300_2436000 0.024
R_VDD24_11184 METAL6_1210300_2436000 METAL6_1210300_2438000 0.004
R_VDD24_11185 METAL6_1210300_2438000 METAL6_1210300_2444000 0.012
R_VDD24_11186 METAL6_1210300_2444000 METAL6_1210300_2450000 0.012
R_VDD24_11187 METAL6_1210300_2450000 METAL6_1210300_2456000 0.012
R_VDD24_11188 METAL6_1210300_2456000 METAL6_1210300_2462000 0.012
R_VDD24_11189 METAL6_1210300_2462000 METAL6_1210300_2468000 0.012
R_VDD24_11190 METAL6_1210300_2468000 METAL6_1210300_2481000 0.026
R_VDD24_11191 METAL6_1210300_2481000 METAL6_1210300_2493000 0.024
R_VDD24_11192 METAL6_1210300_2493000 METAL6_1210300_2505000 0.024
R_VDD24_11193 METAL6_1210300_2505000 METAL6_1210300_2512000 0.014
R_VDD24_11194 METAL6_1210300_2512000 METAL6_1210300_2517700 0.0114
R_VDD24_11195 METAL6_1210300_2517700 METAL6_1210300_2524000 0.0126
R_VDD24_11196 METAL6_1210300_2524000 METAL6_1210300_2529700 0.0114
R_VDD24_11197 METAL6_1210300_2529700 METAL6_1210300_2536000 0.0126
R_VDD24_11198 METAL6_1210300_2536000 METAL6_1210300_2541700 0.0114
R_VDD24_11199 METAL6_1210300_2541700 METAL6_1210300_2548000 0.0126
R_VDD24_11200 METAL6_1210300_2548000 METAL6_1210300_2553700 0.0114
R_VDD24_11201 METAL6_1210300_2553700 METAL6_1210300_2589000 0.0706
R_VDD24_11202 METAL6_1210300_2589000 METAL6_1210300_2603000 0.028
R_VDD24_11203 METAL6_1210300_2603000 METAL6_1210300_2644000 0.082
R_VDD24_11204 METAL6_1210300_2644000 METAL6_1210300_2656000 0.024
R_VDD24_11205 METAL6_1210300_2656000 METAL6_1210300_2665700 0.0194
R_VDD24_11206 METAL6_1210300_2665700 METAL6_1210300_2668000 0.0046
R_VDD24_11207 METAL6_1210300_2668000 METAL6_1210300_2701000 0.066
R_VDD24_11208 METAL6_1210300_2701000 METAL6_1210300_2701700 0.0014
R_VDD24_11209 METAL6_1210300_2701700 METAL6_1210300_2713000 0.0226
R_VDD24_11210 METAL6_1210300_2713000 METAL6_1210300_2713700 0.0014
R_VDD24_11211 METAL6_1210300_2713700 METAL6_1210300_2724000 0.0206
R_VDD24_11212 METAL6_1210300_2724000 METAL6_1210300_2725000 0.002
R_VDD24_11213 METAL6_1210300_2725000 METAL6_1210300_2725700 0.0014
R_VDD24_11214 METAL6_1210300_2725700 METAL6_1210300_2736000 0.0206
R_VDD24_11215 METAL6_1210300_2736000 METAL6_1210300_2737000 0.002
R_VDD24_11216 METAL6_1210300_2737000 METAL6_1210300_2748000 0.022
R_VDD24_11217 METAL6_1210300_2748000 METAL6_1210300_2777000 0.058
R_VDD24_11218 METAL6_1210300_2777000 METAL6_1210300_2789000 0.024
R_VDD24_11219 METAL6_1210300_2789000 METAL6_1210300_2801000 0.024
R_VDD24_11220 METAL6_1210300_2801000 METAL6_1210300_2801700 0.0014
R_VDD24_11221 METAL6_1210300_2801700 METAL6_1210300_2803000 0.0026
R_VDD24_11222 METAL6_1210300_2803000 METAL6_1210300_2808000 0.01
R_VDD24_11223 METAL6_1210300_2808000 METAL6_1210300_2813700 0.0114
R_VDD24_11224 METAL6_1210300_2813700 METAL6_1210300_2825700 0.024
R_VDD24_11225 METAL6_1210300_2825700 METAL6_1210300_2901700 0.152
R_VDD24_11226 METAL6_1210300_2901700 METAL6_1210300_2913000 0.0226
R_VDD24_11227 METAL6_1210300_2913000 METAL6_1210300_2913700 0.0014
R_VDD24_11228 METAL6_1210300_2913700 METAL6_1210300_2925000 0.0226
R_VDD24_11229 METAL6_1210300_2925000 METAL6_1210300_2925700 0.0014
R_VDD24_11230 METAL6_1210300_2925700 METAL6_1210300_2937000 0.0226
R_VDD24_11231 METAL6_1210300_2937000 METAL6_1210300_3001700 0.1294
R_VDD24_11232 METAL6_1210300_3001700 METAL6_1210300_3013700 0.024
R_VDD24_11233 METAL6_1210300_3013700 METAL6_1212000_3013700 0.0034
R_VDD24_11234 METAL6_1212000_3013700 METAL6_1216400_3013700 0.0088
R_VDD24_11235 METAL6_1216400_3013700 METAL6_1218700_3013700 0.0046
R_VDD24_11236 METAL6_1218700_3013700 METAL6_1222300_3013700 0.0072
R_VDD24_11237 METAL6_1222300_3013700 METAL6_1230700_3013700 0.0168
R_VDD24_11238 METAL6_1230700_3013700 METAL6_1234300_3013700 0.0072
I_VDD24_38 METAL6_2982200_1019000 gnd 0.001
I_VDD24_39 METAL6_1246300_3013700 gnd 0.0022

V_VDD25_18 METAL5_3500000_2300000 gnd 1
R_VDD25_11239 METAL5_3500000_2300000 METAL5_3490500_2300000 0.038
R_VDD25_11240 METAL5_3490500_2300000 METAL6_3490500_2300000 0.1
R_VDD25_11241 METAL6_3490500_2300000 METAL6_3478500_2300000 0.024
R_VDD25_11242 METAL6_3478500_2300000 METAL6_3478500_2292000 0.016
R_VDD25_11243 METAL6_3478500_2292000 METAL6_3478500_2288000 0.008
R_VDD25_11244 METAL6_3478500_2288000 METAL6_3478500_2276000 0.024
R_VDD25_11245 METAL6_3478500_2276000 METAL6_3478500_2268500 0.015
R_VDD25_11246 METAL6_3478500_2268500 METAL6_3478500_2246500 0.044
R_VDD25_11247 METAL6_3478500_2246500 METAL6_3477000_2246500 0.003
R_VDD25_11248 METAL6_3477000_2246500 METAL6_3466500_2246500 0.021
R_VDD25_11249 METAL6_3466500_2246500 METAL6_3465000_2246500 0.003
R_VDD25_11250 METAL6_3465000_2246500 METAL6_3454500_2246500 0.021
R_VDD25_11251 METAL6_3454500_2246500 METAL6_3453000_2246500 0.003
R_VDD25_11252 METAL6_3453000_2246500 METAL6_3442500_2246500 0.021
R_VDD25_11253 METAL6_3442500_2246500 METAL6_3360400_2246500 0.1642
R_VDD25_11254 METAL6_3360400_2246500 METAL6_3348400_2246500 0.024
R_VDD25_11255 METAL6_3348400_2246500 METAL6_3336400_2246500 0.024
R_VDD25_11256 METAL6_3336400_2246500 METAL6_3324400_2246500 0.024
R_VDD25_11257 METAL6_3324400_2246500 METAL5_3324400_2246500 0.1
R_VDD25_11258 METAL5_3324400_2246500 METAL5_3312400_2246500 0.048
R_VDD25_11259 METAL5_3312400_2246500 METAL5_3312000_2246500 0.0016
R_VDD25_11260 METAL5_3312000_2246500 METAL5_3305400_2246500 0.0264
R_VDD25_11261 METAL5_3305400_2246500 METAL5_3300400_2246500 0.02
R_VDD25_11262 METAL5_3300400_2246500 METAL6_3300400_2246500 0.1
R_VDD25_11263 METAL6_3300400_2246500 METAL6_3300000_2246500 0.0008
R_VDD25_11264 METAL6_3300000_2246500 METAL6_3299000_2246500 0.002
R_VDD25_11265 METAL6_3299000_2246500 METAL6_3288400_2246500 0.0212
R_VDD25_11266 METAL6_3288400_2246500 METAL6_3288000_2246500 0.0008
R_VDD25_11267 METAL6_3288000_2246500 METAL6_3287000_2246500 0.002
R_VDD25_11268 METAL6_3287000_2246500 METAL6_3276400_2246500 0.0212
R_VDD25_11269 METAL6_3276400_2246500 METAL6_3275000_2246500 0.0028
R_VDD25_11270 METAL6_3275000_2246500 METAL6_3263000_2246500 0.024
R_VDD25_11271 METAL6_3263000_2246500 METAL6_3260400_2246500 0.0052
R_VDD25_11272 METAL6_3260400_2246500 METAL6_3243500_2246500 0.0338
R_VDD25_11273 METAL6_3243500_2246500 METAL6_3231500_2246500 0.024
R_VDD25_11274 METAL6_3231500_2246500 METAL6_3224500_2246500 0.014
R_VDD25_11275 METAL6_3224500_2246500 METAL6_3219500_2246500 0.01
R_VDD25_11276 METAL6_3219500_2246500 METAL6_3212500_2246500 0.014
R_VDD25_11277 METAL6_3212500_2246500 METAL6_3212000_2246500 0.001
R_VDD25_11278 METAL6_3212000_2246500 METAL6_3207500_2246500 0.009
R_VDD25_11279 METAL6_3207500_2246500 METAL6_3200500_2246500 0.014
R_VDD25_11280 METAL6_3200500_2246500 METAL6_3200000_2246500 0.001
R_VDD25_11281 METAL6_3200000_2246500 METAL6_3188000_2246500 0.024
R_VDD25_11282 METAL6_3188000_2246500 METAL6_3179500_2246500 0.017
R_VDD25_11283 METAL6_3179500_2246500 METAL6_3167500_2246500 0.024
R_VDD25_11284 METAL6_3167500_2246500 METAL6_3165900_2246500 0.0032
R_VDD25_11285 METAL6_3165900_2246500 METAL6_3155500_2246500 0.0208
R_VDD25_11286 METAL6_3155500_2246500 METAL6_3124000_2246500 0.063
R_VDD25_11287 METAL6_3124000_2246500 METAL6_3112000_2246500 0.024
R_VDD25_11288 METAL6_3112000_2246500 METAL6_3111200_2246500 0.0016
R_VDD25_11289 METAL6_3111200_2246500 METAL6_3110900_2246500 0.0006
R_VDD25_11290 METAL6_3110900_2246500 METAL6_3100000_2246500 0.0218
R_VDD25_11291 METAL6_3100000_2246500 METAL6_3099200_2246500 0.0016
R_VDD25_11292 METAL6_3099200_2246500 METAL6_3098900_2246500 0.0006
R_VDD25_11293 METAL6_3098900_2246500 METAL6_3088000_2246500 0.0218
R_VDD25_11294 METAL6_3088000_2246500 METAL6_3087200_2246500 0.0016
R_VDD25_11295 METAL6_3087200_2246500 METAL6_3086900_2246500 0.0006
R_VDD25_11296 METAL6_3086900_2246500 METAL6_3076000_2246500 0.0218
R_VDD25_11297 METAL6_3076000_2246500 METAL6_3075200_2246500 0.0016
R_VDD25_11298 METAL6_3075200_2246500 METAL6_3068200_2246500 0.014
R_VDD25_11299 METAL6_3068200_2246500 METAL6_3064000_2246500 0.0084
R_VDD25_11300 METAL6_3064000_2246500 METAL6_3060600_2246500 0.0068
R_VDD25_11301 METAL6_3060600_2246500 METAL6_3052000_2246500 0.0172
R_VDD25_11302 METAL6_3052000_2246500 METAL6_3023200_2246500 0.0576
R_VDD25_11303 METAL6_3023200_2246500 METAL6_3018200_2246500 0.01
R_VDD25_11304 METAL6_3018200_2246500 METAL6_3012000_2246500 0.0124
R_VDD25_11305 METAL6_3012000_2246500 METAL6_3006200_2246500 0.0116
R_VDD25_11306 METAL6_3006200_2246500 METAL6_3000000_2246500 0.0124
R_VDD25_11307 METAL6_3000000_2246500 METAL6_2994200_2246500 0.0116
R_VDD25_11308 METAL6_2994200_2246500 METAL6_2993000_2246500 0.0024
R_VDD25_11309 METAL6_2993000_2246500 METAL6_2988000_2246500 0.01
R_VDD25_11310 METAL6_2988000_2246500 METAL6_2982200_2246500 0.0116
R_VDD25_11311 METAL6_2982200_2246500 METAL6_2975200_2246500 0.014
R_VDD25_11312 METAL6_2975200_2246500 METAL6_2970200_2246500 0.01
R_VDD25_11313 METAL6_2970200_2246500 METAL6_2965900_2246500 0.0086
R_VDD25_11314 METAL6_2965900_2246500 METAL6_2951900_2246500 0.028
R_VDD25_11315 METAL6_2951900_2246500 METAL6_2942200_2246500 0.0194
R_VDD25_11316 METAL6_2942200_2246500 METAL6_2930200_2246500 0.024
R_VDD25_11317 METAL6_2930200_2246500 METAL6_2925600_2246500 0.0092
R_VDD25_11318 METAL6_2925600_2246500 METAL6_2918200_2246500 0.0148
R_VDD25_11319 METAL6_2918200_2246500 METAL6_2913600_2246500 0.0092
R_VDD25_11320 METAL6_2913600_2246500 METAL6_2910900_2246500 0.0054
R_VDD25_11321 METAL6_2910900_2246500 METAL6_2901600_2246500 0.0186
R_VDD25_11322 METAL6_2901600_2246500 METAL6_2898900_2246500 0.0054
R_VDD25_11323 METAL6_2898900_2246500 METAL6_2897100_2246500 0.0036
R_VDD25_11324 METAL6_2897100_2246500 METAL6_2886900_2246500 0.0204
R_VDD25_11325 METAL6_2886900_2246500 METAL6_2874800_2246500 0.0242
R_VDD25_11326 METAL6_2874800_2246500 METAL6_2862800_2246500 0.024
R_VDD25_11327 METAL6_2862800_2246500 METAL6_2860600_2246500 0.0044
R_VDD25_11328 METAL6_2860600_2246500 METAL6_2850800_2246500 0.0196
R_VDD25_11329 METAL6_2850800_2246500 METAL6_2846600_2246500 0.0084
R_VDD25_11330 METAL6_2846600_2246500 METAL6_2843800_2246500 0.0056
R_VDD25_11331 METAL6_2843800_2246500 METAL6_2812000_2246500 0.0636
R_VDD25_11332 METAL6_2812000_2246500 METAL6_2805600_2246500 0.0128
R_VDD25_11333 METAL6_2805600_2246500 METAL6_2800000_2246500 0.0112
R_VDD25_11334 METAL6_2800000_2246500 METAL6_2798800_2246500 0.0024
R_VDD25_11335 METAL6_2798800_2246500 METAL6_2793600_2246500 0.0104
R_VDD25_11336 METAL6_2793600_2246500 METAL6_2788000_2246500 0.0112
R_VDD25_11337 METAL6_2788000_2246500 METAL6_2781600_2246500 0.0128
R_VDD25_11338 METAL6_2781600_2246500 METAL6_2765900_2246500 0.0314
R_VDD25_11339 METAL6_2765900_2246500 METAL6_2751900_2246500 0.028
R_VDD25_11340 METAL6_2751900_2246500 METAL6_2728200_2246500 0.0474
R_VDD25_11341 METAL6_2728200_2246500 METAL6_2710900_2246500 0.0346
R_VDD25_11342 METAL6_2710900_2246500 METAL6_2698900_2246500 0.024
R_VDD25_11343 METAL6_2698900_2246500 METAL6_2686900_2246500 0.024
R_VDD25_11344 METAL6_2686900_2246500 METAL6_2683200_2246500 0.0074
R_VDD25_11345 METAL6_2683200_2246500 METAL6_2676200_2246500 0.014
R_VDD25_11346 METAL6_2676200_2246500 METAL6_2664200_2246500 0.024
R_VDD25_11347 METAL6_2664200_2246500 METAL6_2660600_2246500 0.0072
R_VDD25_11348 METAL6_2660600_2246500 METAL6_2652200_2246500 0.0168
R_VDD25_11349 METAL6_2652200_2246500 METAL6_2646600_2246500 0.0112
R_VDD25_11350 METAL6_2646600_2246500 METAL6_2604400_2246500 0.0844
R_VDD25_11351 METAL6_2604400_2246500 METAL6_2592400_2246500 0.024
R_VDD25_11352 METAL6_2592400_2246500 METAL6_2580400_2246500 0.024
R_VDD25_11353 METAL6_2580400_2246500 METAL6_2568400_2246500 0.024
R_VDD25_11354 METAL6_2568400_2246500 METAL6_2565900_2246500 0.005
R_VDD25_11355 METAL6_2565900_2246500 METAL6_2556400_2246500 0.019
R_VDD25_11356 METAL6_2556400_2246500 METAL6_2551900_2246500 0.009
R_VDD25_11357 METAL6_2551900_2246500 METAL6_2548000_2246500 0.0078
R_VDD25_11358 METAL6_2548000_2246500 METAL6_2537600_2246500 0.0208
R_VDD25_11359 METAL6_2537600_2246500 METAL6_2536000_2246500 0.0032
R_VDD25_11360 METAL6_2536000_2246500 METAL6_2535400_2246500 0.0012
R_VDD25_11361 METAL6_2535400_2246500 METAL6_2529000_2246500 0.0128
R_VDD25_11362 METAL6_2529000_2246500 METAL6_2528400_2246500 0.0012
R_VDD25_11363 METAL6_2528400_2246500 METAL6_2525600_2246500 0.0056
R_VDD25_11364 METAL6_2525600_2246500 METAL6_2524000_2246500 0.0032
R_VDD25_11365 METAL6_2524000_2246500 METAL6_2517000_2246500 0.014
R_VDD25_11366 METAL6_2517000_2246500 METAL6_2516400_2246500 0.0012
R_VDD25_11367 METAL6_2516400_2246500 METAL6_2513600_2246500 0.0056
R_VDD25_11368 METAL6_2513600_2246500 METAL6_2512000_2246500 0.0032
R_VDD25_11369 METAL6_2512000_2246500 METAL6_2510900_2246500 0.0022
R_VDD25_11370 METAL6_2510900_2246500 METAL6_2505000_2246500 0.0118
R_VDD25_11371 METAL6_2505000_2246500 METAL6_2504400_2246500 0.0012
R_VDD25_11372 METAL6_2504400_2246500 METAL6_2501600_2246500 0.0056
R_VDD25_11373 METAL6_2501600_2246500 METAL6_2500000_2246500 0.0032
R_VDD25_11374 METAL6_2500000_2246500 METAL6_2498900_2246500 0.0022
R_VDD25_11375 METAL6_2498900_2246500 METAL6_2493000_2246500 0.0118
R_VDD25_11376 METAL6_2493000_2246500 METAL6_2492400_2246500 0.0012
R_VDD25_11377 METAL6_2492400_2246500 METAL6_2489600_2246500 0.0056
R_VDD25_11378 METAL6_2489600_2246500 METAL6_2488000_2246500 0.0032
R_VDD25_11379 METAL6_2488000_2246500 METAL6_2486900_2246500 0.0022
R_VDD25_11380 METAL6_2486900_2246500 METAL6_2484600_2246500 0.0046
R_VDD25_11381 METAL6_2484600_2246500 METAL6_2481000_2246500 0.0072
R_VDD25_11382 METAL6_2481000_2246500 METAL6_2481000_2234500 0.024
R_VDD25_11383 METAL6_2481000_2234500 METAL6_2481000_2222500 0.024
R_VDD25_11384 METAL6_2481000_2222500 METAL6_2481000_2202300 0.0404
R_VDD25_11385 METAL6_2481000_2202300 METAL6_2481000_2190300 0.024
R_VDD25_11386 METAL6_2481000_2190300 METAL6_2480400_2190300 0.0012
R_VDD25_11387 METAL6_2480400_2190300 METAL6_2477600_2190300 0.0056
R_VDD25_11388 METAL6_2477600_2190300 METAL6_2476000_2190300 0.0032
R_VDD25_11389 METAL6_2476000_2190300 METAL6_2476000_2187000 0.0066
R_VDD25_11390 METAL6_2476000_2187000 METAL6_2476000_2178300 0.0174
R_VDD25_11391 METAL6_2476000_2178300 METAL6_2476000_2175000 0.0066
R_VDD25_11392 METAL6_2476000_2175000 METAL6_2476000_2166300 0.0174
R_VDD25_11393 METAL6_2476000_2166300 METAL6_2476000_2163000 0.0066
R_VDD25_11394 METAL6_2476000_2163000 METAL6_2476000_2154300 0.0174
R_VDD25_11395 METAL6_2476000_2154300 METAL6_2476000_2150500 0.0076
R_VDD25_11396 METAL6_2476000_2150500 METAL6_2476000_2147300 0.0064
R_VDD25_11397 METAL6_2476000_2147300 METAL6_2476000_2138500 0.0176
R_VDD25_11398 METAL6_2476000_2138500 METAL6_2476000_2126500 0.024
R_VDD25_11399 METAL6_2476000_2126500 METAL6_2476000_2114500 0.024
R_VDD25_11400 METAL6_2476000_2114500 METAL6_2476000_2038500 0.152
R_VDD25_11401 METAL6_2476000_2038500 METAL6_2476000_2026500 0.024
R_VDD25_11402 METAL6_2476000_2026500 METAL6_2476000_2014500 0.024
R_VDD25_11403 METAL6_2476000_2014500 METAL6_2476000_1988500 0.052
R_VDD25_11404 METAL6_2476000_1988500 METAL6_2476000_1987000 0.003
R_VDD25_11405 METAL6_2476000_1987000 METAL6_2476000_1976500 0.021
R_VDD25_11406 METAL6_2476000_1976500 METAL5_2476000_1976500 0.1
R_VDD25_11407 METAL5_2476000_1976500 METAL5_2476000_1975000 0.006
R_VDD25_11408 METAL5_2476000_1975000 METAL5_2476000_1964500 0.042
R_VDD25_11409 METAL5_2476000_1964500 METAL5_2476000_1963000 0.006
R_VDD25_11410 METAL5_2476000_1963000 METAL5_2476000_1962500 0.002
R_VDD25_11411 METAL5_2476000_1962500 METAL5_2476000_1952500 0.04
R_VDD25_11412 METAL5_2476000_1952500 METAL6_2476000_1952500 0.1
R_VDD25_11413 METAL6_2476000_1952500 METAL6_2477600_1952500 0.0032
R_VDD25_11414 METAL6_2477600_1952500 METAL6_2480400_1952500 0.0056
R_VDD25_11415 METAL6_2480400_1952500 METAL6_2480400_1951000 0.003
R_VDD25_11416 METAL6_2480400_1951000 METAL6_2481000_1951000 0.0012
R_VDD25_11417 METAL6_2481000_1951000 METAL6_2481000_1950500 0.001
R_VDD25_11418 METAL6_2481000_1950500 METAL6_2481000_1940500 0.02
R_VDD25_11419 METAL6_2481000_1940500 METAL6_2481000_1938500 0.004
R_VDD25_11420 METAL6_2481000_1938500 METAL6_2481000_1926500 0.024
R_VDD25_11421 METAL6_2481000_1926500 METAL6_2481000_1914500 0.024
R_VDD25_11422 METAL6_2481000_1914500 METAL6_2481000_1902500 0.024
R_VDD25_11423 METAL6_2481000_1902500 METAL6_2481000_1866300 0.0724
R_VDD25_11424 METAL6_2481000_1866300 METAL6_2481000_1852300 0.028
R_VDD25_11425 METAL6_2481000_1852300 METAL6_2481000_1838500 0.0276
R_VDD25_11426 METAL6_2481000_1838500 METAL6_2481000_1826500 0.024
R_VDD25_11427 METAL6_2481000_1826500 METAL6_2481000_1814500 0.024
R_VDD25_11428 METAL6_2481000_1814500 METAL6_2481000_1802500 0.024
R_VDD25_11429 METAL6_2481000_1802500 METAL6_2481000_1774500 0.056
R_VDD25_11430 METAL6_2481000_1774500 METAL6_2481000_1762500 0.024
R_VDD25_11431 METAL6_2481000_1762500 METAL6_2481000_1750500 0.024
R_VDD25_11432 METAL6_2481000_1750500 METAL6_2481000_1738500 0.024
R_VDD25_11433 METAL6_2481000_1738500 METAL6_2481000_1731700 0.0136
R_VDD25_11434 METAL6_2481000_1731700 METAL6_2481000_1726500 0.0104
R_VDD25_11435 METAL6_2481000_1726500 METAL6_2481000_1720500 0.012
R_VDD25_11436 METAL6_2481000_1720500 METAL6_2481000_1714500 0.012
R_VDD25_11437 METAL6_2481000_1714500 METAL6_2481000_1576300 0.2764
R_VDD25_11438 METAL6_2481000_1576300 METAL6_2481000_1571300 0.01
R_VDD25_11439 METAL6_2481000_1571300 METAL6_2481000_1564300 0.014
R_VDD25_11440 METAL6_2481000_1564300 METAL6_2481000_1554500 0.0196
R_VDD25_11441 METAL6_2481000_1554500 METAL6_2481000_1552300 0.0044
R_VDD25_11442 METAL6_2481000_1552300 METAL6_2481000_1540300 0.024
R_VDD25_11443 METAL6_2481000_1540300 METAL6_2481000_1528300 0.024
R_VDD25_11444 METAL6_2481000_1528300 METAL6_2481000_1516300 0.024
R_VDD25_11445 METAL6_2481000_1516300 METAL6_2481000_1504300 0.024
R_VDD25_11446 METAL6_2481000_1504300 METAL6_2481000_1492300 0.024
R_VDD25_11447 METAL6_2481000_1492300 METAL6_2481000_1461700 0.0612
R_VDD25_11448 METAL6_2481000_1461700 METAL6_2481000_1449700 0.024
R_VDD25_11449 METAL6_2481000_1449700 METAL6_2481000_1437700 0.024
R_VDD25_11450 METAL6_2481000_1437700 METAL6_2481000_1405000 0.0654
R_VDD25_11451 METAL6_2481000_1405000 METAL6_2481000_1393000 0.024
R_VDD25_11452 METAL6_2481000_1393000 METAL6_2481000_1386600 0.0128
R_VDD25_11453 METAL6_2481000_1386600 METAL6_2481000_1381000 0.0112
R_VDD25_11454 METAL6_2481000_1381000 METAL6_2481000_1374000 0.014
R_VDD25_11455 METAL6_2481000_1374000 METAL6_2481000_1369000 0.01
R_VDD25_11456 METAL6_2481000_1369000 METAL6_2481000_1362000 0.014
R_VDD25_11457 METAL6_2481000_1362000 METAL6_2481000_1357000 0.01
R_VDD25_11458 METAL6_2481000_1357000 METAL6_2481000_1350000 0.014
R_VDD25_11459 METAL6_2481000_1350000 METAL6_2481000_1338000 0.024
R_VDD25_11460 METAL6_2481000_1338000 METAL6_2481000_1326000 0.024
R_VDD25_11461 METAL6_2481000_1326000 METAL6_2481000_1319700 0.0126
R_VDD25_11462 METAL6_2481000_1319700 METAL6_2481000_1314000 0.0114
R_VDD25_11463 METAL6_2481000_1314000 METAL6_2481000_1307700 0.0126
R_VDD25_11464 METAL6_2481000_1307700 METAL6_2481000_1302000 0.0114
R_VDD25_11465 METAL6_2481000_1302000 METAL6_2481000_1297000 0.01
R_VDD25_11466 METAL6_2481000_1297000 METAL6_2484600_1297000 0.0072
R_VDD25_11467 METAL6_2484600_1297000 METAL6_2484600_1295700 0.0026
R_VDD25_11468 METAL6_2484600_1295700 METAL5_2484600_1295700 0.1
R_VDD25_11469 METAL5_2484600_1295700 METAL5_2484600_1285000 0.0428
R_VDD25_11470 METAL5_2484600_1285000 METAL5_2484600_1283700 0.0052
R_VDD25_11471 METAL5_2484600_1283700 METAL5_2484600_1273000 0.0428
R_VDD25_11472 METAL5_2484600_1273000 METAL5_2484600_1271700 0.0052
R_VDD25_11473 METAL5_2484600_1271700 METAL5_2481000_1271700 0.0144
R_VDD25_11474 METAL5_2481000_1271700 METAL5_2480400_1271700 0.0024
R_VDD25_11475 METAL5_2480400_1271700 METAL5_2477600_1271700 0.0112
R_VDD25_11476 METAL5_2477600_1271700 METAL5_2476000_1271700 0.0064
R_VDD25_11477 METAL5_2476000_1271700 METAL5_2472600_1271700 0.0136
R_VDD25_11478 METAL5_2472600_1271700 METAL5_2469000_1271700 0.0144
R_VDD25_11479 METAL5_2469000_1271700 METAL5_2469000_1262000 0.0388
R_VDD25_11480 METAL5_2469000_1262000 METAL5_2469000_1261000 0.004
R_VDD25_11481 METAL5_2469000_1261000 METAL5_2469000_1259700 0.0052
R_VDD25_11482 METAL5_2469000_1259700 METAL5_2469000_1250000 0.0388
R_VDD25_11483 METAL5_2469000_1250000 METAL5_2469000_1247700 0.0092
R_VDD25_11484 METAL5_2469000_1247700 METAL5_2469000_1238000 0.0388
R_VDD25_11485 METAL5_2469000_1238000 METAL5_2469000_1235700 0.0092
R_VDD25_11486 METAL5_2469000_1235700 METAL5_2469000_1229700 0.024
R_VDD25_11487 METAL5_2469000_1229700 METAL5_2469000_1223700 0.024
R_VDD25_11488 METAL5_2469000_1223700 METAL5_2469000_1217700 0.024
R_VDD25_11489 METAL5_2469000_1217700 METAL5_2469000_1205700 0.048
R_VDD25_11490 METAL5_2469000_1205700 METAL5_2469000_1193800 0.0476
R_VDD25_11491 METAL5_2469000_1193800 METAL5_2472600_1193800 0.0144
R_VDD25_11492 METAL5_2472600_1193800 METAL5_2476000_1193800 0.0136
R_VDD25_11493 METAL5_2476000_1193800 METAL5_2477600_1193800 0.0064
R_VDD25_11494 METAL5_2477600_1193800 METAL5_2480400_1193800 0.0112
R_VDD25_11495 METAL5_2480400_1193800 METAL5_2481000_1193800 0.0024
R_VDD25_11496 METAL5_2481000_1193800 METAL5_2484600_1193800 0.0144
R_VDD25_11497 METAL5_2484600_1193800 METAL5_2486900_1193800 0.0092
R_VDD25_11498 METAL5_2486900_1193800 METAL5_2488000_1193800 0.0044
R_VDD25_11499 METAL5_2488000_1193800 METAL5_2488000_1193700 0.0004
R_VDD25_11500 METAL5_2488000_1193700 METAL5_2488000_1191600 0.0084
R_VDD25_11501 METAL5_2488000_1191600 METAL5_2488000_1184600 0.028
R_VDD25_11502 METAL5_2488000_1184600 METAL5_2488000_1181700 0.0116
R_VDD25_11503 METAL5_2488000_1181700 METAL5_2488000_1172600 0.0364
R_VDD25_11504 METAL5_2488000_1172600 METAL5_2488000_1169700 0.0116
R_VDD25_11505 METAL5_2488000_1169700 METAL5_2489600_1169700 0.0064
R_VDD25_11506 METAL5_2489600_1169700 METAL5_2492400_1169700 0.0112
R_VDD25_11507 METAL5_2492400_1169700 METAL5_2493000_1169700 0.0024
R_VDD25_11508 METAL5_2493000_1169700 METAL5_2498900_1169700 0.0236
R_VDD25_11509 METAL5_2498900_1169700 METAL5_2500000_1169700 0.0044
R_VDD25_11510 METAL5_2500000_1169700 METAL5_2501600_1169700 0.0064
R_VDD25_11511 METAL5_2501600_1169700 METAL5_2504400_1169700 0.0112
R_VDD25_11512 METAL5_2504400_1169700 METAL5_2505000_1169700 0.0024
R_VDD25_11513 METAL5_2505000_1169700 METAL5_2510900_1169700 0.0236
R_VDD25_11514 METAL5_2510900_1169700 METAL5_2512000_1169700 0.0044
R_VDD25_11515 METAL5_2512000_1169700 METAL5_2513600_1169700 0.0064
R_VDD25_11516 METAL5_2513600_1169700 METAL5_2516400_1169700 0.0112
R_VDD25_11517 METAL5_2516400_1169700 METAL5_2517000_1169700 0.0024
R_VDD25_11518 METAL5_2517000_1169700 METAL5_2524000_1169700 0.028
R_VDD25_11519 METAL5_2524000_1169700 METAL6_2524000_1169700 0.1
R_VDD25_11520 METAL6_2524000_1169700 METAL6_2524000_1160600 0.0182
R_VDD25_11521 METAL6_2524000_1160600 METAL6_2524000_1153300 0.0146
R_VDD25_11522 METAL6_2524000_1153300 METAL6_2524000_1141300 0.024
R_VDD25_11523 METAL6_2524000_1141300 METAL6_2524000_1134300 0.014
R_VDD25_11524 METAL6_2524000_1134300 METAL6_2525600_1134300 0.0032
R_VDD25_11525 METAL6_2525600_1134300 METAL6_2528400_1134300 0.0056
R_VDD25_11526 METAL6_2528400_1134300 METAL6_2529000_1134300 0.0012
R_VDD25_11527 METAL6_2529000_1134300 METAL6_2535400_1134300 0.0128
R_VDD25_11528 METAL6_2535400_1134300 METAL6_2536000_1134300 0.0012
R_VDD25_11529 METAL6_2536000_1134300 METAL6_2537600_1134300 0.0032
R_VDD25_11530 METAL6_2537600_1134300 METAL6_2548000_1134300 0.0208
R_VDD25_11531 METAL6_2548000_1134300 METAL6_2551900_1134300 0.0078
R_VDD25_11532 METAL6_2551900_1134300 METAL6_2556400_1134300 0.009
R_VDD25_11533 METAL6_2556400_1134300 METAL6_2565900_1134300 0.019
R_VDD25_11534 METAL6_2565900_1134300 METAL6_2568400_1134300 0.005
R_VDD25_11535 METAL6_2568400_1134300 METAL6_2580400_1134300 0.024
R_VDD25_11536 METAL6_2580400_1134300 METAL6_2592400_1134300 0.024
R_VDD25_11537 METAL6_2592400_1134300 METAL6_2604400_1134300 0.024
R_VDD25_11538 METAL6_2604400_1134300 METAL6_2646600_1134300 0.0844
R_VDD25_11539 METAL6_2646600_1134300 METAL6_2652200_1134300 0.0112
R_VDD25_11540 METAL6_2652200_1134300 METAL6_2660600_1134300 0.0168
R_VDD25_11541 METAL6_2660600_1134300 METAL6_2664200_1134300 0.0072
R_VDD25_11542 METAL6_2664200_1134300 METAL6_2676200_1134300 0.024
R_VDD25_11543 METAL6_2676200_1134300 METAL6_2683200_1134300 0.014
R_VDD25_11544 METAL6_2683200_1134300 METAL6_2686900_1134300 0.0074
R_VDD25_11545 METAL6_2686900_1134300 METAL6_2698900_1134300 0.024
R_VDD25_11546 METAL6_2698900_1134300 METAL6_2710900_1134300 0.024
R_VDD25_11547 METAL6_2710900_1134300 METAL6_2728200_1134300 0.0346
R_VDD25_11548 METAL6_2728200_1134300 METAL6_2751900_1134300 0.0474
R_VDD25_11549 METAL6_2751900_1134300 METAL6_2765900_1134300 0.028
R_VDD25_11550 METAL6_2765900_1134300 METAL6_2781600_1134300 0.0314
R_VDD25_11551 METAL6_2781600_1134300 METAL6_2788000_1134300 0.0128
R_VDD25_11552 METAL6_2788000_1134300 METAL6_2793600_1134300 0.0112
R_VDD25_11553 METAL6_2793600_1134300 METAL6_2798800_1134300 0.0104
R_VDD25_11554 METAL6_2798800_1134300 METAL6_2798800_1132800 0.003
R_VDD25_11555 METAL6_2798800_1132800 METAL6_2798800_1129300 0.007
R_VDD25_11556 METAL6_2798800_1129300 METAL6_2798800_1122500 0.0136
R_VDD25_11557 METAL6_2798800_1122500 METAL6_2800000_1122500 0.0024
R_VDD25_11558 METAL6_2800000_1122500 METAL6_2805600_1122500 0.0112
R_VDD25_11559 METAL6_2805600_1122500 METAL6_2812000_1122500 0.0128
R_VDD25_11560 METAL6_2812000_1122500 METAL6_2843800_1122500 0.0636
R_VDD25_11561 METAL6_2843800_1122500 METAL6_2846600_1122500 0.0056
R_VDD25_11562 METAL6_2846600_1122500 METAL6_2850800_1122500 0.0084
R_VDD25_11563 METAL6_2850800_1122500 METAL6_2860600_1122500 0.0196
R_VDD25_11564 METAL6_2860600_1122500 METAL6_2862800_1122500 0.0044
R_VDD25_11565 METAL6_2862800_1122500 METAL6_2874800_1122500 0.024
R_VDD25_11566 METAL6_2874800_1122500 METAL6_2886900_1122500 0.0242
R_VDD25_11567 METAL6_2886900_1122500 METAL6_2897100_1122500 0.0204
R_VDD25_11568 METAL6_2897100_1122500 METAL6_2898900_1122500 0.0036
R_VDD25_11569 METAL6_2898900_1122500 METAL6_2901600_1122500 0.0054
R_VDD25_11570 METAL6_2901600_1122500 METAL6_2910900_1122500 0.0186
R_VDD25_11571 METAL6_2910900_1122500 METAL6_2913600_1122500 0.0054
R_VDD25_11572 METAL6_2913600_1122500 METAL6_2918200_1122500 0.0092
R_VDD25_11573 METAL6_2918200_1122500 METAL6_2925600_1122500 0.0148
R_VDD25_11574 METAL6_2925600_1122500 METAL6_2930200_1122500 0.0092
R_VDD25_11575 METAL6_2930200_1122500 METAL6_2942200_1122500 0.024
R_VDD25_11576 METAL6_2942200_1122500 METAL6_2951900_1122500 0.0194
R_VDD25_11577 METAL6_2951900_1122500 METAL6_2965900_1122500 0.028
R_VDD25_11578 METAL6_2965900_1122500 METAL6_2970200_1122500 0.0086
R_VDD25_11579 METAL6_2970200_1122500 METAL6_2975200_1122500 0.01
R_VDD25_11580 METAL6_2975200_1122500 METAL6_2982200_1122500 0.014
R_VDD25_11581 METAL6_2982200_1122500 METAL6_2982200_1122300 0.0004
R_VDD25_11582 METAL6_2982200_1122300 METAL6_2982200_1120800 0.003
R_VDD25_11583 METAL6_2982200_1120800 METAL6_2982200_1112000 0.0176
R_VDD25_11584 METAL6_2982200_1112000 METAL6_2982200_1110500 0.003
R_VDD25_11585 METAL6_2982200_1110500 METAL6_2982200_1110300 0.0004
R_VDD25_11586 METAL6_2982200_1110300 METAL6_2982200_1108800 0.003
R_VDD25_11587 METAL6_2982200_1108800 METAL6_2982200_1100000 0.0176
R_VDD25_11588 METAL6_2982200_1100000 METAL6_2982200_1098500 0.003
R_VDD25_11589 METAL6_2982200_1098500 METAL6_2982200_1098300 0.0004
R_VDD25_11590 METAL6_2982200_1098300 METAL6_2982200_1098000 0.0006
R_VDD25_11591 METAL6_2982200_1098000 METAL5_2982200_1098000 0.1
R_VDD25_11592 METAL5_2982200_1098000 METAL5_2988000_1098000 0.0232
R_VDD25_11593 METAL5_2988000_1098000 METAL5_2993000_1098000 0.02
R_VDD25_11594 METAL5_2993000_1098000 METAL5_2994200_1098000 0.0048
R_VDD25_11595 METAL5_2994200_1098000 METAL5_3000000_1098000 0.0232
R_VDD25_11596 METAL5_3000000_1098000 METAL5_3006200_1098000 0.0248
R_VDD25_11597 METAL5_3006200_1098000 METAL5_3012000_1098000 0.0232
R_VDD25_11598 METAL5_3012000_1098000 METAL5_3018200_1098000 0.0248
R_VDD25_11599 METAL5_3018200_1098000 METAL5_3023200_1098000 0.02
R_VDD25_11600 METAL5_3023200_1098000 METAL5_3052000_1098000 0.1152
R_VDD25_11601 METAL5_3052000_1098000 METAL5_3060600_1098000 0.0344
R_VDD25_11602 METAL5_3060600_1098000 METAL5_3064000_1098000 0.0136
R_VDD25_11603 METAL5_3064000_1098000 METAL5_3068200_1098000 0.0168
R_VDD25_11604 METAL5_3068200_1098000 METAL5_3075200_1098000 0.028
R_VDD25_11605 METAL5_3075200_1098000 METAL5_3075200_1096800 0.0048
R_VDD25_11606 METAL5_3075200_1096800 METAL5_3075200_1088000 0.0352
R_VDD25_11607 METAL5_3075200_1088000 METAL5_3075200_1086500 0.006
R_VDD25_11608 METAL5_3075200_1086500 METAL5_3076000_1086500 0.0032
R_VDD25_11609 METAL5_3076000_1086500 METAL5_3086900_1086500 0.0436
R_VDD25_11610 METAL5_3086900_1086500 METAL5_3087200_1086500 0.0012
R_VDD25_11611 METAL5_3087200_1086500 METAL5_3088000_1086500 0.0032
R_VDD25_11612 METAL5_3088000_1086500 METAL5_3098900_1086500 0.0436
R_VDD25_11613 METAL5_3098900_1086500 METAL5_3099200_1086500 0.0012
R_VDD25_11614 METAL5_3099200_1086500 METAL6_3099200_1086500 0.1
R_VDD25_11615 METAL6_3099200_1086500 METAL6_3100000_1086500 0.0016
R_VDD25_11616 METAL6_3100000_1086500 METAL6_3110900_1086500 0.0218
R_VDD25_11617 METAL6_3110900_1086500 METAL6_3111200_1086500 0.0006
R_VDD25_11618 METAL6_3111200_1086500 METAL6_3112000_1086500 0.0016
R_VDD25_11619 METAL6_3112000_1086500 METAL6_3124000_1086500 0.024
R_VDD25_11620 METAL6_3124000_1086500 METAL6_3155500_1086500 0.063
R_VDD25_11621 METAL6_3155500_1086500 METAL6_3165900_1086500 0.0208
R_VDD25_11622 METAL6_3165900_1086500 METAL6_3167500_1086500 0.0032
R_VDD25_11623 METAL6_3167500_1086500 METAL6_3179500_1086500 0.024
R_VDD25_11624 METAL6_3179500_1086500 METAL6_3188000_1086500 0.017
R_VDD25_11625 METAL6_3188000_1086500 METAL6_3200000_1086500 0.024
R_VDD25_11626 METAL6_3200000_1086500 METAL6_3200500_1086500 0.001
R_VDD25_11627 METAL6_3200500_1086500 METAL6_3207500_1086500 0.014
R_VDD25_11628 METAL6_3207500_1086500 METAL6_3212000_1086500 0.009
R_VDD25_11629 METAL6_3212000_1086500 METAL6_3212500_1086500 0.001
R_VDD25_11630 METAL6_3212500_1086500 METAL6_3219500_1086500 0.014
R_VDD25_11631 METAL6_3219500_1086500 METAL6_3224500_1086500 0.01
R_VDD25_11632 METAL6_3224500_1086500 METAL6_3231500_1086500 0.014
R_VDD25_11633 METAL6_3231500_1086500 METAL6_3231500_1086300 0.0004
R_VDD25_11634 METAL6_3231500_1086300 METAL6_3231500_1086000 0.0006
R_VDD25_11635 METAL6_3231500_1086000 METAL6_3231500_1074000 0.024
R_VDD25_11636 METAL6_3231500_1074000 METAL6_3231500_1073800 0.0004
R_VDD25_11637 METAL6_3231500_1073800 METAL6_3231500_1066700 0.0142
R_VDD25_11638 METAL6_3231500_1066700 METAL6_3231500_1061800 0.0098
R_VDD25_11639 METAL6_3231500_1061800 METAL6_3231500_1061400 0.0008
R_VDD25_11640 METAL6_3231500_1061400 METAL6_3231500_1054700 0.0134
R_VDD25_11641 METAL6_3231500_1054700 METAL6_3231500_1053800 0.0018
R_VDD25_11642 METAL6_3231500_1053800 METAL6_3231500_1049800 0.008
R_VDD25_11643 METAL6_3231500_1049800 METAL6_3231500_1049400 0.0008
R_VDD25_11644 METAL6_3231500_1049400 METAL6_3231500_1047700 0.0034
R_VDD25_11645 METAL6_3231500_1047700 METAL6_3231500_1042700 0.01
R_VDD25_11646 METAL6_3231500_1042700 METAL6_3231500_1041800 0.0018
R_VDD25_11647 METAL6_3231500_1041800 METAL6_3231500_1038000 0.0076
R_VDD25_11648 METAL6_3231500_1038000 METAL6_3231500_1037400 0.0012
R_VDD25_11649 METAL6_3231500_1037400 METAL6_3231500_1035700 0.0034
R_VDD25_11650 METAL6_3231500_1035700 METAL6_3231500_1031000 0.0094
R_VDD25_11651 METAL6_3231500_1031000 METAL6_3231500_1029800 0.0024
R_VDD25_11652 METAL6_3231500_1029800 METAL6_3231500_1026000 0.0076
R_VDD25_11653 METAL6_3231500_1026000 METAL6_3231500_1025400 0.0012
R_VDD25_11654 METAL6_3231500_1025400 METAL6_3231500_1023700 0.0034
R_VDD25_11655 METAL6_3231500_1023700 METAL6_3231500_1019000 0.0094
R_VDD25_11656 METAL6_3231500_1019000 METAL6_3231500_1014000 0.01
R_VDD25_11657 METAL6_3231500_1014000 METAL6_3231500_1012000 0.004
R_VDD25_11658 METAL6_3231500_1012000 METAL6_3231500_1007000 0.01
R_VDD25_11659 METAL6_3231500_1007000 METAL6_3231500_1000000 0.014
R_VDD25_11660 METAL6_3231500_1000000 METAL6_3231500_995000 0.01
R_VDD25_11661 METAL6_3231500_995000 METAL6_3231500_988000 0.014
R_VDD25_11662 METAL6_3231500_988000 METAL6_3231500_976000 0.024
R_VDD25_11663 METAL6_3231500_976000 METAL6_3231500_971000 0.01
R_VDD25_11664 METAL6_3231500_971000 METAL6_3231500_959000 0.024
R_VDD25_11665 METAL6_3231500_959000 METAL6_3231500_947000 0.024
R_VDD25_11666 METAL6_3231500_947000 METAL6_3231500_927300 0.0394
R_VDD25_11667 METAL6_3231500_927300 METAL6_3231500_912000 0.0306
R_VDD25_11668 METAL6_3231500_912000 METAL6_3231500_900400 0.0232
R_VDD25_11669 METAL6_3231500_900400 METAL6_3231500_900000 0.0008
R_VDD25_11670 METAL6_3231500_900000 METAL6_3231500_888000 0.024
R_VDD25_11671 METAL6_3231500_888000 METAL6_3231500_887000 0.002
R_VDD25_11672 METAL6_3231500_887000 METAL6_3231500_863500 0.047
R_VDD25_11673 METAL6_3231500_863500 METAL6_3231500_858200 0.0106
R_VDD25_11674 METAL6_3231500_858200 METAL6_3231500_851500 0.0134
R_VDD25_11675 METAL6_3231500_851500 METAL6_3231500_840700 0.0216
R_VDD25_11676 METAL6_3231500_840700 METAL6_3231500_839500 0.0024
R_VDD25_11677 METAL6_3231500_839500 METAL6_3231500_832000 0.015
R_VDD25_11678 METAL6_3231500_832000 METAL6_3231500_830400 0.0032
R_VDD25_11679 METAL6_3231500_830400 METAL6_3231500_820000 0.0208
R_VDD25_11680 METAL6_3231500_820000 METAL6_3231500_818400 0.0032
R_VDD25_11681 METAL6_3231500_818400 METAL6_3231500_814400 0.008
R_VDD25_11682 METAL6_3231500_814400 METAL6_3231500_812000 0.0048
R_VDD25_11683 METAL6_3231500_812000 METAL6_3231500_808000 0.008
R_VDD25_11684 METAL6_3231500_808000 METAL6_3231500_806400 0.0032
R_VDD25_11685 METAL6_3231500_806400 METAL5_3231500_806400 0.1
R_VDD25_11686 METAL5_3231500_806400 METAL5_3231500_803200 0.0128
R_VDD25_11687 METAL5_3231500_803200 METAL5_3231500_802400 0.0032
R_VDD25_11688 METAL5_3231500_802400 METAL5_3231500_800000 0.0096
R_VDD25_11689 METAL5_3231500_800000 METAL5_3231500_794800 0.0208
R_VDD25_11690 METAL5_3231500_794800 METAL5_3231500_794400 0.0016
R_VDD25_11691 METAL5_3231500_794400 METAL5_3231500_791200 0.0128
R_VDD25_11692 METAL5_3231500_791200 METAL5_3231500_790400 0.0032
R_VDD25_11693 METAL5_3231500_790400 METAL5_3231500_788000 0.0096
R_VDD25_11694 METAL5_3231500_788000 METAL5_3231500_784500 0.014
R_VDD25_11695 METAL5_3231500_784500 METAL5_3231500_782400 0.0084
R_VDD25_11696 METAL5_3231500_782400 METAL6_3231500_782400 0.1
R_VDD25_11697 METAL6_3231500_782400 METAL6_3231500_779200 0.0064
R_VDD25_11698 METAL6_3231500_779200 METAL6_3231500_778400 0.0016
R_VDD25_11699 METAL6_3231500_778400 METAL6_3231500_772000 0.0128
R_VDD25_11700 METAL6_3231500_772000 METAL6_3231500_770400 0.0032
R_VDD25_11701 METAL6_3231500_770400 METAL6_3231500_766400 0.008
R_VDD25_11702 METAL6_3231500_766400 METAL6_3231500_763000 0.0068
R_VDD25_11703 METAL6_3231500_763000 METAL6_3231500_758400 0.0092
R_VDD25_11704 METAL6_3231500_758400 METAL6_3231500_754400 0.008
R_VDD25_11705 METAL6_3231500_754400 METAL6_3231500_746400 0.016
R_VDD25_11706 METAL6_3231500_746400 METAL6_3231500_745800 0.0012
R_VDD25_11707 METAL6_3231500_745800 METAL6_3231500_742400 0.0068
R_VDD25_11708 METAL6_3231500_742400 METAL6_3231500_735400 0.014
R_VDD25_11709 METAL6_3231500_735400 METAL6_3231500_733800 0.0032
R_VDD25_11710 METAL6_3231500_733800 METAL6_3231500_721800 0.024
R_VDD25_11711 METAL6_3231500_721800 METAL6_3231500_716800 0.01
R_VDD25_11712 METAL6_3231500_716800 METAL6_3231500_712000 0.0096
R_VDD25_11713 METAL6_3231500_712000 METAL6_3231500_709800 0.0044
R_VDD25_11714 METAL6_3231500_709800 METAL6_3231500_702800 0.014
R_VDD25_11715 METAL6_3231500_702800 METAL6_3231500_700000 0.0056
R_VDD25_11716 METAL6_3231500_700000 METAL6_3231500_697800 0.0044
R_VDD25_11717 METAL6_3231500_697800 METAL6_3231500_688000 0.0196
R_VDD25_11718 METAL6_3231500_688000 METAL6_3231500_665400 0.0452
R_VDD25_11719 METAL6_3231500_665400 METAL6_3231500_661800 0.0072
R_VDD25_11720 METAL6_3231500_661800 METAL6_3231500_653400 0.0168
R_VDD25_11721 METAL6_3231500_653400 METAL6_3231500_649800 0.0072
R_VDD25_11722 METAL6_3219500_649800 METAL6_3231500_649800 0.024
R_VDD25_11723 METAL6_2850800_791200 METAL6_2860600_791200 0.0196
R_VDD25_11724 METAL6_2860600_791200 METAL6_2862800_791200 0.0044
R_VDD25_11725 METAL6_3231500_840700 METAL6_3224500_840700 0.014
R_VDD25_11726 METAL6_3224500_840700 METAL6_3219500_840700 0.01
R_VDD25_11727 METAL6_3219500_840700 METAL6_3219500_851500 0.0216
R_VDD25_11728 METAL6_3219500_851500 METAL6_3212500_851500 0.014
R_VDD25_11729 METAL6_3212500_851500 METAL6_3212500_858200 0.0134
R_VDD25_11730 METAL6_3212500_858200 METAL6_3212500_863500 0.0106
R_VDD25_11731 METAL6_3212500_863500 METAL6_3212500_887000 0.047
R_VDD25_11732 METAL6_3212500_887000 METAL6_3212000_887000 0.001
R_VDD25_11733 METAL6_3212000_887000 METAL6_3207500_887000 0.009
R_VDD25_11734 METAL6_3207500_887000 METAL6_3200500_887000 0.014
R_VDD25_11735 METAL6_3200500_887000 METAL6_3200000_887000 0.001
R_VDD25_11736 METAL6_3200000_887000 METAL6_3188000_887000 0.024
R_VDD25_11737 METAL6_3188000_887000 METAL6_3179500_887000 0.017
R_VDD25_11738 METAL6_3179500_887000 METAL6_3167500_887000 0.024
R_VDD25_11739 METAL6_3167500_887000 METAL6_3165900_887000 0.0032
R_VDD25_11740 METAL6_3165900_887000 METAL6_3155500_887000 0.0208
R_VDD25_11741 METAL6_3155500_887000 METAL6_3124000_887000 0.063
R_VDD25_11742 METAL6_3124000_887000 METAL6_3112000_887000 0.024
R_VDD25_11743 METAL6_3112000_887000 METAL6_3111200_887000 0.0016
R_VDD25_11744 METAL6_3111200_887000 METAL6_3110900_887000 0.0006
R_VDD25_11745 METAL6_3110900_887000 METAL6_3100000_887000 0.0218
R_VDD25_11746 METAL6_3100000_887000 METAL6_3099200_887000 0.0016
R_VDD25_11747 METAL6_3099200_887000 METAL5_3099200_887000 0.1
R_VDD25_11748 METAL5_3099200_887000 METAL5_3098900_887000 0.0012
R_VDD25_11749 METAL5_3098900_887000 METAL5_3088000_887000 0.0436
R_VDD25_11750 METAL5_3088000_887000 METAL5_3087200_887000 0.0032
R_VDD25_11751 METAL5_3087200_887000 METAL5_3086900_887000 0.0012
R_VDD25_11752 METAL5_3086900_887000 METAL5_3076000_887000 0.0436
R_VDD25_11753 METAL5_3076000_887000 METAL5_3075200_887000 0.0032
R_VDD25_11754 METAL5_3075200_887000 METAL6_3075200_887000 0.1
R_VDD25_11755 METAL6_3075200_887000 METAL6_3068200_887000 0.014
R_VDD25_11756 METAL6_3068200_887000 METAL6_3064000_887000 0.0084
R_VDD25_11757 METAL6_3064000_887000 METAL6_3063200_887000 0.0016
R_VDD25_11758 METAL6_3063200_887000 METAL6_3060600_887000 0.0052
R_VDD25_11759 METAL6_3060600_887000 METAL6_3052000_887000 0.0172
R_VDD25_11760 METAL6_3052000_887000 METAL6_3023200_887000 0.0576
R_VDD25_11761 METAL6_3023200_887000 METAL6_3023200_863500 0.047
R_VDD25_11762 METAL6_3023200_863500 METAL6_3023200_858200 0.0106
R_VDD25_11763 METAL6_3023200_858200 METAL6_3023200_851500 0.0134
R_VDD25_11764 METAL6_3023200_851500 METAL6_3023200_840700 0.0216
R_VDD25_11765 METAL6_3023200_840700 METAL6_3018200_840700 0.01
R_VDD25_11766 METAL6_3018200_840700 METAL6_3012000_840700 0.0124
R_VDD25_11767 METAL6_3012000_840700 METAL6_3006200_840700 0.0116
R_VDD25_11768 METAL6_3006200_840700 METAL6_3000000_840700 0.0124
R_VDD25_11769 METAL6_3000000_840700 METAL6_2994200_840700 0.0116
R_VDD25_11770 METAL6_2994200_840700 METAL6_2994200_839500 0.0024
R_VDD25_11771 METAL6_2994200_839500 METAL6_2994200_832000 0.015
R_VDD25_11772 METAL6_2994200_832000 METAL6_2994200_830400 0.0032
R_VDD25_11773 METAL6_2994200_830400 METAL6_2994200_820000 0.0208
R_VDD25_11774 METAL6_2994200_820000 METAL6_2994200_818400 0.0032
R_VDD25_11775 METAL6_2994200_818400 METAL6_2994200_814400 0.008
R_VDD25_11776 METAL6_2994200_814400 METAL6_2994200_812000 0.0048
R_VDD25_11777 METAL6_2994200_812000 METAL6_2994200_808000 0.008
R_VDD25_11778 METAL6_2994200_808000 METAL6_2994200_806400 0.0032
R_VDD25_11779 METAL6_2994200_806400 METAL6_2994200_803200 0.0064
R_VDD25_11780 METAL6_2994200_803200 METAL6_2994200_802400 0.0016
R_VDD25_11781 METAL6_2994200_802400 METAL6_2994200_800000 0.0048
R_VDD25_11782 METAL6_2994200_800000 METAL6_2994200_794800 0.0104
R_VDD25_11783 METAL6_2994200_794800 METAL6_2994200_794400 0.0008
R_VDD25_11784 METAL6_2994200_794400 METAL6_2994200_791200 0.0064
R_VDD25_11785 METAL6_2994200_791200 METAL6_2994200_790400 0.0016
R_VDD25_11786 METAL6_2994200_790400 METAL6_2994200_788000 0.0048
R_VDD25_11787 METAL6_2994200_788000 METAL6_2994200_784500 0.007
R_VDD25_11788 METAL6_2994200_784500 METAL6_2994200_782400 0.0042
R_VDD25_11789 METAL6_2994200_782400 METAL6_2994200_779200 0.0064
R_VDD25_11790 METAL6_2994200_779200 METAL6_2994200_778400 0.0016
R_VDD25_11791 METAL6_2994200_778400 METAL6_2994200_772000 0.0128
R_VDD25_11792 METAL6_2994200_772000 METAL6_2993000_772000 0.0024
R_VDD25_11793 METAL6_2993000_772000 METAL6_2988000_772000 0.01
R_VDD25_11794 METAL6_2988000_772000 METAL6_2982200_772000 0.0116
R_VDD25_11795 METAL6_2982200_772000 METAL6_2975200_772000 0.014
R_VDD25_11796 METAL6_2975200_772000 METAL6_2970200_772000 0.01
R_VDD25_11797 METAL6_2970200_772000 METAL6_2965900_772000 0.0086
R_VDD25_11798 METAL6_2965900_772000 METAL6_2951900_772000 0.028
R_VDD25_11799 METAL6_2951900_772000 METAL6_2942200_772000 0.0194
R_VDD25_11800 METAL6_2942200_772000 METAL6_2930200_772000 0.024
R_VDD25_11801 METAL6_2930200_772000 METAL6_2930200_778400 0.0128
R_VDD25_11802 METAL6_2930200_778400 METAL6_2925600_778400 0.0092
R_VDD25_11803 METAL6_2925600_778400 METAL6_2918200_778400 0.0148
R_VDD25_11804 METAL6_2918200_778400 METAL6_2913600_778400 0.0092
R_VDD25_11805 METAL6_2913600_778400 METAL6_2910900_778400 0.0054
R_VDD25_11806 METAL6_2910900_778400 METAL6_2901600_778400 0.0186
R_VDD25_11807 METAL6_2901600_778400 METAL6_2898900_778400 0.0054
R_VDD25_11808 METAL6_2898900_778400 METAL6_2897100_778400 0.0036
R_VDD25_11809 METAL6_2897100_778400 METAL6_2886900_778400 0.0204
R_VDD25_11810 METAL6_2886900_778400 METAL6_2874800_778400 0.0242
R_VDD25_11811 METAL6_2874800_778400 METAL6_2862800_778400 0.024
R_VDD25_11812 METAL6_2862800_778400 METAL6_2862800_779200 0.0016
R_VDD25_11813 METAL6_2862800_779200 METAL6_2862800_782400 0.0064
R_VDD25_11814 METAL6_2862800_782400 METAL6_2862800_784500 0.0042
R_VDD25_11815 METAL6_2862800_784500 METAL6_2862800_788000 0.007
R_VDD25_11816 METAL6_2862800_788000 METAL6_2862800_790400 0.0048
R_VDD25_11817 METAL6_2862800_790400 METAL6_2862800_791200 0.0016
R_VDD25_11818 METAL6_940400_2126500 METAL6_928400_2126500 0.024
R_VDD25_11819 METAL6_2493000_2246500 METAL6_2493000_2258500 0.024
R_VDD25_11820 METAL6_2493000_2258500 METAL6_2493000_2268500 0.02
R_VDD25_11821 METAL6_2493000_2268500 METAL6_2492400_2268500 0.0012
R_VDD25_11822 METAL6_2492400_2268500 METAL6_2489600_2268500 0.0056
R_VDD25_11823 METAL6_2489600_2268500 METAL6_2488000_2268500 0.0032
R_VDD25_11824 METAL6_2488000_2268500 METAL6_2486900_2268500 0.0022
R_VDD25_11825 METAL6_2486900_2268500 METAL6_2484600_2268500 0.0046
R_VDD25_11826 METAL6_2484600_2268500 METAL6_2481000_2268500 0.0072
R_VDD25_11827 METAL6_2481000_2268500 METAL6_2480400_2268500 0.0012
R_VDD25_11828 METAL6_2480400_2268500 METAL6_2477600_2268500 0.0056
R_VDD25_11829 METAL6_2477600_2268500 METAL6_2476000_2268500 0.0032
R_VDD25_11830 METAL6_2476000_2268500 METAL6_2472600_2268500 0.0068
R_VDD25_11831 METAL6_2472600_2268500 METAL6_2469000_2268500 0.0072
R_VDD25_11832 METAL6_2469000_2268500 METAL6_2468400_2268500 0.0012
R_VDD25_11833 METAL6_2468400_2268500 METAL6_2465600_2268500 0.0056
R_VDD25_11834 METAL6_2465600_2268500 METAL6_2464000_2268500 0.0032
R_VDD25_11835 METAL6_2464000_2268500 METAL6_2460600_2268500 0.0068
R_VDD25_11836 METAL6_2460600_2268500 METAL6_2458600_2268500 0.004
R_VDD25_11837 METAL6_2458600_2268500 METAL5_2458600_2268500 0.1
R_VDD25_11838 METAL5_2458600_2268500 METAL5_2457000_2268500 0.0064
R_VDD25_11839 METAL5_2457000_2268500 METAL5_2448600_2268500 0.0336
R_VDD25_11840 METAL5_2448600_2268500 METAL5_2446600_2268500 0.008
R_VDD25_11841 METAL5_2446600_2268500 METAL5_2436600_2268500 0.04
R_VDD25_11842 METAL5_2436600_2268500 METAL5_2434600_2268500 0.008
R_VDD25_11843 METAL5_2434600_2268500 METAL6_2434600_2268500 0.1
R_VDD25_11844 METAL6_2434600_2268500 METAL6_2424600_2268500 0.02
R_VDD25_11845 METAL6_2424600_2268500 METAL6_2419100_2268500 0.011
R_VDD25_11846 METAL6_2419100_2268500 METAL6_2407100_2268500 0.024
R_VDD25_11847 METAL6_2407100_2268500 METAL6_2405600_2268500 0.003
R_VDD25_11848 METAL6_2405600_2268500 METAL6_2402100_2268500 0.007
R_VDD25_11849 METAL6_2402100_2268500 METAL6_2395100_2268500 0.014
R_VDD25_11850 METAL6_2395100_2268500 METAL6_2393600_2268500 0.003
R_VDD25_11851 METAL6_2393600_2268500 METAL6_2383100_2268500 0.021
R_VDD25_11852 METAL6_2383100_2268500 METAL6_2381600_2268500 0.003
R_VDD25_11853 METAL6_2381600_2268500 METAL6_2371100_2268500 0.021
R_VDD25_11854 METAL6_2371100_2268500 METAL6_2369600_2268500 0.003
R_VDD25_11855 METAL6_2369600_2268500 METAL6_2365900_2268500 0.0074
R_VDD25_11856 METAL6_2365900_2268500 METAL6_2357600_2268500 0.0166
R_VDD25_11857 METAL6_2357600_2268500 METAL6_2351900_2268500 0.0114
R_VDD25_11858 METAL6_2351900_2268500 METAL6_2343700_2268500 0.0164
R_VDD25_11859 METAL6_2343700_2268500 METAL6_2320600_2268500 0.0462
R_VDD25_11860 METAL6_2320600_2268500 METAL6_2310900_2268500 0.0194
R_VDD25_11861 METAL6_2310900_2268500 METAL6_2308600_2268500 0.0046
R_VDD25_11862 METAL6_2308600_2268500 METAL6_2298900_2268500 0.0194
R_VDD25_11863 METAL6_2298900_2268500 METAL6_2296600_2268500 0.0046
R_VDD25_11864 METAL6_2296600_2268500 METAL5_2296600_2268500 0.1
R_VDD25_11865 METAL5_2296600_2268500 METAL5_2286900_2268500 0.0388
R_VDD25_11866 METAL5_2286900_2268500 METAL5_2284600_2268500 0.0092
R_VDD25_11867 METAL5_2284600_2268500 METAL5_2284400_2268500 0.0008
R_VDD25_11868 METAL5_2284400_2268500 METAL5_2274900_2268500 0.038
R_VDD25_11869 METAL5_2274900_2268500 METAL5_2272600_2268500 0.0092
R_VDD25_11870 METAL5_2272600_2268500 METAL5_2272400_2268500 0.0008
R_VDD25_11871 METAL5_2272400_2268500 METAL5_2260600_2268500 0.0472
R_VDD25_11872 METAL5_2260600_2268500 METAL5_2260400_2268500 0.0008
R_VDD25_11873 METAL5_2260400_2268500 METAL5_2258600_2268500 0.0072
R_VDD25_11874 METAL5_2258600_2268500 METAL5_2248700_2268500 0.0396
R_VDD25_11875 METAL5_2248700_2268500 METAL5_2248600_2268500 0.0004
R_VDD25_11876 METAL5_2248600_2268500 METAL5_2248400_2268500 0.0008
R_VDD25_11877 METAL5_2248400_2268500 METAL5_2246600_2268500 0.0072
R_VDD25_11878 METAL5_2246600_2268500 METAL5_2236700_2268500 0.0396
R_VDD25_11879 METAL5_2236700_2268500 METAL5_2236600_2268500 0.0004
R_VDD25_11880 METAL5_2236600_2268500 METAL5_2234600_2268500 0.008
R_VDD25_11881 METAL5_2234600_2268500 METAL5_2233900_2268500 0.0028
R_VDD25_11882 METAL5_2233900_2268500 METAL5_2224700_2268500 0.0368
R_VDD25_11883 METAL5_2224700_2268500 METAL5_2224600_2268500 0.0004
R_VDD25_11884 METAL5_2224600_2268500 METAL5_2222600_2268500 0.008
R_VDD25_11885 METAL5_2222600_2268500 METAL5_2221900_2268500 0.0028
R_VDD25_11886 METAL5_2221900_2268500 METAL5_2212700_2268500 0.0368
R_VDD25_11887 METAL5_2212700_2268500 METAL5_2210600_2268500 0.0084
R_VDD25_11888 METAL5_2210600_2268500 METAL5_2209900_2268500 0.0028
R_VDD25_11889 METAL5_2209900_2268500 METAL5_2200700_2268500 0.0368
R_VDD25_11890 METAL5_2200700_2268500 METAL5_2189900_2268500 0.0432
R_VDD25_11891 METAL5_2189900_2268500 METAL5_2188700_2268500 0.0048
R_VDD25_11892 METAL5_2188700_2268500 METAL5_2177900_2268500 0.0432
R_VDD25_11893 METAL5_2177900_2268500 METAL5_2176700_2268500 0.0048
R_VDD25_11894 METAL5_2176700_2268500 METAL5_2165900_2268500 0.0432
R_VDD25_11895 METAL5_2165900_2268500 METAL5_2165400_2268500 0.002
R_VDD25_11896 METAL5_2165400_2268500 METAL5_2153900_2268500 0.046
R_VDD25_11897 METAL5_2153900_2268500 METAL5_2153400_2268500 0.002
R_VDD25_11898 METAL5_2153400_2268500 METAL5_2151900_2268500 0.006
R_VDD25_11899 METAL5_2151900_2268500 METAL5_2141900_2268500 0.04
R_VDD25_11900 METAL5_2141900_2268500 METAL5_2141400_2268500 0.002
R_VDD25_11901 METAL5_2141400_2268500 METAL5_2129900_2268500 0.046
R_VDD25_11902 METAL5_2129900_2268500 METAL5_2129700_2268500 0.0008
R_VDD25_11903 METAL5_2129700_2268500 METAL5_2125600_2268500 0.0164
R_VDD25_11904 METAL5_2125600_2268500 METAL5_2121400_2268500 0.0168
R_VDD25_11905 METAL5_2121400_2268500 METAL5_2117900_2268500 0.014
R_VDD25_11906 METAL5_2117900_2268500 METAL6_2117900_2268500 0.1
R_VDD25_11907 METAL6_2117900_2268500 METAL6_2113900_2268500 0.008
R_VDD25_11908 METAL6_2113900_2268500 METAL6_2113600_2268500 0.0006
R_VDD25_11909 METAL6_2113600_2268500 METAL6_2105900_2268500 0.0154
R_VDD25_11910 METAL6_2105900_2268500 METAL6_2101900_2268500 0.008
R_VDD25_11911 METAL6_2101900_2268500 METAL6_2101600_2268500 0.0006
R_VDD25_11912 METAL6_2101600_2268500 METAL6_2089900_2268500 0.0234
R_VDD25_11913 METAL6_2089900_2268500 METAL6_2079700_2268500 0.0204
R_VDD25_11914 METAL6_2079700_2268500 METAL6_2077900_2268500 0.0036
R_VDD25_11915 METAL6_2077900_2268500 METAL6_2067700_2268500 0.0204
R_VDD25_11916 METAL6_2067700_2268500 METAL6_2060600_2268500 0.0142
R_VDD25_11917 METAL6_2060600_2268500 METAL6_2058800_2268500 0.0036
R_VDD25_11918 METAL6_2058800_2268500 METAL6_2055700_2268500 0.0062
R_VDD25_11919 METAL6_2055700_2268500 METAL6_2046800_2268500 0.0178
R_VDD25_11920 METAL6_2046800_2268500 METAL6_2046600_2268500 0.0004
R_VDD25_11921 METAL6_2046600_2268500 METAL6_2046400_2268500 0.0004
R_VDD25_11922 METAL6_2046400_2268500 METAL6_2043700_2268500 0.0054
R_VDD25_11923 METAL6_2043700_2268500 METAL6_2034800_2268500 0.0178
R_VDD25_11924 METAL6_2034800_2268500 METAL6_2031700_2268500 0.0062
R_VDD25_11925 METAL6_2031700_2268500 METAL6_2030900_2268500 0.0016
R_VDD25_11926 METAL6_2030900_2268500 METAL6_2026400_2268500 0.009
R_VDD25_11927 METAL6_2026400_2268500 METAL6_2021200_2268500 0.0104
R_VDD25_11928 METAL6_2021200_2268500 METAL6_2019700_2268500 0.003
R_VDD25_11929 METAL6_2019700_2268500 METAL6_2018900_2268500 0.0016
R_VDD25_11930 METAL6_2018900_2268500 METAL6_2014400_2268500 0.009
R_VDD25_11931 METAL6_2014400_2268500 METAL6_2012000_2268500 0.0048
R_VDD25_11932 METAL6_2012000_2268500 METAL6_2007700_2268500 0.0086
R_VDD25_11933 METAL6_2007700_2268500 METAL6_2006900_2268500 0.0016
R_VDD25_11934 METAL6_2006900_2268500 METAL6_2002400_2268500 0.009
R_VDD25_11935 METAL6_2002400_2268500 METAL6_2000000_2268500 0.0048
R_VDD25_11936 METAL6_2000000_2268500 METAL6_1988000_2268500 0.024
R_VDD25_11937 METAL6_1988000_2268500 METAL6_1963900_2268500 0.0482
R_VDD25_11938 METAL6_1963900_2268500 METAL6_1951900_2268500 0.024
R_VDD25_11939 METAL6_1951900_2268500 METAL6_1951800_2268500 0.0002
R_VDD25_11940 METAL6_1951800_2268500 METAL6_1939900_2268500 0.0238
R_VDD25_11941 METAL6_1939900_2268500 METAL6_1939800_2268500 0.0002
R_VDD25_11942 METAL6_1939800_2268500 METAL6_1937600_2268500 0.0044
R_VDD25_11943 METAL6_1937600_2268500 METAL6_1931200_2268500 0.0128
R_VDD25_11944 METAL6_1931200_2268500 METAL6_1927800_2268500 0.0068
R_VDD25_11945 METAL6_1927800_2268500 METAL6_1926200_2268500 0.0032
R_VDD25_11946 METAL6_1926200_2268500 METAL6_1925600_2268500 0.0012
R_VDD25_11947 METAL6_1925600_2268500 METAL6_1919200_2268500 0.0128
R_VDD25_11948 METAL6_1919200_2268500 METAL6_1913600_2268500 0.0112
R_VDD25_11949 METAL6_1913600_2268500 METAL6_1907400_2268500 0.0124
R_VDD25_11950 METAL6_1907400_2268500 METAL6_1907200_2268500 0.0004
R_VDD25_11951 METAL6_1907200_2268500 METAL6_1901600_2268500 0.0112
R_VDD25_11952 METAL6_1901600_2268500 METAL6_1900700_2268500 0.0018
R_VDD25_11953 METAL6_1900700_2268500 METAL6_1895200_2268500 0.011
R_VDD25_11954 METAL6_1895200_2268500 METAL6_1889600_2268500 0.0112
R_VDD25_11955 METAL6_1889600_2268500 METAL6_1889400_2268500 0.0004
R_VDD25_11956 METAL6_1889400_2268500 METAL6_1888700_2268500 0.0014
R_VDD25_11957 METAL6_1888700_2268500 METAL6_1883200_2268500 0.011
R_VDD25_11958 METAL6_1883200_2268500 METAL6_1877600_2268500 0.0112
R_VDD25_11959 METAL6_1877600_2268500 METAL6_1877400_2268500 0.0004
R_VDD25_11960 METAL6_1877400_2268500 METAL6_1876700_2268500 0.0014
R_VDD25_11961 METAL6_1876700_2268500 METAL6_1874700_2268500 0.004
R_VDD25_11962 METAL6_1874700_2268500 METAL6_1871200_2268500 0.007
R_VDD25_11963 METAL6_1871200_2268500 METAL6_1870600_2268500 0.0012
R_VDD25_11964 METAL6_1870600_2268500 METAL6_1865600_2268500 0.01
R_VDD25_11965 METAL6_1865600_2268500 METAL6_1865400_2268500 0.0004
R_VDD25_11966 METAL6_1865400_2268500 METAL6_1864700_2268500 0.0014
R_VDD25_11967 METAL6_1864700_2268500 METAL6_1859200_2268500 0.011
R_VDD25_11968 METAL6_1859200_2268500 METAL6_1858600_2268500 0.0012
R_VDD25_11969 METAL6_1858600_2268500 METAL6_1858400_2268500 0.0004
R_VDD25_11970 METAL6_1858400_2268500 METAL6_1853400_2268500 0.01
R_VDD25_11971 METAL6_1853400_2268500 METAL6_1852700_2268500 0.0014
R_VDD25_11972 METAL6_1852700_2268500 METAL6_1847200_2268500 0.011
R_VDD25_11973 METAL6_1847200_2268500 METAL6_1846800_2268500 0.0008
R_VDD25_11974 METAL6_1846800_2268500 METAL6_1846600_2268500 0.0004
R_VDD25_11975 METAL6_1846600_2268500 METAL6_1846400_2268500 0.0004
R_VDD25_11976 METAL6_1846400_2268500 METAL6_1844800_2268500 0.0032
R_VDD25_11977 METAL6_1844800_2268500 METAL6_1841400_2268500 0.0068
R_VDD25_11978 METAL6_1841400_2268500 METAL6_1834600_2268500 0.0136
R_VDD25_11979 METAL6_1834600_2268500 METAL6_1834400_2268500 0.0004
R_VDD25_11980 METAL6_1834400_2268500 METAL6_1832800_2268500 0.0032
R_VDD25_11981 METAL6_1832800_2268500 METAL6_1822600_2268500 0.0204
R_VDD25_11982 METAL6_1822600_2268500 METAL6_1822400_2268500 0.0004
R_VDD25_11983 METAL6_1822400_2268500 METAL6_1820800_2268500 0.0032
R_VDD25_11984 METAL6_1820800_2268500 METAL6_1812000_2268500 0.0176
R_VDD25_11985 METAL6_1812000_2268500 METAL6_1800000_2268500 0.024
R_VDD25_11986 METAL6_1800000_2268500 METAL6_1788000_2268500 0.024
R_VDD25_11987 METAL6_1788000_2268500 METAL6_1763400_2268500 0.0492
R_VDD25_11988 METAL6_1763400_2268500 METAL6_1755700_2268500 0.0154
R_VDD25_11989 METAL6_1755700_2268500 METAL6_1753800_2268500 0.0038
R_VDD25_11990 METAL6_1753800_2268500 METAL6_1751800_2268500 0.004
R_VDD25_11991 METAL6_1751800_2268500 METAL6_1751400_2268500 0.0008
R_VDD25_11992 METAL6_1751400_2268500 METAL6_1744000_2268500 0.0148
R_VDD25_11993 METAL6_1744000_2268500 METAL6_1743700_2268500 0.0006
R_VDD25_11994 METAL6_1743700_2268500 METAL6_1741800_2268500 0.0038
R_VDD25_11995 METAL6_1741800_2268500 METAL6_1739800_2268500 0.004
R_VDD25_11996 METAL6_1739800_2268500 METAL6_1739400_2268500 0.0008
R_VDD25_11997 METAL6_1739400_2268500 METAL6_1731700_2268500 0.0154
R_VDD25_11998 METAL6_1731700_2268500 METAL6_1729800_2268500 0.0038
R_VDD25_11999 METAL6_1729800_2268500 METAL6_1727800_2268500 0.004
R_VDD25_12000 METAL6_1727800_2268500 METAL6_1719700_2268500 0.0162
R_VDD25_12001 METAL6_1719700_2268500 METAL6_1717800_2268500 0.0038
R_VDD25_12002 METAL6_1717800_2268500 METAL6_1710800_2268500 0.014
R_VDD25_12003 METAL6_1710800_2268500 METAL6_1707700_2268500 0.0062
R_VDD25_12004 METAL6_1707700_2268500 METAL6_1699000_2268500 0.0174
R_VDD25_12005 METAL6_1699000_2268500 METAL6_1692000_2268500 0.014
R_VDD25_12006 METAL6_1692000_2268500 METAL6_1680000_2268500 0.024
R_VDD25_12007 METAL6_1680000_2268500 METAL6_1670800_2268500 0.0184
R_VDD25_12008 METAL6_1670800_2268500 METAL6_1668000_2268500 0.0056
R_VDD25_12009 METAL6_1668000_2268500 METAL6_1658800_2268500 0.0184
R_VDD25_12010 METAL6_1658800_2268500 METAL6_1646800_2268500 0.024
R_VDD25_12011 METAL6_1646800_2268500 METAL6_1634800_2268500 0.024
R_VDD25_12012 METAL6_1634800_2268500 METAL6_1632800_2268500 0.004
R_VDD25_12013 METAL6_1632800_2268500 METAL6_1627800_2268500 0.01
R_VDD25_12014 METAL6_1627800_2268500 METAL6_1615800_2268500 0.024
R_VDD25_12015 METAL6_1615800_2268500 METAL6_1612700_2268500 0.0062
R_VDD25_12016 METAL6_1612700_2268500 METAL6_1612000_2268500 0.0014
R_VDD25_12017 METAL6_1612000_2268500 METAL6_1607900_2268500 0.0082
R_VDD25_12018 METAL6_1607900_2268500 METAL6_1603800_2268500 0.0082
R_VDD25_12019 METAL6_1603800_2268500 METAL6_1600700_2268500 0.0062
R_VDD25_12020 METAL6_1600700_2268500 METAL6_1600000_2268500 0.0014
R_VDD25_12021 METAL6_1600000_2268500 METAL6_1591800_2268500 0.0164
R_VDD25_12022 METAL6_1591800_2268500 METAL6_1588700_2268500 0.0062
R_VDD25_12023 METAL6_1588700_2268500 METAL6_1588000_2268500 0.0014
R_VDD25_12024 METAL6_1588000_2268500 METAL6_1579800_2268500 0.0164
R_VDD25_12025 METAL6_1579800_2268500 METAL6_1576700_2268500 0.0062
R_VDD25_12026 METAL6_1576700_2268500 METAL6_1576000_2268500 0.0014
R_VDD25_12027 METAL6_1576000_2268500 METAL6_1574700_2268500 0.0026
R_VDD25_12028 METAL6_1574700_2268500 METAL6_1564000_2268500 0.0214
R_VDD25_12029 METAL6_1564000_2268500 METAL6_1557000_2268500 0.014
R_VDD25_12030 METAL6_1557000_2268500 METAL6_1555400_2268500 0.0032
R_VDD25_12031 METAL6_1555400_2268500 METAL6_1551800_2268500 0.0072
R_VDD25_12032 METAL6_1551800_2268500 METAL6_1539800_2268500 0.024
R_VDD25_12033 METAL6_1539800_2268500 METAL6_1527800_2268500 0.024
R_VDD25_12034 METAL6_1527800_2268500 METAL6_1512000_2268500 0.0316
R_VDD25_12035 METAL6_1512000_2268500 METAL6_1510400_2268500 0.0032
R_VDD25_12036 METAL6_1510400_2268500 METAL6_1503400_2268500 0.014
R_VDD25_12037 METAL6_1503400_2268500 METAL6_1500000_2268500 0.0068
R_VDD25_12038 METAL6_1500000_2268500 METAL6_1498300_2268500 0.0034
R_VDD25_12039 METAL6_1498300_2268500 METAL6_1491400_2268500 0.0138
R_VDD25_12040 METAL6_1491400_2268500 METAL6_1488000_2268500 0.0068
R_VDD25_12041 METAL6_1488000_2268500 METAL6_1479400_2268500 0.0172
R_VDD25_12042 METAL6_1479400_2268500 METAL6_1443700_2268500 0.0714
R_VDD25_12043 METAL6_1443700_2268500 METAL6_1432800_2268500 0.0218
R_VDD25_12044 METAL6_1432800_2268500 METAL6_1431700_2268500 0.0022
R_VDD25_12045 METAL6_1431700_2268500 METAL6_1424000_2268500 0.0154
R_VDD25_12046 METAL6_1424000_2268500 METAL6_1419700_2268500 0.0086
R_VDD25_12047 METAL6_1419700_2268500 METAL6_1412000_2268500 0.0154
R_VDD25_12048 METAL6_1412000_2268500 METAL6_1400000_2268500 0.024
R_VDD25_12049 METAL6_1400000_2268500 METAL6_1388000_2268500 0.024
R_VDD25_12050 METAL6_1388000_2268500 METAL6_1337000_2268500 0.102
R_VDD25_12051 METAL6_1337000_2268500 METAL6_1325000_2268500 0.024
R_VDD25_12052 METAL6_1325000_2268500 METAL6_1324000_2268500 0.002
R_VDD25_12053 METAL6_1324000_2268500 METAL6_1323800_2268500 0.0004
R_VDD25_12054 METAL6_1323800_2268500 METAL6_1313000_2268500 0.0216
R_VDD25_12055 METAL6_1313000_2268500 METAL6_1312000_2268500 0.002
R_VDD25_12056 METAL6_1312000_2268500 METAL6_1311800_2268500 0.0004
R_VDD25_12057 METAL6_1311800_2268500 METAL5_1311800_2268500 0.1
R_VDD25_12058 METAL5_1311800_2268500 METAL5_1301000_2268500 0.0432
R_VDD25_12059 METAL5_1301000_2268500 METAL5_1300000_2268500 0.004
R_VDD25_12060 METAL5_1300000_2268500 METAL5_1299800_2268500 0.0008
R_VDD25_12061 METAL5_1299800_2268500 METAL5_1289000_2268500 0.0432
R_VDD25_12062 METAL5_1289000_2268500 METAL5_1288000_2268500 0.004
R_VDD25_12063 METAL5_1288000_2268500 METAL5_1287800_2268500 0.0008
R_VDD25_12064 METAL5_1287800_2268500 METAL5_1286700_2268500 0.0044
R_VDD25_12065 METAL5_1286700_2268500 METAL5_1274700_2268500 0.048
R_VDD25_12066 METAL5_1274700_2268500 METAL5_1266800_2268500 0.0316
R_VDD25_12067 METAL5_1266800_2268500 METAL5_1262700_2268500 0.0164
R_VDD25_12068 METAL5_1262700_2268500 METAL5_1259800_2268500 0.0116
R_VDD25_12069 METAL5_1259800_2268500 METAL5_1258300_2268500 0.006
R_VDD25_12070 METAL5_1258300_2268500 METAL5_1254700_2268500 0.0144
R_VDD25_12071 METAL5_1254700_2268500 METAL5_1253300_2268500 0.0056
R_VDD25_12072 METAL5_1253300_2268500 METAL5_1247800_2268500 0.022
R_VDD25_12073 METAL5_1247800_2268500 METAL5_1246300_2268500 0.006
R_VDD25_12074 METAL5_1246300_2268500 METAL5_1242700_2268500 0.0144
R_VDD25_12075 METAL5_1242700_2268500 METAL5_1235800_2268500 0.0276
R_VDD25_12076 METAL5_1235800_2268500 METAL5_1234300_2268500 0.006
R_VDD25_12077 METAL5_1234300_2268500 METAL5_1230700_2268500 0.0144
R_VDD25_12078 METAL5_1230700_2268500 METAL5_1224000_2268500 0.0268
R_VDD25_12079 METAL5_1224000_2268500 METAL5_1223800_2268500 0.0008
R_VDD25_12080 METAL5_1223800_2268500 METAL5_1222300_2268500 0.006
R_VDD25_12081 METAL5_1222300_2268500 METAL5_1218700_2268500 0.0144
R_VDD25_12082 METAL5_1218700_2268500 METAL5_1216400_2268500 0.0092
R_VDD25_12083 METAL5_1216400_2268500 METAL5_1212000_2268500 0.0176
R_VDD25_12084 METAL5_1212000_2268500 METAL5_1211800_2268500 0.0008
R_VDD25_12085 METAL5_1211800_2268500 METAL5_1210300_2268500 0.006
R_VDD25_12086 METAL5_1210300_2268500 METAL5_1206700_2268500 0.0144
R_VDD25_12087 METAL5_1206700_2268500 METAL5_1204400_2268500 0.0092
R_VDD25_12088 METAL5_1204400_2268500 METAL5_1200000_2268500 0.0176
R_VDD25_12089 METAL5_1200000_2268500 METAL5_1199800_2268500 0.0008
R_VDD25_12090 METAL5_1199800_2268500 METAL5_1198300_2268500 0.006
R_VDD25_12091 METAL5_1198300_2268500 METAL6_1198300_2268500 0.1
R_VDD25_12092 METAL6_1198300_2268500 METAL6_1194700_2268500 0.0072
R_VDD25_12093 METAL6_1194700_2268500 METAL6_1192400_2268500 0.0046
R_VDD25_12094 METAL6_1192400_2268500 METAL6_1188000_2268500 0.0088
R_VDD25_12095 METAL6_1188000_2268500 METAL6_1186300_2268500 0.0034
R_VDD25_12096 METAL6_1186300_2268500 METAL6_1180400_2268500 0.0118
R_VDD25_12097 METAL6_1180400_2268500 METAL6_1174300_2268500 0.0122
R_VDD25_12098 METAL6_1174300_2268500 METAL6_1173700_2268500 0.0012
R_VDD25_12099 METAL6_1173700_2268500 METAL6_1166700_2268500 0.014
R_VDD25_12100 METAL6_1166700_2268500 METAL6_1154700_2268500 0.024
R_VDD25_12101 METAL6_1154700_2268500 METAL6_1142700_2268500 0.024
R_VDD25_12102 METAL6_1142700_2268500 METAL6_1137000_2268500 0.0114
R_VDD25_12103 METAL6_1137000_2268500 METAL6_1130700_2268500 0.0126
R_VDD25_12104 METAL6_1130700_2268500 METAL6_1125000_2268500 0.0114
R_VDD25_12105 METAL6_1125000_2268500 METAL6_1113000_2268500 0.024
R_VDD25_12106 METAL6_1113000_2268500 METAL6_1019000_2268500 0.188
R_VDD25_12107 METAL6_1019000_2268500 METAL6_1007000_2268500 0.024
R_VDD25_12108 METAL6_1007000_2268500 METAL6_995000_2268500 0.024
R_VDD25_12109 METAL6_995000_2268500 METAL6_988000_2268500 0.014
R_VDD25_12110 METAL6_988000_2268500 METAL6_952400_2268500 0.0712
R_VDD25_12111 METAL6_952400_2268500 METAL6_947400_2268500 0.01
R_VDD25_12112 METAL6_947400_2268500 METAL6_940400_2268500 0.014
R_VDD25_12113 METAL6_940400_2268500 METAL5_940400_2268500 0.1
R_VDD25_12114 METAL5_940400_2268500 METAL5_928400_2268500 0.048
R_VDD25_12115 METAL5_928400_2268500 METAL5_928400_2258500 0.04
R_VDD25_12116 METAL5_928400_2258500 METAL5_928400_2246500 0.048
R_VDD25_12117 METAL5_928400_2246500 METAL5_928400_2234500 0.048
R_VDD25_12118 METAL5_928400_2234500 METAL5_928400_2222500 0.048
R_VDD25_12119 METAL5_928400_2222500 METAL5_928400_2202300 0.0808
R_VDD25_12120 METAL5_928400_2202300 METAL5_928400_2190300 0.048
R_VDD25_12121 METAL5_928400_2190300 METAL5_928400_2187000 0.0132
R_VDD25_12122 METAL5_928400_2187000 METAL5_928400_2178300 0.0348
R_VDD25_12123 METAL5_928400_2178300 METAL5_928400_2175000 0.0132
R_VDD25_12124 METAL5_928400_2175000 METAL5_928400_2166300 0.0348
R_VDD25_12125 METAL5_928400_2166300 METAL5_928400_2163000 0.0132
R_VDD25_12126 METAL5_928400_2163000 METAL5_928400_2154300 0.0348
R_VDD25_12127 METAL5_928400_2154300 METAL5_928400_2150500 0.0152
R_VDD25_12128 METAL5_928400_2150500 METAL5_928400_2147300 0.0128
R_VDD25_12129 METAL5_928400_2147300 METAL5_928400_2138500 0.0352
R_VDD25_12130 METAL5_928400_2138500 METAL5_928400_2126500 0.048
R_VDD25_12131 METAL5_928400_2126500 METAL6_928400_2126500 0.1
I_VDD25_40 METAL6_3219500_649800 gnd 0.001
I_VDD25_41 METAL6_2850800_791200 gnd 0.001
I_VDD25_42 METAL6_940400_2126500 gnd 0.0016

V_VDD26_19 METAL5_3500000_2350000 gnd 1
R_VDD26_12132 METAL5_3500000_2350000 METAL5_3490500_2350000 0.038
R_VDD26_12133 METAL5_3490500_2350000 METAL6_3490500_2350000 0.1
R_VDD26_12134 METAL6_3490500_2350000 METAL6_3478500_2350000 0.024
R_VDD26_12135 METAL6_3478500_2350000 METAL6_3478500_2341000 0.018
R_VDD26_12136 METAL6_3478500_2341000 METAL6_3477000_2341000 0.003
R_VDD26_12137 METAL6_3477000_2341000 METAL6_3466500_2341000 0.021
R_VDD26_12138 METAL6_3466500_2341000 METAL6_3465000_2341000 0.003
R_VDD26_12139 METAL6_3465000_2341000 METAL6_3454500_2341000 0.021
R_VDD26_12140 METAL6_3454500_2341000 METAL6_3453000_2341000 0.003
R_VDD26_12141 METAL6_3453000_2341000 METAL6_3442500_2341000 0.021
R_VDD26_12142 METAL6_3442500_2341000 METAL6_3360400_2341000 0.1642
R_VDD26_12143 METAL6_3360400_2341000 METAL6_3348400_2341000 0.024
R_VDD26_12144 METAL6_3348400_2341000 METAL6_3336400_2341000 0.024
R_VDD26_12145 METAL6_3336400_2341000 METAL6_3324400_2341000 0.024
R_VDD26_12146 METAL6_3324400_2341000 METAL5_3324400_2341000 0.1
R_VDD26_12147 METAL5_3324400_2341000 METAL5_3312400_2341000 0.048
R_VDD26_12148 METAL5_3312400_2341000 METAL5_3312000_2341000 0.0016
R_VDD26_12149 METAL5_3312000_2341000 METAL5_3305400_2341000 0.0264
R_VDD26_12150 METAL5_3305400_2341000 METAL5_3300400_2341000 0.02
R_VDD26_12151 METAL5_3300400_2341000 METAL6_3300400_2341000 0.1
R_VDD26_12152 METAL6_3300400_2341000 METAL6_3300400_2340000 0.002
R_VDD26_12153 METAL6_3300400_2340000 METAL6_3300400_2338000 0.004
R_VDD26_12154 METAL6_3300400_2338000 METAL6_3300400_2329000 0.018
R_VDD26_12155 METAL6_3300400_2329000 METAL6_3300400_2328000 0.002
R_VDD26_12156 METAL6_3300400_2328000 METAL6_3300400_2326000 0.004
R_VDD26_12157 METAL6_3300400_2326000 METAL6_3300400_2317000 0.018
R_VDD26_12158 METAL6_3300400_2317000 METAL6_3300400_2316000 0.002
R_VDD26_12159 METAL6_3300400_2316000 METAL6_3300000_2316000 0.0008
R_VDD26_12160 METAL6_3300000_2316000 METAL6_3288400_2316000 0.0232
R_VDD26_12161 METAL6_3288400_2316000 METAL6_3288000_2316000 0.0008
R_VDD26_12162 METAL6_3288000_2316000 METAL6_3287000_2316000 0.002
R_VDD26_12163 METAL6_3287000_2316000 METAL6_3276400_2316000 0.0212
R_VDD26_12164 METAL6_3276400_2316000 METAL6_3275000_2316000 0.0028
R_VDD26_12165 METAL6_3275000_2316000 METAL6_3263000_2316000 0.024
R_VDD26_12166 METAL6_3263000_2316000 METAL6_3260400_2316000 0.0052
R_VDD26_12167 METAL6_3260400_2316000 METAL6_3243500_2316000 0.0338
R_VDD26_12168 METAL6_3243500_2316000 METAL6_3231500_2316000 0.024
R_VDD26_12169 METAL6_3231500_2316000 METAL6_3224500_2316000 0.014
R_VDD26_12170 METAL6_3224500_2316000 METAL6_3219500_2316000 0.01
R_VDD26_12171 METAL6_3219500_2316000 METAL6_3212500_2316000 0.014
R_VDD26_12172 METAL6_3212500_2316000 METAL6_3212000_2316000 0.001
R_VDD26_12173 METAL6_3212000_2316000 METAL6_3207500_2316000 0.009
R_VDD26_12174 METAL6_3207500_2316000 METAL6_3200500_2316000 0.014
R_VDD26_12175 METAL6_3200500_2316000 METAL6_3200000_2316000 0.001
R_VDD26_12176 METAL6_3200000_2316000 METAL6_3188000_2316000 0.024
R_VDD26_12177 METAL6_3188000_2316000 METAL6_3179500_2316000 0.017
R_VDD26_12178 METAL6_3179500_2316000 METAL6_3167500_2316000 0.024
R_VDD26_12179 METAL6_3167500_2316000 METAL6_3165900_2316000 0.0032
R_VDD26_12180 METAL6_3165900_2316000 METAL6_3155500_2316000 0.0208
R_VDD26_12181 METAL6_3155500_2316000 METAL6_3124000_2316000 0.063
R_VDD26_12182 METAL6_3124000_2316000 METAL6_3112000_2316000 0.024
R_VDD26_12183 METAL6_3112000_2316000 METAL6_3110900_2316000 0.0022
R_VDD26_12184 METAL6_3110900_2316000 METAL6_3100000_2316000 0.0218
R_VDD26_12185 METAL6_3100000_2316000 METAL6_3099200_2316000 0.0016
R_VDD26_12186 METAL6_3099200_2316000 METAL6_3098900_2316000 0.0006
R_VDD26_12187 METAL6_3098900_2316000 METAL6_3088000_2316000 0.0218
R_VDD26_12188 METAL6_3088000_2316000 METAL6_3087200_2316000 0.0016
R_VDD26_12189 METAL6_3087200_2316000 METAL6_3086900_2316000 0.0006
R_VDD26_12190 METAL6_3086900_2316000 METAL6_3076000_2316000 0.0218
R_VDD26_12191 METAL6_3076000_2316000 METAL6_3075200_2316000 0.0016
R_VDD26_12192 METAL6_3075200_2316000 METAL6_3068200_2316000 0.014
R_VDD26_12193 METAL6_3068200_2316000 METAL6_3064000_2316000 0.0084
R_VDD26_12194 METAL6_3064000_2316000 METAL6_3060600_2316000 0.0068
R_VDD26_12195 METAL6_3060600_2316000 METAL6_3052000_2316000 0.0172
R_VDD26_12196 METAL6_3052000_2316000 METAL6_3023200_2316000 0.0576
R_VDD26_12197 METAL6_3023200_2316000 METAL6_3012000_2316000 0.0224
R_VDD26_12198 METAL6_3012000_2316000 METAL6_3006200_2316000 0.0116
R_VDD26_12199 METAL6_3006200_2316000 METAL6_3000000_2316000 0.0124
R_VDD26_12200 METAL6_3000000_2316000 METAL6_2994200_2316000 0.0116
R_VDD26_12201 METAL6_2994200_2316000 METAL6_2993000_2316000 0.0024
R_VDD26_12202 METAL6_2993000_2316000 METAL6_2988000_2316000 0.01
R_VDD26_12203 METAL6_2988000_2316000 METAL6_2982200_2316000 0.0116
R_VDD26_12204 METAL6_2982200_2316000 METAL6_2975200_2316000 0.014
R_VDD26_12205 METAL6_2975200_2316000 METAL6_2965900_2316000 0.0186
R_VDD26_12206 METAL6_2965900_2316000 METAL6_2951900_2316000 0.028
R_VDD26_12207 METAL6_2951900_2316000 METAL6_2942200_2316000 0.0194
R_VDD26_12208 METAL6_2942200_2316000 METAL6_2930200_2316000 0.024
R_VDD26_12209 METAL6_2930200_2316000 METAL6_2925600_2316000 0.0092
R_VDD26_12210 METAL6_2925600_2316000 METAL6_2918200_2316000 0.0148
R_VDD26_12211 METAL6_2918200_2316000 METAL6_2913600_2316000 0.0092
R_VDD26_12212 METAL6_2913600_2316000 METAL6_2910900_2316000 0.0054
R_VDD26_12213 METAL6_2910900_2316000 METAL6_2901600_2316000 0.0186
R_VDD26_12214 METAL6_2901600_2316000 METAL6_2898900_2316000 0.0054
R_VDD26_12215 METAL6_2898900_2316000 METAL6_2897100_2316000 0.0036
R_VDD26_12216 METAL6_2897100_2316000 METAL6_2886900_2316000 0.0204
R_VDD26_12217 METAL6_2886900_2316000 METAL6_2874800_2316000 0.0242
R_VDD26_12218 METAL6_2874800_2316000 METAL6_2862800_2316000 0.024
R_VDD26_12219 METAL6_2862800_2316000 METAL6_2860600_2316000 0.0044
R_VDD26_12220 METAL6_2860600_2316000 METAL6_2850800_2316000 0.0196
R_VDD26_12221 METAL6_2850800_2316000 METAL6_2846600_2316000 0.0084
R_VDD26_12222 METAL6_2846600_2316000 METAL6_2843800_2316000 0.0056
R_VDD26_12223 METAL6_2843800_2316000 METAL6_2812000_2316000 0.0636
R_VDD26_12224 METAL6_2812000_2316000 METAL6_2805600_2316000 0.0128
R_VDD26_12225 METAL6_2805600_2316000 METAL6_2800000_2316000 0.0112
R_VDD26_12226 METAL6_2800000_2316000 METAL6_2798800_2316000 0.0024
R_VDD26_12227 METAL6_2798800_2316000 METAL6_2793600_2316000 0.0104
R_VDD26_12228 METAL6_2793600_2316000 METAL6_2788000_2316000 0.0112
R_VDD26_12229 METAL6_2788000_2316000 METAL6_2781600_2316000 0.0128
R_VDD26_12230 METAL6_2781600_2316000 METAL6_2765900_2316000 0.0314
R_VDD26_12231 METAL6_2765900_2316000 METAL6_2751900_2316000 0.028
R_VDD26_12232 METAL6_2751900_2316000 METAL6_2728200_2316000 0.0474
R_VDD26_12233 METAL6_2728200_2316000 METAL6_2710900_2316000 0.0346
R_VDD26_12234 METAL6_2710900_2316000 METAL6_2698900_2316000 0.024
R_VDD26_12235 METAL6_2698900_2316000 METAL6_2686900_2316000 0.024
R_VDD26_12236 METAL6_2686900_2316000 METAL6_2683200_2316000 0.0074
R_VDD26_12237 METAL6_2683200_2316000 METAL6_2676200_2316000 0.014
R_VDD26_12238 METAL6_2676200_2316000 METAL6_2664200_2316000 0.024
R_VDD26_12239 METAL6_2664200_2316000 METAL6_2660600_2316000 0.0072
R_VDD26_12240 METAL6_2660600_2316000 METAL6_2652200_2316000 0.0168
R_VDD26_12241 METAL6_2652200_2316000 METAL6_2646600_2316000 0.0112
R_VDD26_12242 METAL6_2646600_2316000 METAL6_2592400_2316000 0.1084
R_VDD26_12243 METAL6_2592400_2316000 METAL6_2580400_2316000 0.024
R_VDD26_12244 METAL6_2580400_2316000 METAL6_2568400_2316000 0.024
R_VDD26_12245 METAL6_2568400_2316000 METAL6_2565900_2316000 0.005
R_VDD26_12246 METAL6_2565900_2316000 METAL6_2556400_2316000 0.019
R_VDD26_12247 METAL6_2556400_2316000 METAL6_2551900_2316000 0.009
R_VDD26_12248 METAL6_2551900_2316000 METAL6_2537600_2316000 0.0286
R_VDD26_12249 METAL6_2537600_2316000 METAL6_2536000_2316000 0.0032
R_VDD26_12250 METAL6_2536000_2316000 METAL6_2535400_2316000 0.0012
R_VDD26_12251 METAL6_2535400_2316000 METAL6_2529000_2316000 0.0128
R_VDD26_12252 METAL6_2529000_2316000 METAL6_2528400_2316000 0.0012
R_VDD26_12253 METAL6_2528400_2316000 METAL6_2525600_2316000 0.0056
R_VDD26_12254 METAL6_2525600_2316000 METAL6_2524000_2316000 0.0032
R_VDD26_12255 METAL6_2524000_2316000 METAL6_2517000_2316000 0.014
R_VDD26_12256 METAL6_2517000_2316000 METAL6_2516400_2316000 0.0012
R_VDD26_12257 METAL6_2516400_2316000 METAL6_2513600_2316000 0.0056
R_VDD26_12258 METAL6_2513600_2316000 METAL6_2512000_2316000 0.0032
R_VDD26_12259 METAL6_2512000_2316000 METAL6_2510900_2316000 0.0022
R_VDD26_12260 METAL6_2510900_2316000 METAL6_2505000_2316000 0.0118
R_VDD26_12261 METAL6_2505000_2316000 METAL6_2504400_2316000 0.0012
R_VDD26_12262 METAL6_2504400_2316000 METAL6_2501600_2316000 0.0056
R_VDD26_12263 METAL6_2501600_2316000 METAL6_2500000_2316000 0.0032
R_VDD26_12264 METAL6_2500000_2316000 METAL6_2498900_2316000 0.0022
R_VDD26_12265 METAL6_2498900_2316000 METAL6_2493000_2316000 0.0118
R_VDD26_12266 METAL6_2493000_2316000 METAL6_2489600_2316000 0.0068
R_VDD26_12267 METAL6_2489600_2316000 METAL6_2488000_2316000 0.0032
R_VDD26_12268 METAL6_2488000_2316000 METAL6_2486900_2316000 0.0022
R_VDD26_12269 METAL6_2486900_2316000 METAL6_2481000_2316000 0.0118
R_VDD26_12270 METAL6_2481000_2316000 METAL6_2477600_2316000 0.0068
R_VDD26_12271 METAL6_2477600_2316000 METAL6_2476000_2316000 0.0032
R_VDD26_12272 METAL6_2476000_2316000 METAL6_2472600_2316000 0.0068
R_VDD26_12273 METAL6_2472600_2316000 METAL6_2469000_2316000 0.0072
R_VDD26_12274 METAL6_2469000_2316000 METAL6_2465600_2316000 0.0068
R_VDD26_12275 METAL6_2465600_2316000 METAL6_2464000_2316000 0.0032
R_VDD26_12276 METAL6_2464000_2316000 METAL6_2460600_2316000 0.0068
R_VDD26_12277 METAL6_2460600_2316000 METAL6_2448600_2316000 0.024
R_VDD26_12278 METAL6_2448600_2316000 METAL6_2446600_2316000 0.004
R_VDD26_12279 METAL6_2446600_2316000 METAL6_2436600_2316000 0.02
R_VDD26_12280 METAL6_2436600_2316000 METAL6_2419100_2316000 0.035
R_VDD26_12281 METAL6_2419100_2316000 METAL6_2407100_2316000 0.024
R_VDD26_12282 METAL6_2407100_2316000 METAL6_2405600_2316000 0.003
R_VDD26_12283 METAL6_2405600_2316000 METAL6_2402100_2316000 0.007
R_VDD26_12284 METAL6_2402100_2316000 METAL6_2395100_2316000 0.014
R_VDD26_12285 METAL6_2395100_2316000 METAL6_2393600_2316000 0.003
R_VDD26_12286 METAL6_2393600_2316000 METAL6_2383100_2316000 0.021
R_VDD26_12287 METAL6_2383100_2316000 METAL6_2381600_2316000 0.003
R_VDD26_12288 METAL6_2381600_2316000 METAL6_2371100_2316000 0.021
R_VDD26_12289 METAL6_2371100_2316000 METAL6_2369600_2316000 0.003
R_VDD26_12290 METAL6_2369600_2316000 METAL6_2365900_2316000 0.0074
R_VDD26_12291 METAL6_2365900_2316000 METAL6_2357600_2316000 0.0166
R_VDD26_12292 METAL6_2357600_2316000 METAL6_2351900_2316000 0.0114
R_VDD26_12293 METAL6_2351900_2316000 METAL6_2343700_2316000 0.0164
R_VDD26_12294 METAL6_2343700_2316000 METAL6_2310900_2316000 0.0656
R_VDD26_12295 METAL6_2310900_2316000 METAL6_2308600_2316000 0.0046
R_VDD26_12296 METAL6_2308600_2316000 METAL6_2298900_2316000 0.0194
R_VDD26_12297 METAL6_2298900_2316000 METAL6_2296600_2316000 0.0046
R_VDD26_12298 METAL6_2296600_2316000 METAL5_2296600_2316000 0.1
R_VDD26_12299 METAL5_2296600_2316000 METAL5_2286900_2316000 0.0388
R_VDD26_12300 METAL5_2286900_2316000 METAL5_2284600_2316000 0.0092
R_VDD26_12301 METAL5_2284600_2316000 METAL5_2284400_2316000 0.0008
R_VDD26_12302 METAL5_2284400_2316000 METAL5_2272600_2316000 0.0472
R_VDD26_12303 METAL5_2272600_2316000 METAL5_2272400_2316000 0.0008
R_VDD26_12304 METAL5_2272400_2316000 METAL5_2260600_2316000 0.0472
R_VDD26_12305 METAL5_2260600_2316000 METAL5_2260400_2316000 0.0008
R_VDD26_12306 METAL5_2260400_2316000 METAL5_2258600_2316000 0.0072
R_VDD26_12307 METAL5_2258600_2316000 METAL5_2248700_2316000 0.0396
R_VDD26_12308 METAL5_2248700_2316000 METAL5_2248600_2316000 0.0004
R_VDD26_12309 METAL5_2248600_2316000 METAL5_2248400_2316000 0.0008
R_VDD26_12310 METAL5_2248400_2316000 METAL5_2246600_2316000 0.0072
R_VDD26_12311 METAL5_2246600_2316000 METAL5_2236700_2316000 0.0396
R_VDD26_12312 METAL5_2236700_2316000 METAL5_2236600_2316000 0.0004
R_VDD26_12313 METAL5_2236600_2316000 METAL5_2234600_2316000 0.008
R_VDD26_12314 METAL5_2234600_2316000 METAL5_2233900_2316000 0.0028
R_VDD26_12315 METAL5_2233900_2316000 METAL5_2224700_2316000 0.0368
R_VDD26_12316 METAL5_2224700_2316000 METAL5_2222600_2316000 0.0084
R_VDD26_12317 METAL5_2222600_2316000 METAL5_2221900_2316000 0.0028
R_VDD26_12318 METAL5_2221900_2316000 METAL5_2212700_2316000 0.0368
R_VDD26_12319 METAL5_2212700_2316000 METAL5_2210600_2316000 0.0084
R_VDD26_12320 METAL5_2210600_2316000 METAL5_2209900_2316000 0.0028
R_VDD26_12321 METAL5_2209900_2316000 METAL5_2200700_2316000 0.0368
R_VDD26_12322 METAL5_2200700_2316000 METAL5_2189900_2316000 0.0432
R_VDD26_12323 METAL5_2189900_2316000 METAL5_2188700_2316000 0.0048
R_VDD26_12324 METAL5_2188700_2316000 METAL5_2177900_2316000 0.0432
R_VDD26_12325 METAL5_2177900_2316000 METAL5_2176700_2316000 0.0048
R_VDD26_12326 METAL5_2176700_2316000 METAL5_2165900_2316000 0.0432
R_VDD26_12327 METAL5_2165900_2316000 METAL5_2165400_2316000 0.002
R_VDD26_12328 METAL5_2165400_2316000 METAL5_2153900_2316000 0.046
R_VDD26_12329 METAL5_2153900_2316000 METAL5_2153400_2316000 0.002
R_VDD26_12330 METAL5_2153400_2316000 METAL5_2151900_2316000 0.006
R_VDD26_12331 METAL5_2151900_2316000 METAL5_2141900_2316000 0.04
R_VDD26_12332 METAL5_2141900_2316000 METAL5_2141400_2316000 0.002
R_VDD26_12333 METAL5_2141400_2316000 METAL5_2129900_2316000 0.046
R_VDD26_12334 METAL5_2129900_2316000 METAL5_2129700_2316000 0.0008
R_VDD26_12335 METAL5_2129700_2316000 METAL5_2125600_2316000 0.0164
R_VDD26_12336 METAL5_2125600_2316000 METAL5_2121400_2316000 0.0168
R_VDD26_12337 METAL5_2121400_2316000 METAL5_2117900_2316000 0.014
R_VDD26_12338 METAL5_2117900_2316000 METAL6_2117900_2316000 0.1
R_VDD26_12339 METAL6_2117900_2316000 METAL6_2113900_2316000 0.008
R_VDD26_12340 METAL6_2113900_2316000 METAL6_2113600_2316000 0.0006
R_VDD26_12341 METAL6_2113600_2316000 METAL6_2101900_2316000 0.0234
R_VDD26_12342 METAL6_2101900_2316000 METAL6_2101600_2316000 0.0006
R_VDD26_12343 METAL6_2101600_2316000 METAL6_2089900_2316000 0.0234
R_VDD26_12344 METAL6_2089900_2316000 METAL6_2079700_2316000 0.0204
R_VDD26_12345 METAL6_2079700_2316000 METAL6_2077900_2316000 0.0036
R_VDD26_12346 METAL6_2077900_2316000 METAL6_2067700_2316000 0.0204
R_VDD26_12347 METAL6_2067700_2316000 METAL6_2060600_2316000 0.0142
R_VDD26_12348 METAL6_2060600_2316000 METAL6_2058800_2316000 0.0036
R_VDD26_12349 METAL6_2058800_2316000 METAL6_2055700_2316000 0.0062
R_VDD26_12350 METAL6_2055700_2316000 METAL6_2046800_2316000 0.0178
R_VDD26_12351 METAL6_2046800_2316000 METAL6_2046600_2316000 0.0004
R_VDD26_12352 METAL6_2046600_2316000 METAL6_2046400_2316000 0.0004
R_VDD26_12353 METAL6_2046400_2316000 METAL6_2043700_2316000 0.0054
R_VDD26_12354 METAL6_2043700_2316000 METAL6_2034800_2316000 0.0178
R_VDD26_12355 METAL6_2034800_2316000 METAL6_2031700_2316000 0.0062
R_VDD26_12356 METAL6_2031700_2316000 METAL6_2030900_2316000 0.0016
R_VDD26_12357 METAL6_2030900_2316000 METAL6_2026400_2316000 0.009
R_VDD26_12358 METAL6_2026400_2316000 METAL6_2021200_2316000 0.0104
R_VDD26_12359 METAL6_2021200_2316000 METAL6_2019700_2316000 0.003
R_VDD26_12360 METAL6_2019700_2316000 METAL6_2019700_2317000 0.002
R_VDD26_12361 METAL6_2019700_2317000 METAL6_2018900_2317000 0.0016
R_VDD26_12362 METAL6_2018900_2317000 METAL6_2014400_2317000 0.009
R_VDD26_12363 METAL6_2014400_2317000 METAL6_2012000_2317000 0.0048
R_VDD26_12364 METAL6_2012000_2317000 METAL6_2006900_2317000 0.0102
R_VDD26_12365 METAL6_2006900_2317000 METAL6_2002400_2317000 0.009
R_VDD26_12366 METAL6_2002400_2317000 METAL6_2000000_2317000 0.0048
R_VDD26_12367 METAL6_2000000_2317000 METAL6_1988000_2317000 0.024
R_VDD26_12368 METAL6_1988000_2317000 METAL6_1951900_2317000 0.0722
R_VDD26_12369 METAL6_1951900_2317000 METAL6_1951800_2317000 0.0002
R_VDD26_12370 METAL6_1951800_2317000 METAL6_1939800_2317000 0.024
R_VDD26_12371 METAL6_1939800_2317000 METAL6_1931200_2317000 0.0172
R_VDD26_12372 METAL6_1931200_2317000 METAL6_1927800_2317000 0.0068
R_VDD26_12373 METAL6_1927800_2317000 METAL6_1926200_2317000 0.0032
R_VDD26_12374 METAL6_1926200_2317000 METAL6_1925600_2317000 0.0012
R_VDD26_12375 METAL6_1925600_2317000 METAL6_1919200_2317000 0.0128
R_VDD26_12376 METAL6_1919200_2317000 METAL6_1913600_2317000 0.0112
R_VDD26_12377 METAL6_1913600_2317000 METAL6_1907400_2317000 0.0124
R_VDD26_12378 METAL6_1907400_2317000 METAL6_1907200_2317000 0.0004
R_VDD26_12379 METAL6_1907200_2317000 METAL6_1901600_2317000 0.0112
R_VDD26_12380 METAL6_1901600_2317000 METAL6_1900700_2317000 0.0018
R_VDD26_12381 METAL6_1900700_2317000 METAL6_1895200_2317000 0.011
R_VDD26_12382 METAL6_1895200_2317000 METAL6_1889600_2317000 0.0112
R_VDD26_12383 METAL6_1889600_2317000 METAL6_1889400_2317000 0.0004
R_VDD26_12384 METAL6_1889400_2317000 METAL6_1888700_2317000 0.0014
R_VDD26_12385 METAL6_1888700_2317000 METAL6_1883200_2317000 0.011
R_VDD26_12386 METAL6_1883200_2317000 METAL6_1883200_2326000 0.018
R_VDD26_12387 METAL6_1883200_2326000 METAL6_1877600_2326000 0.0112
R_VDD26_12388 METAL6_1877600_2326000 METAL6_1877600_2328000 0.004
R_VDD26_12389 METAL6_1877600_2328000 METAL6_1877600_2329000 0.002
R_VDD26_12390 METAL6_1877600_2329000 METAL6_1877400_2329000 0.0004
R_VDD26_12391 METAL6_1877400_2329000 METAL6_1876700_2329000 0.0014
R_VDD26_12392 METAL6_1876700_2329000 METAL6_1874700_2329000 0.004
R_VDD26_12393 METAL6_1874700_2329000 METAL6_1871200_2329000 0.007
R_VDD26_12394 METAL6_1871200_2329000 METAL6_1870600_2329000 0.0012
R_VDD26_12395 METAL6_1870600_2329000 METAL6_1865400_2329000 0.0104
R_VDD26_12396 METAL6_1865400_2329000 METAL6_1864700_2329000 0.0014
R_VDD26_12397 METAL6_1864700_2329000 METAL6_1859200_2329000 0.011
R_VDD26_12398 METAL6_1859200_2329000 METAL6_1859200_2338000 0.018
R_VDD26_12399 METAL6_1859200_2338000 METAL6_1858600_2338000 0.0012
R_VDD26_12400 METAL6_1858600_2338000 METAL6_1858400_2338000 0.0004
R_VDD26_12401 METAL6_1858400_2338000 METAL6_1853400_2338000 0.01
R_VDD26_12402 METAL6_1853400_2338000 METAL6_1853400_2340000 0.004
R_VDD26_12403 METAL6_1853400_2340000 METAL6_1853400_2341000 0.002
R_VDD26_12404 METAL6_1853400_2341000 METAL6_1852700_2341000 0.0014
R_VDD26_12405 METAL6_1852700_2341000 METAL6_1846800_2341000 0.0118
R_VDD26_12406 METAL6_1846800_2341000 METAL6_1846600_2341000 0.0004
R_VDD26_12407 METAL6_1846600_2341000 METAL6_1846400_2341000 0.0004
R_VDD26_12408 METAL6_1846400_2341000 METAL6_1844800_2341000 0.0032
R_VDD26_12409 METAL6_1844800_2341000 METAL6_1834600_2341000 0.0204
R_VDD26_12410 METAL6_1834600_2341000 METAL6_1834400_2341000 0.0004
R_VDD26_12411 METAL6_1834400_2341000 METAL6_1832800_2341000 0.0032
R_VDD26_12412 METAL6_1832800_2341000 METAL6_1822600_2341000 0.0204
R_VDD26_12413 METAL6_1822600_2341000 METAL6_1822400_2341000 0.0004
R_VDD26_12414 METAL6_1822400_2341000 METAL6_1820800_2341000 0.0032
R_VDD26_12415 METAL6_1820800_2341000 METAL6_1812000_2341000 0.0176
R_VDD26_12416 METAL6_1812000_2341000 METAL6_1800000_2341000 0.024
R_VDD26_12417 METAL6_1800000_2341000 METAL6_1788000_2341000 0.024
R_VDD26_12418 METAL6_1788000_2341000 METAL6_1755700_2341000 0.0646
R_VDD26_12419 METAL6_1755700_2341000 METAL6_1753800_2341000 0.0038
R_VDD26_12420 METAL6_1753800_2341000 METAL6_1751800_2341000 0.004
R_VDD26_12421 METAL6_1751800_2341000 METAL6_1751400_2341000 0.0008
R_VDD26_12422 METAL6_1751400_2341000 METAL6_1744000_2341000 0.0148
R_VDD26_12423 METAL6_1744000_2341000 METAL6_1743700_2341000 0.0006
R_VDD26_12424 METAL6_1743700_2341000 METAL6_1741800_2341000 0.0038
R_VDD26_12425 METAL6_1741800_2341000 METAL6_1739800_2341000 0.004
R_VDD26_12426 METAL6_1739800_2341000 METAL6_1731700_2341000 0.0162
R_VDD26_12427 METAL6_1731700_2341000 METAL6_1729800_2341000 0.0038
R_VDD26_12428 METAL6_1729800_2341000 METAL6_1727800_2341000 0.004
R_VDD26_12429 METAL6_1727800_2341000 METAL6_1719700_2341000 0.0162
R_VDD26_12430 METAL6_1719700_2341000 METAL6_1717800_2341000 0.0038
R_VDD26_12431 METAL6_1717800_2341000 METAL6_1710800_2341000 0.014
R_VDD26_12432 METAL6_1710800_2341000 METAL6_1707700_2341000 0.0062
R_VDD26_12433 METAL6_1707700_2341000 METAL6_1699000_2341000 0.0174
R_VDD26_12434 METAL6_1699000_2341000 METAL6_1692000_2341000 0.014
R_VDD26_12435 METAL6_1692000_2341000 METAL6_1680000_2341000 0.024
R_VDD26_12436 METAL6_1680000_2341000 METAL6_1670800_2341000 0.0184
R_VDD26_12437 METAL6_1670800_2341000 METAL6_1668000_2341000 0.0056
R_VDD26_12438 METAL6_1668000_2341000 METAL6_1658800_2341000 0.0184
R_VDD26_12439 METAL6_1658800_2341000 METAL6_1646800_2341000 0.024
R_VDD26_12440 METAL6_1646800_2341000 METAL6_1634800_2341000 0.024
R_VDD26_12441 METAL6_1634800_2341000 METAL6_1632800_2341000 0.004
R_VDD26_12442 METAL6_1632800_2341000 METAL6_1627800_2341000 0.01
R_VDD26_12443 METAL6_1627800_2341000 METAL6_1615800_2341000 0.024
R_VDD26_12444 METAL6_1615800_2341000 METAL6_1612700_2341000 0.0062
R_VDD26_12445 METAL6_1612700_2341000 METAL6_1612000_2341000 0.0014
R_VDD26_12446 METAL6_1612000_2341000 METAL6_1607900_2341000 0.0082
R_VDD26_12447 METAL6_1607900_2341000 METAL6_1603800_2341000 0.0082
R_VDD26_12448 METAL6_1603800_2341000 METAL6_1600700_2341000 0.0062
R_VDD26_12449 METAL6_1600700_2341000 METAL6_1600000_2341000 0.0014
R_VDD26_12450 METAL6_1600000_2341000 METAL6_1591800_2341000 0.0164
R_VDD26_12451 METAL6_1591800_2341000 METAL6_1591800_2350000 0.018
R_VDD26_12452 METAL6_1591800_2350000 METAL6_1588700_2350000 0.0062
R_VDD26_12453 METAL6_1588700_2350000 METAL6_1588700_2352000 0.004
R_VDD26_12454 METAL6_1588700_2352000 METAL6_1588700_2353000 0.002
R_VDD26_12455 METAL6_1588700_2353000 METAL6_1588000_2353000 0.0014
R_VDD26_12456 METAL6_1588000_2353000 METAL6_1576700_2353000 0.0226
R_VDD26_12457 METAL6_1576700_2353000 METAL6_1576000_2353000 0.0014
R_VDD26_12458 METAL6_1576000_2353000 METAL6_1574700_2353000 0.0026
R_VDD26_12459 METAL6_1574700_2353000 METAL6_1557000_2353000 0.0354
R_VDD26_12460 METAL6_1557000_2353000 METAL6_1555400_2353000 0.0032
R_VDD26_12461 METAL6_1555400_2353000 METAL6_1551800_2353000 0.0072
R_VDD26_12462 METAL6_1551800_2353000 METAL6_1539800_2353000 0.024
R_VDD26_12463 METAL6_1539800_2353000 METAL6_1527800_2353000 0.024
R_VDD26_12464 METAL6_1527800_2353000 METAL6_1512000_2353000 0.0316
R_VDD26_12465 METAL6_1512000_2353000 METAL6_1510400_2353000 0.0032
R_VDD26_12466 METAL6_1510400_2353000 METAL6_1503400_2353000 0.014
R_VDD26_12467 METAL6_1503400_2353000 METAL6_1500000_2353000 0.0068
R_VDD26_12468 METAL6_1500000_2353000 METAL6_1498300_2353000 0.0034
R_VDD26_12469 METAL6_1498300_2353000 METAL6_1491400_2353000 0.0138
R_VDD26_12470 METAL6_1491400_2353000 METAL6_1488000_2353000 0.0068
R_VDD26_12471 METAL6_1488000_2353000 METAL6_1479400_2353000 0.0172
R_VDD26_12472 METAL6_1479400_2353000 METAL6_1443700_2353000 0.0714
R_VDD26_12473 METAL6_1443700_2353000 METAL6_1432800_2353000 0.0218
R_VDD26_12474 METAL6_1432800_2353000 METAL6_1431700_2353000 0.0022
R_VDD26_12475 METAL6_1431700_2353000 METAL6_1424000_2353000 0.0154
R_VDD26_12476 METAL6_1424000_2353000 METAL6_1419700_2353000 0.0086
R_VDD26_12477 METAL6_1419700_2353000 METAL6_1412000_2353000 0.0154
R_VDD26_12478 METAL6_1412000_2353000 METAL6_1400000_2353000 0.024
R_VDD26_12479 METAL6_1400000_2353000 METAL6_1388000_2353000 0.024
R_VDD26_12480 METAL6_1388000_2353000 METAL6_1337000_2353000 0.102
R_VDD26_12481 METAL6_1337000_2353000 METAL6_1325000_2353000 0.024
R_VDD26_12482 METAL6_1325000_2353000 METAL6_1324000_2353000 0.002
R_VDD26_12483 METAL6_1324000_2353000 METAL6_1323800_2353000 0.0004
R_VDD26_12484 METAL6_1323800_2353000 METAL6_1313000_2353000 0.0216
R_VDD26_12485 METAL6_1313000_2353000 METAL6_1312000_2353000 0.002
R_VDD26_12486 METAL6_1312000_2353000 METAL6_1311800_2353000 0.0004
R_VDD26_12487 METAL6_1311800_2353000 METAL5_1311800_2353000 0.1
R_VDD26_12488 METAL5_1311800_2353000 METAL5_1301000_2353000 0.0432
R_VDD26_12489 METAL5_1301000_2353000 METAL5_1300000_2353000 0.004
R_VDD26_12490 METAL5_1300000_2353000 METAL5_1299800_2353000 0.0008
R_VDD26_12491 METAL5_1299800_2353000 METAL5_1289000_2353000 0.0432
R_VDD26_12492 METAL5_1289000_2353000 METAL5_1288000_2353000 0.004
R_VDD26_12493 METAL5_1288000_2353000 METAL5_1287800_2353000 0.0008
R_VDD26_12494 METAL5_1287800_2353000 METAL5_1286700_2353000 0.0044
R_VDD26_12495 METAL5_1286700_2353000 METAL5_1274700_2353000 0.048
R_VDD26_12496 METAL5_1274700_2353000 METAL5_1266800_2353000 0.0316
R_VDD26_12497 METAL5_1266800_2353000 METAL5_1262700_2353000 0.0164
R_VDD26_12498 METAL5_1262700_2353000 METAL5_1259800_2353000 0.0116
R_VDD26_12499 METAL5_1259800_2353000 METAL5_1258300_2353000 0.006
R_VDD26_12500 METAL5_1258300_2353000 METAL5_1254700_2353000 0.0144
R_VDD26_12501 METAL5_1254700_2353000 METAL5_1253300_2353000 0.0056
R_VDD26_12502 METAL5_1253300_2353000 METAL5_1247800_2353000 0.022
R_VDD26_12503 METAL5_1247800_2353000 METAL5_1246300_2353000 0.006
R_VDD26_12504 METAL5_1246300_2353000 METAL5_1242700_2353000 0.0144
R_VDD26_12505 METAL5_1242700_2353000 METAL5_1235800_2353000 0.0276
R_VDD26_12506 METAL5_1235800_2353000 METAL5_1234300_2353000 0.006
R_VDD26_12507 METAL5_1234300_2353000 METAL5_1230700_2353000 0.0144
R_VDD26_12508 METAL5_1230700_2353000 METAL5_1224000_2353000 0.0268
R_VDD26_12509 METAL5_1224000_2353000 METAL5_1223800_2353000 0.0008
R_VDD26_12510 METAL5_1223800_2353000 METAL5_1222300_2353000 0.006
R_VDD26_12511 METAL5_1222300_2353000 METAL5_1218700_2353000 0.0144
R_VDD26_12512 METAL5_1218700_2353000 METAL5_1216400_2353000 0.0092
R_VDD26_12513 METAL5_1216400_2353000 METAL5_1212000_2353000 0.0176
R_VDD26_12514 METAL5_1212000_2353000 METAL5_1210300_2353000 0.0068
R_VDD26_12515 METAL5_1210300_2353000 METAL5_1206700_2353000 0.0144
R_VDD26_12516 METAL5_1206700_2353000 METAL5_1204400_2353000 0.0092
R_VDD26_12517 METAL5_1204400_2353000 METAL5_1200000_2353000 0.0176
R_VDD26_12518 METAL5_1200000_2353000 METAL5_1198300_2353000 0.0068
R_VDD26_12519 METAL5_1198300_2353000 METAL6_1198300_2353000 0.1
R_VDD26_12520 METAL6_1198300_2353000 METAL6_1198300_2362000 0.018
R_VDD26_12521 METAL6_1198300_2362000 METAL6_1198300_2364000 0.004
R_VDD26_12522 METAL6_1198300_2364000 METAL6_1198300_2365000 0.002
R_VDD26_12523 METAL6_1198300_2365000 METAL6_1198300_2374000 0.018
R_VDD26_12524 METAL6_1198300_2374000 METAL6_1198300_2376000 0.004
R_VDD26_12525 METAL6_1198300_2376000 METAL6_1198300_2377000 0.002
R_VDD26_12526 METAL6_1198300_2377000 METAL6_1198300_2388000 0.022
R_VDD26_12527 METAL6_1198300_2388000 METAL6_1198300_2389000 0.002
R_VDD26_12528 METAL6_1198300_2389000 METAL6_1198300_2395000 0.012
R_VDD26_12529 METAL6_1198300_2395000 METAL6_1198300_2400000 0.01
R_VDD26_12530 METAL6_1198300_2400000 METAL6_1198300_2401000 0.002
R_VDD26_12531 METAL6_1198300_2401000 METAL6_1198300_2407000 0.012
R_VDD26_12532 METAL6_1198300_2407000 METAL6_1198300_2412000 0.01
R_VDD26_12533 METAL6_1198300_2412000 METAL6_1198300_2413000 0.002
R_VDD26_12534 METAL6_1198300_2413000 METAL6_1198300_2419000 0.012
R_VDD26_12535 METAL6_1198300_2419000 METAL6_1198300_2424000 0.01
R_VDD26_12536 METAL6_1198300_2424000 METAL6_1198300_2436000 0.024
R_VDD26_12537 METAL6_1198300_2436000 METAL6_1198300_2438000 0.004
R_VDD26_12538 METAL6_1198300_2438000 METAL6_1198300_2444000 0.012
R_VDD26_12539 METAL6_1198300_2444000 METAL6_1198300_2450000 0.012
R_VDD26_12540 METAL6_1198300_2450000 METAL6_1198300_2456000 0.012
R_VDD26_12541 METAL6_1198300_2456000 METAL6_1198300_2462000 0.012
R_VDD26_12542 METAL6_1198300_2462000 METAL6_1198300_2468000 0.012
R_VDD26_12543 METAL6_1198300_2468000 METAL6_1198300_2481000 0.026
R_VDD26_12544 METAL6_1198300_2481000 METAL6_1198300_2493000 0.024
R_VDD26_12545 METAL6_1198300_2493000 METAL6_1198300_2505000 0.024
R_VDD26_12546 METAL6_1198300_2505000 METAL6_1198300_2512000 0.014
R_VDD26_12547 METAL6_1198300_2512000 METAL6_1198300_2517700 0.0114
R_VDD26_12548 METAL6_1198300_2517700 METAL6_1198300_2524000 0.0126
R_VDD26_12549 METAL6_1198300_2524000 METAL6_1198300_2529700 0.0114
R_VDD26_12550 METAL6_1198300_2529700 METAL6_1198300_2536000 0.0126
R_VDD26_12551 METAL6_1198300_2536000 METAL6_1198300_2541700 0.0114
R_VDD26_12552 METAL6_1198300_2541700 METAL6_1198300_2548000 0.0126
R_VDD26_12553 METAL6_1198300_2548000 METAL6_1198300_2553700 0.0114
R_VDD26_12554 METAL6_1198300_2553700 METAL6_1198300_2589000 0.0706
R_VDD26_12555 METAL6_1198300_2589000 METAL6_1198300_2603000 0.028
R_VDD26_12556 METAL6_1198300_2603000 METAL6_1198300_2644000 0.082
R_VDD26_12557 METAL6_1198300_2644000 METAL6_1198300_2656000 0.024
R_VDD26_12558 METAL6_1198300_2656000 METAL6_1198300_2665700 0.0194
R_VDD26_12559 METAL6_1198300_2665700 METAL6_1198300_2668000 0.0046
R_VDD26_12560 METAL6_1198300_2668000 METAL6_1198300_2701000 0.066
R_VDD26_12561 METAL6_1198300_2701000 METAL6_1198300_2701700 0.0014
R_VDD26_12562 METAL6_1198300_2701700 METAL6_1198300_2713000 0.0226
R_VDD26_12563 METAL6_1198300_2713000 METAL6_1198300_2713700 0.0014
R_VDD26_12564 METAL6_1198300_2713700 METAL6_1198300_2724000 0.0206
R_VDD26_12565 METAL6_1198300_2724000 METAL6_1198300_2725000 0.002
R_VDD26_12566 METAL6_1198300_2725000 METAL6_1198300_2725700 0.0014
R_VDD26_12567 METAL6_1198300_2725700 METAL6_1198300_2736000 0.0206
R_VDD26_12568 METAL6_1198300_2736000 METAL6_1198300_2737000 0.002
R_VDD26_12569 METAL6_1198300_2737000 METAL6_1198300_2748000 0.022
R_VDD26_12570 METAL6_1198300_2748000 METAL6_1198300_2777000 0.058
R_VDD26_12571 METAL6_1198300_2777000 METAL6_1198300_2789000 0.024
R_VDD26_12572 METAL6_1198300_2789000 METAL6_1198300_2801000 0.024
R_VDD26_12573 METAL6_1198300_2801000 METAL6_1198300_2801700 0.0014
R_VDD26_12574 METAL6_1198300_2801700 METAL6_1198300_2803000 0.0026
R_VDD26_12575 METAL6_1198300_2803000 METAL6_1198300_2808000 0.01
R_VDD26_12576 METAL6_1198300_2808000 METAL6_1198300_2813700 0.0114
R_VDD26_12577 METAL6_1198300_2813700 METAL6_1198300_2825700 0.024
R_VDD26_12578 METAL6_1198300_2825700 METAL6_1198300_2901700 0.152
R_VDD26_12579 METAL6_1198300_2901700 METAL6_1198300_2913000 0.0226
R_VDD26_12580 METAL6_1198300_2913000 METAL6_1198300_2913700 0.0014
R_VDD26_12581 METAL6_1198300_2913700 METAL6_1198300_2925000 0.0226
R_VDD26_12582 METAL6_1198300_2925000 METAL6_1198300_2925700 0.0014
R_VDD26_12583 METAL6_1198300_2925700 METAL6_1198300_2937000 0.0226
R_VDD26_12584 METAL6_1198300_2937000 METAL6_1198300_3001700 0.1294
R_VDD26_12585 METAL6_1198300_3001700 METAL6_1198300_3013700 0.024
R_VDD26_12586 METAL6_1198300_3013700 METAL6_1198300_3025700 0.024
R_VDD26_12587 METAL6_1198300_3025700 METAL6_1198300_3063000 0.0746
R_VDD26_12588 METAL6_1198300_3063000 METAL6_1198300_3075000 0.024
R_VDD26_12589 METAL6_1198300_3075000 METAL6_1198300_3085700 0.0214
R_VDD26_12590 METAL6_1198300_3085700 METAL6_1200000_3085700 0.0034
R_VDD26_12591 METAL6_1200000_3085700 METAL6_1204400_3085700 0.0088
R_VDD26_12592 METAL6_1204400_3085700 METAL6_1206700_3085700 0.0046
R_VDD26_12593 METAL6_1206700_3085700 METAL6_1210300_3085700 0.0072
R_VDD26_12594 METAL6_1210300_3085700 METAL6_1212000_3085700 0.0034
R_VDD26_12595 METAL6_1212000_3085700 METAL6_1216400_3085700 0.0088
R_VDD26_12596 METAL6_1216400_3085700 METAL6_1218700_3085700 0.0046
R_VDD26_12597 METAL6_1218700_3085700 METAL6_1222300_3085700 0.0072
R_VDD26_12598 METAL6_1222300_3085700 METAL6_1223800_3085700 0.003
R_VDD26_12599 METAL6_1223800_3085700 METAL6_1223800_3087000 0.0026
R_VDD26_12600 METAL6_1223800_3087000 METAL6_1223800_3097700 0.0214
R_VDD26_12601 METAL6_1223800_3097700 METAL6_1223800_3101700 0.008
R_VDD26_12602 METAL6_1223800_3101700 METAL6_1224000_3101700 0.0004
R_VDD26_12603 METAL6_1224000_3101700 METAL6_1230700_3101700 0.0134
R_VDD26_12604 METAL6_1230700_3101700 METAL6_1234300_3101700 0.0072
R_VDD26_12605 METAL6_1234300_3101700 METAL6_1234300_3109700 0.016
R_VDD26_12606 METAL6_1234300_3109700 METAL6_1234300_3113700 0.008
R_VDD26_12607 METAL6_1246300_3113700 METAL6_1234300_3113700 0.024
I_VDD26_43 METAL6_1246300_3113700 gnd 0.0022

V_VDD3_20 METAL6_1400000_0 gnd 1
R_VDD3_12608 METAL6_1400000_0 METAL6_1400000_9500 0.019
R_VDD3_12609 METAL6_1400000_9500 METAL6_1412000_9500 0.024
R_VDD3_12610 METAL6_1412000_9500 METAL6_1412000_21500 0.024
R_VDD3_12611 METAL6_1412000_21500 METAL6_1412000_52600 0.0622
R_VDD3_12612 METAL6_1412000_52600 METAL6_1412000_64600 0.024
R_VDD3_12613 METAL6_1412000_64600 METAL6_1412000_76600 0.024
R_VDD3_12614 METAL6_1412000_76600 METAL6_1419700_76600 0.0154
R_VDD3_12615 METAL6_1419700_76600 METAL6_1431700_76600 0.024
R_VDD3_12616 METAL6_1431700_76600 METAL6_1431700_83600 0.014
R_VDD3_12617 METAL6_1431700_83600 METAL6_1431700_88000 0.0088
R_VDD3_12618 METAL6_1431700_88000 METAL6_1431700_100000 0.024
R_VDD3_12619 METAL6_1431700_100000 METAL6_1431700_112000 0.024
R_VDD3_12620 METAL6_1431700_112000 METAL6_1431700_159600 0.0952
R_VDD3_12621 METAL6_1431700_159600 METAL6_1431700_166600 0.014
R_VDD3_12622 METAL6_1431700_166600 METAL6_1431700_178600 0.024
R_VDD3_12623 METAL6_1431700_178600 METAL6_1431700_188000 0.0188
R_VDD3_12624 METAL6_1431700_188000 METAL6_1431700_190600 0.0052
R_VDD3_12625 METAL6_1431700_190600 METAL6_1431700_200000 0.0188
R_VDD3_12626 METAL6_1431700_200000 METAL6_1431700_212000 0.024
R_VDD3_12627 METAL6_1431700_212000 METAL6_1431700_248300 0.0726
R_VDD3_12628 METAL6_1431700_248300 METAL6_1431700_260300 0.024
R_VDD3_12629 METAL6_1431700_260300 METAL6_1431700_263000 0.0054
R_VDD3_12630 METAL6_1431700_263000 METAL6_1431700_272300 0.0186
R_VDD3_12631 METAL6_1431700_272300 METAL6_1431700_275000 0.0054
R_VDD3_12632 METAL6_1431700_275000 METAL6_1431700_279300 0.0086
R_VDD3_12633 METAL6_1431700_279300 METAL6_1431700_287000 0.0154
R_VDD3_12634 METAL6_1431700_287000 METAL6_1432800_287000 0.0022
R_VDD3_12635 METAL6_1432800_287000 METAL6_1443700_287000 0.0218
R_VDD3_12636 METAL6_1443700_287000 METAL6_1479400_287000 0.0714
R_VDD3_12637 METAL6_1479400_287000 METAL6_1488000_287000 0.0172
R_VDD3_12638 METAL6_1488000_287000 METAL6_1491400_287000 0.0068
R_VDD3_12639 METAL6_1491400_287000 METAL6_1498300_287000 0.0138
R_VDD3_12640 METAL6_1498300_287000 METAL6_1500000_287000 0.0034
R_VDD3_12641 METAL6_1500000_287000 METAL6_1503400_287000 0.0068
R_VDD3_12642 METAL6_1503400_287000 METAL6_1510400_287000 0.014
R_VDD3_12643 METAL6_1510400_287000 METAL6_1512000_287000 0.0032
R_VDD3_12644 METAL6_1512000_287000 METAL6_1527800_287000 0.0316
R_VDD3_12645 METAL6_1527800_287000 METAL6_1539800_287000 0.024
R_VDD3_12646 METAL6_1539800_287000 METAL6_1551800_287000 0.024
R_VDD3_12647 METAL6_1551800_287000 METAL6_1555400_287000 0.0072
R_VDD3_12648 METAL6_1555400_287000 METAL6_1557000_287000 0.0032
R_VDD3_12649 METAL6_1557000_287000 METAL6_1574700_287000 0.0354
R_VDD3_12650 METAL6_1574700_287000 METAL6_1588000_287000 0.0266
R_VDD3_12651 METAL6_1588000_287000 METAL6_1588000_288000 0.002
R_VDD3_12652 METAL6_1588000_288000 METAL6_1588000_300000 0.024
R_VDD3_12653 METAL6_1588000_300000 METAL6_1588000_312000 0.024
R_VDD3_12654 METAL6_1588000_312000 METAL6_1588000_355300 0.0866
R_VDD3_12655 METAL6_1588000_355300 METAL6_1588000_362300 0.014
R_VDD3_12656 METAL6_1588000_362300 METAL6_1588000_374300 0.024
R_VDD3_12657 METAL6_1588000_374300 METAL6_1588000_386300 0.024
R_VDD3_12658 METAL6_1588000_386300 METAL6_1588000_388000 0.0034
R_VDD3_12659 METAL6_1588000_388000 METAL6_1588000_400000 0.024
R_VDD3_12660 METAL6_1588000_400000 METAL6_1588000_402800 0.0056
R_VDD3_12661 METAL6_1588000_402800 METAL6_1588000_412000 0.0184
R_VDD3_12662 METAL6_1588000_412000 METAL6_1588000_449000 0.074
R_VDD3_12663 METAL6_1588000_449000 METAL6_1588000_453000 0.008
R_VDD3_12664 METAL6_1588000_453000 METAL6_1588000_465000 0.024
R_VDD3_12665 METAL6_1588000_465000 METAL6_1588000_477000 0.024
R_VDD3_12666 METAL6_1588000_477000 METAL6_1588000_480400 0.0068
R_VDD3_12667 METAL6_1588000_480400 METAL6_1588000_488000 0.0152
R_VDD3_12668 METAL6_1588000_488000 METAL6_1588000_500000 0.024
R_VDD3_12669 METAL6_1588000_500000 METAL6_1588000_504000 0.008
R_VDD3_12670 METAL6_1588000_504000 METAL6_1588000_507000 0.006
R_VDD3_12671 METAL6_1588000_507000 METAL6_1588000_507800 0.0016
R_VDD3_12672 METAL6_1588000_507800 METAL6_1588000_512000 0.0084
R_VDD3_12673 METAL6_1588000_512000 METAL6_1588000_516000 0.008
R_VDD3_12674 METAL6_1588000_516000 METAL6_1588000_528000 0.024
R_VDD3_12675 METAL6_1588000_528000 METAL6_1588000_535400 0.0148
R_VDD3_12676 METAL6_1588000_535400 METAL6_1588000_544200 0.0176
R_VDD3_12677 METAL6_1588000_544200 METAL6_1588000_547400 0.0064
R_VDD3_12678 METAL6_1588000_547400 METAL6_1588000_559400 0.024
R_VDD3_12679 METAL6_1588000_559400 METAL6_1588000_573000 0.0272
R_VDD3_12680 METAL6_1588000_573000 METAL6_1588000_579800 0.0136
R_VDD3_12681 METAL6_1588000_579800 METAL6_1588000_586400 0.0132
R_VDD3_12682 METAL6_1588000_586400 METAL6_1588000_588000 0.0032
R_VDD3_12683 METAL6_1588000_588000 METAL6_1588000_600000 0.024
R_VDD3_12684 METAL6_1588000_600000 METAL6_1588000_612000 0.024
R_VDD3_12685 METAL6_1588000_612000 METAL6_1588000_637800 0.0516
R_VDD3_12686 METAL6_1588000_637800 METAL6_1588000_641400 0.0072
R_VDD3_12687 METAL6_1588000_641400 METAL6_1588000_649800 0.0168
R_VDD3_12688 METAL6_1588000_649800 METAL6_1588000_653400 0.0072
R_VDD3_12689 METAL6_1588000_653400 METAL6_1588000_661800 0.0168
R_VDD3_12690 METAL6_1588000_661800 METAL6_1588000_665400 0.0072
R_VDD3_12691 METAL6_1588000_665400 METAL6_1588000_688000 0.0452
R_VDD3_12692 METAL6_1588000_688000 METAL6_1588000_700000 0.024
R_VDD3_12693 METAL6_1588000_700000 METAL6_1588000_702800 0.0056
R_VDD3_12694 METAL6_1588000_702800 METAL6_1588000_709800 0.014
R_VDD3_12695 METAL6_1588000_709800 METAL6_1588000_712000 0.0044
R_VDD3_12696 METAL6_1588000_712000 METAL6_1588000_716800 0.0096
R_VDD3_12697 METAL6_1588000_716800 METAL6_1588000_721800 0.01
R_VDD3_12698 METAL6_1588000_721800 METAL6_1588000_733800 0.024
R_VDD3_12699 METAL6_1588000_733800 METAL6_1588000_735400 0.0032
R_VDD3_12700 METAL6_1588000_735400 METAL6_1588000_763000 0.0552
R_VDD3_12701 METAL6_1588000_763000 METAL6_1588000_772000 0.018
R_VDD3_12702 METAL6_1588000_772000 METAL6_1588000_779200 0.0144
R_VDD3_12703 METAL6_1588000_779200 METAL6_1588000_784500 0.0106
R_VDD3_12704 METAL6_1588000_784500 METAL6_1588000_788000 0.007
R_VDD3_12705 METAL6_1588000_788000 METAL6_1588000_790400 0.0048
R_VDD3_12706 METAL6_1588000_790400 METAL6_1588000_791200 0.0016
R_VDD3_12707 METAL6_1588000_791200 METAL6_1588000_794400 0.0064
R_VDD3_12708 METAL6_1588000_794400 METAL6_1588700_794400 0.0014
R_VDD3_12709 METAL6_1588700_794400 METAL6_1600000_794400 0.0226
R_VDD3_12710 METAL6_1600000_794400 METAL6_1607900_794400 0.0158
R_VDD3_12711 METAL6_1607900_794400 METAL6_1612000_794400 0.0082
R_VDD3_12712 METAL6_1612000_794400 METAL6_1615800_794400 0.0076
R_VDD3_12713 METAL6_1615800_794400 METAL6_1632800_794400 0.034
R_VDD3_12714 METAL6_1632800_794400 METAL6_1646800_794400 0.028
R_VDD3_12715 METAL6_1646800_794400 METAL6_1668000_794400 0.0424
R_VDD3_12716 METAL6_1668000_794400 METAL6_1680000_794400 0.024
R_VDD3_12717 METAL6_1680000_794400 METAL6_1692000_794400 0.024
R_VDD3_12718 METAL6_1692000_794400 METAL6_1699000_794400 0.014
R_VDD3_12719 METAL6_1699000_794400 METAL6_1707700_794400 0.0174
R_VDD3_12720 METAL6_1707700_794400 METAL6_1710800_794400 0.0062
R_VDD3_12721 METAL6_1710800_794400 METAL6_1717800_794400 0.014
R_VDD3_12722 METAL6_1717800_794400 METAL6_1719700_794400 0.0038
R_VDD3_12723 METAL6_1719700_794400 METAL6_1727800_794400 0.0162
R_VDD3_12724 METAL6_1727800_794400 METAL6_1729800_794400 0.004
R_VDD3_12725 METAL6_1729800_794400 METAL6_1731700_794400 0.0038
R_VDD3_12726 METAL6_1731700_794400 METAL6_1739800_794400 0.0162
R_VDD3_12727 METAL6_1739800_794400 METAL6_1741800_794400 0.004
R_VDD3_12728 METAL6_1741800_794400 METAL6_1743700_794400 0.0038
R_VDD3_12729 METAL6_1743700_794400 METAL6_1743700_794800 0.0008
R_VDD3_12730 METAL6_1743700_794800 METAL6_1743700_800000 0.0104
R_VDD3_12731 METAL6_1743700_800000 METAL6_1743700_802400 0.0048
R_VDD3_12732 METAL6_1743700_802400 METAL6_1743700_803200 0.0016
R_VDD3_12733 METAL6_1743700_803200 METAL6_1743700_808000 0.0096
R_VDD3_12734 METAL6_1743700_808000 METAL6_1743700_812000 0.008
R_VDD3_12735 METAL6_1743700_812000 METAL6_1743700_814400 0.0048
R_VDD3_12736 METAL6_1743700_814400 METAL6_1743700_820000 0.0112
R_VDD3_12737 METAL6_1743700_820000 METAL6_1743700_832000 0.024
R_VDD3_12738 METAL6_1743700_832000 METAL6_1743700_839500 0.015
R_VDD3_12739 METAL6_1743700_839500 METAL6_1743700_840700 0.0024
R_VDD3_12740 METAL6_1743700_840700 METAL6_1743700_851500 0.0216
R_VDD3_12741 METAL6_1743700_851500 METAL6_1743700_858200 0.0134
R_VDD3_12742 METAL6_1743700_858200 METAL6_1743700_863500 0.0106
R_VDD3_12743 METAL6_1743700_863500 METAL6_1743700_887000 0.047
R_VDD3_12744 METAL6_1743700_887000 METAL6_1743700_888000 0.002
R_VDD3_12745 METAL6_1743700_888000 METAL6_1743700_900000 0.024
R_VDD3_12746 METAL6_1743700_900000 METAL6_1743700_900400 0.0008
R_VDD3_12747 METAL6_1743700_900400 METAL6_1743700_912000 0.0232
R_VDD3_12748 METAL6_1743700_912000 METAL6_1743700_927300 0.0306
R_VDD3_12749 METAL6_1743700_927300 METAL6_1743700_959000 0.0634
R_VDD3_12750 METAL6_1743700_959000 METAL6_1743700_988000 0.058
R_VDD3_12751 METAL6_1743700_988000 METAL6_1743700_1000000 0.024
R_VDD3_12752 METAL6_1743700_1000000 METAL6_1743700_1007000 0.014
R_VDD3_12753 METAL6_1743700_1007000 METAL6_1743700_1012000 0.01
R_VDD3_12754 METAL6_1743700_1012000 METAL6_1743700_1014000 0.004
R_VDD3_12755 METAL6_1743700_1014000 METAL6_1743700_1019000 0.01
R_VDD3_12756 METAL6_1743700_1019000 METAL6_1743700_1026000 0.014
R_VDD3_12757 METAL6_1743700_1026000 METAL6_1743700_1029800 0.0076
R_VDD3_12758 METAL6_1743700_1029800 METAL6_1743700_1031000 0.0024
R_VDD3_12759 METAL6_1743700_1031000 METAL6_1743700_1035700 0.0094
R_VDD3_12760 METAL6_1743700_1035700 METAL6_1743700_1038000 0.0046
R_VDD3_12761 METAL6_1743700_1038000 METAL6_1743700_1041800 0.0076
R_VDD3_12762 METAL6_1743700_1041800 METAL6_1743700_1042700 0.0018
R_VDD3_12763 METAL6_1743700_1042700 METAL6_1743700_1049400 0.0134
R_VDD3_12764 METAL6_1743700_1049400 METAL6_1743700_1049800 0.0008
R_VDD3_12765 METAL6_1743700_1049800 METAL6_1743700_1053800 0.008
R_VDD3_12766 METAL6_1743700_1053800 METAL6_1743700_1054700 0.0018
R_VDD3_12767 METAL6_1743700_1054700 METAL6_1743700_1061800 0.0142
R_VDD3_12768 METAL6_1743700_1061800 METAL6_1743700_1066700 0.0098
R_VDD3_12769 METAL6_1743700_1066700 METAL6_1743700_1073800 0.0142
R_VDD3_12770 METAL6_1743700_1073800 METAL6_1743700_1086000 0.0244
R_VDD3_12771 METAL6_1743700_1086000 METAL6_1743700_1088000 0.004
R_VDD3_12772 METAL6_1743700_1088000 METAL6_1743700_1098500 0.021
R_VDD3_12773 METAL6_1743700_1098500 METAL6_1743700_1100000 0.003
R_VDD3_12774 METAL6_1743700_1100000 METAL6_1743700_1108800 0.0176
R_VDD3_12775 METAL6_1743700_1108800 METAL6_1743700_1112000 0.0064
R_VDD3_12776 METAL6_1743700_1112000 METAL6_1743700_1122300 0.0206
R_VDD3_12777 METAL6_1743700_1122300 METAL6_1744000_1122300 0.0006
R_VDD3_12778 METAL6_1744000_1122300 METAL6_1751400_1122300 0.0148
R_VDD3_12779 METAL6_1751400_1122300 METAL6_1751800_1122300 0.0008
R_VDD3_12780 METAL6_1751800_1122300 METAL6_1788000_1122300 0.0724
R_VDD3_12781 METAL6_1788000_1122300 METAL6_1800000_1122300 0.024
R_VDD3_12782 METAL6_1800000_1122300 METAL6_1812000_1122300 0.024
R_VDD3_12783 METAL6_1812000_1122300 METAL6_1832800_1122300 0.0416
R_VDD3_12784 METAL6_1832800_1122300 METAL6_1846400_1122300 0.0272
R_VDD3_12785 METAL6_1846400_1122300 METAL6_1846400_1129300 0.014
R_VDD3_12786 METAL6_1846400_1129300 METAL6_1846400_1141300 0.024
R_VDD3_12787 METAL6_1846400_1141300 METAL6_1846400_1153300 0.024
R_VDD3_12788 METAL6_1846400_1153300 METAL6_1846400_1160600 0.0146
R_VDD3_12789 METAL6_1846400_1160600 METAL6_1846400_1172600 0.024
R_VDD3_12790 METAL6_1846400_1172600 METAL6_1846400_1184600 0.024
R_VDD3_12791 METAL6_1846400_1184600 METAL6_1846400_1191600 0.014
R_VDD3_12792 METAL6_1846400_1191600 METAL6_1846400_1193800 0.0044
R_VDD3_12793 METAL6_1846400_1193800 METAL6_1846400_1217700 0.0478
R_VDD3_12794 METAL6_1846400_1217700 METAL6_1846400_1238000 0.0406
R_VDD3_12795 METAL6_1846400_1238000 METAL6_1846400_1247700 0.0194
R_VDD3_12796 METAL6_1846400_1247700 METAL6_1846400_1250000 0.0046
R_VDD3_12797 METAL6_1846400_1250000 METAL6_1846400_1259700 0.0194
R_VDD3_12798 METAL6_1846400_1259700 METAL6_1846400_1262000 0.0046
R_VDD3_12799 METAL6_1846400_1262000 METAL6_1846400_1271700 0.0194
R_VDD3_12800 METAL6_1846400_1271700 METAL6_1846400_1273000 0.0026
R_VDD3_12801 METAL6_1846400_1273000 METAL6_1846400_1326000 0.106
R_VDD3_12802 METAL6_1846400_1326000 METAL6_1846400_1338000 0.024
R_VDD3_12803 METAL6_1846400_1338000 METAL6_1846400_1350000 0.024
R_VDD3_12804 METAL6_1846400_1350000 METAL6_1846400_1362000 0.024
R_VDD3_12805 METAL6_1846400_1362000 METAL6_1846400_1374000 0.024
R_VDD3_12806 METAL6_1846400_1374000 METAL6_1846400_1381000 0.014
R_VDD3_12807 METAL6_1846400_1381000 METAL6_1846400_1386600 0.0112
R_VDD3_12808 METAL6_1846400_1386600 METAL6_1846400_1393000 0.0128
R_VDD3_12809 METAL6_1846400_1393000 METAL6_1846400_1405000 0.024
R_VDD3_12810 METAL6_1846400_1405000 METAL6_1846400_1437700 0.0654
R_VDD3_12811 METAL6_1846400_1437700 METAL6_1846400_1449700 0.024
R_VDD3_12812 METAL6_1846400_1449700 METAL6_1846400_1461700 0.024
R_VDD3_12813 METAL6_1846400_1461700 METAL6_1846400_1528300 0.1332
R_VDD3_12814 METAL6_1846400_1528300 METAL6_1846600_1528300 0.0004
R_VDD3_12815 METAL6_1846600_1528300 METAL6_1846800_1528300 0.0004
R_VDD3_12816 METAL6_1846800_1528300 METAL6_1853400_1528300 0.0132
R_VDD3_12817 METAL6_1853400_1528300 METAL6_1865400_1528300 0.024
R_VDD3_12818 METAL6_1865400_1528300 METAL6_1874700_1528300 0.0186
R_VDD3_12819 METAL6_1874700_1528300 METAL6_1876700_1528300 0.004
R_VDD3_12820 METAL6_1876700_1528300 METAL6_1877400_1528300 0.0014
R_VDD3_12821 METAL6_1877400_1528300 METAL6_1888700_1528300 0.0226
R_VDD3_12822 METAL6_1888700_1528300 METAL6_1895200_1528300 0.013
R_VDD3_12823 METAL6_1895200_1528300 METAL6_1900700_1528300 0.011
R_VDD3_12824 METAL6_1900700_1528300 METAL6_1901600_1528300 0.0018
R_VDD3_12825 METAL6_1901600_1528300 METAL6_1907200_1528300 0.0112
R_VDD3_12826 METAL6_1907200_1528300 METAL6_1907400_1528300 0.0004
R_VDD3_12827 METAL6_1907400_1528300 METAL6_1913600_1528300 0.0124
R_VDD3_12828 METAL6_1913600_1528300 METAL6_1919200_1528300 0.0112
R_VDD3_12829 METAL6_1919200_1528300 METAL6_1925600_1528300 0.0128
R_VDD3_12830 METAL6_1925600_1528300 METAL6_1926200_1528300 0.0012
R_VDD3_12831 METAL6_1926200_1528300 METAL6_1927800_1528300 0.0032
R_VDD3_12832 METAL6_1927800_1528300 METAL6_1939800_1528300 0.024
R_VDD3_12833 METAL6_1939800_1528300 METAL6_1951800_1528300 0.024
R_VDD3_12834 METAL6_1951800_1528300 METAL6_1951900_1528300 0.0002
R_VDD3_12835 METAL6_1951900_1528300 METAL6_1988000_1528300 0.0722
R_VDD3_12836 METAL6_1988000_1528300 METAL6_2000000_1528300 0.024
R_VDD3_12837 METAL6_2000000_1528300 METAL6_2002400_1528300 0.0048
R_VDD3_12838 METAL6_2002400_1528300 METAL6_2006900_1528300 0.009
R_VDD3_12839 METAL6_2006900_1528300 METAL6_2012000_1528300 0.0102
R_VDD3_12840 METAL6_2012000_1528300 METAL6_2014400_1528300 0.0048
R_VDD3_12841 METAL6_2014400_1528300 METAL6_2018900_1528300 0.009
R_VDD3_12842 METAL6_2018900_1528300 METAL6_2019700_1528300 0.0016
R_VDD3_12843 METAL6_2019700_1528300 METAL6_2021200_1528300 0.003
R_VDD3_12844 METAL6_2021200_1528300 METAL6_2026400_1528300 0.0104
R_VDD3_12845 METAL6_2026400_1528300 METAL6_2030900_1528300 0.009
R_VDD3_12846 METAL6_2030900_1528300 METAL6_2031700_1528300 0.0016
R_VDD3_12847 METAL6_2031700_1528300 METAL6_2043700_1528300 0.024
R_VDD3_12848 METAL6_2043700_1528300 METAL5_2043700_1528300 0.1
R_VDD3_12849 METAL5_2043700_1528300 METAL5_2043700_1540300 0.048
R_VDD3_12850 METAL5_2043700_1540300 METAL5_2043700_1552300 0.048
R_VDD3_12851 METAL5_2043700_1552300 METAL6_2043700_1552300 0.1
R_VDD3_12852 METAL6_2043700_1552300 METAL6_2046400_1552300 0.0054
R_VDD3_12853 METAL6_2046400_1552300 METAL6_2046600_1552300 0.0004
R_VDD3_12854 METAL6_2046600_1552300 METAL6_2046800_1552300 0.0004
R_VDD3_12855 METAL6_2046800_1552300 METAL6_2060600_1552300 0.0276
R_VDD3_12856 METAL6_2060600_1552300 METAL6_2077900_1552300 0.0346
R_VDD3_12857 METAL6_2077900_1552300 METAL6_2089900_1552300 0.024
R_VDD3_12858 METAL6_2089900_1552300 METAL6_2101600_1552300 0.0234
R_VDD3_12859 METAL6_2101600_1552300 METAL6_2101900_1552300 0.0006
R_VDD3_12860 METAL6_2101900_1552300 METAL6_2113600_1552300 0.0234
R_VDD3_12861 METAL6_2113600_1552300 METAL6_2121400_1552300 0.0156
R_VDD3_12862 METAL6_2121400_1552300 METAL6_2125600_1552300 0.0084
R_VDD3_12863 METAL6_2125600_1552300 METAL6_2129700_1552300 0.0082
R_VDD3_12864 METAL6_2129700_1552300 METAL6_2141400_1552300 0.0234
R_VDD3_12865 METAL6_2141400_1552300 METAL6_2151900_1552300 0.021
R_VDD3_12866 METAL6_2151900_1552300 METAL6_2153400_1552300 0.003
R_VDD3_12867 METAL6_2153400_1552300 METAL6_2165400_1552300 0.024
R_VDD3_12868 METAL6_2165400_1552300 METAL6_2165900_1552300 0.001
R_VDD3_12869 METAL6_2165900_1552300 METAL6_2188700_1552300 0.0456
R_VDD3_12870 METAL6_2188700_1552300 METAL6_2188700_1554500 0.0044
R_VDD3_12871 METAL6_2188700_1554500 METAL6_2188700_1564300 0.0196
R_VDD3_12872 METAL6_2188700_1564300 METAL6_2188700_1571300 0.014
R_VDD3_12873 METAL6_2188700_1571300 METAL6_2188700_1714500 0.2864
R_VDD3_12874 METAL6_2188700_1714500 METAL6_2188700_1720500 0.012
R_VDD3_12875 METAL6_2188700_1720500 METAL6_2188700_1726500 0.012
R_VDD3_12876 METAL6_2188700_1726500 METAL6_2188700_1731700 0.0104
R_VDD3_12877 METAL6_2188700_1731700 METAL6_2188700_1738500 0.0136
R_VDD3_12878 METAL6_2188700_1738500 METAL6_2188700_1750500 0.024
R_VDD3_12879 METAL6_2188700_1750500 METAL6_2188700_1762500 0.024
R_VDD3_12880 METAL6_2188700_1762500 METAL6_2188700_1774500 0.024
R_VDD3_12881 METAL6_2188700_1774500 METAL6_2188700_1814500 0.08
R_VDD3_12882 METAL6_2188700_1814500 METAL6_2188700_1826500 0.024
R_VDD3_12883 METAL6_2188700_1826500 METAL6_2188700_1838500 0.024
R_VDD3_12884 METAL6_2188700_1838500 METAL6_2188700_1852300 0.0276
R_VDD3_12885 METAL6_2188700_1852300 METAL6_2188700_1866300 0.028
R_VDD3_12886 METAL6_2188700_1866300 METAL6_2188700_1914500 0.0964
R_VDD3_12887 METAL6_2188700_1914500 METAL6_2188700_1926500 0.024
R_VDD3_12888 METAL6_2188700_1926500 METAL6_2188700_1938500 0.024
R_VDD3_12889 METAL6_2188700_1938500 METAL6_2188700_1940500 0.004
R_VDD3_12890 METAL6_2188700_1940500 METAL6_2188700_1952500 0.024
R_VDD3_12891 METAL6_2188700_1952500 METAL6_2188700_1963000 0.021
R_VDD3_12892 METAL6_2188700_1963000 METAL6_2188700_1964500 0.003
R_VDD3_12893 METAL6_2188700_1964500 METAL6_2188700_1975000 0.021
R_VDD3_12894 METAL6_2188700_1975000 METAL6_2188700_1976500 0.003
R_VDD3_12895 METAL6_2188700_1976500 METAL6_2188700_1987000 0.021
R_VDD3_12896 METAL6_2188700_1987000 METAL6_2188700_2014500 0.055
R_VDD3_12897 METAL6_2188700_2014500 METAL6_2188700_2026500 0.024
R_VDD3_12898 METAL6_2188700_2026500 METAL6_2188700_2038500 0.024
R_VDD3_12899 METAL6_2188700_2038500 METAL6_2188700_2114500 0.152
R_VDD3_12900 METAL6_2188700_2114500 METAL6_2188700_2126500 0.024
R_VDD3_12901 METAL6_2188700_2126500 METAL6_2188700_2138500 0.024
R_VDD3_12902 METAL6_2188700_2138500 METAL6_2188700_2147300 0.0176
R_VDD3_12903 METAL6_2188700_2147300 METAL6_2188700_2154300 0.014
R_VDD3_12904 METAL6_2188700_2154300 METAL6_2188700_2163000 0.0174
R_VDD3_12905 METAL6_2188700_2163000 METAL6_2188700_2166300 0.0066
R_VDD3_12906 METAL6_2188700_2166300 METAL6_2165900_2166300 0.0456
R_VDD3_12907 METAL6_2165900_2166300 METAL6_2165900_2175000 0.0174
R_VDD3_12908 METAL6_2165900_2175000 METAL6_2165900_2178300 0.0066
R_VDD3_12909 METAL6_2165900_2178300 METAL6_2165900_2187000 0.0174
R_VDD3_12910 METAL6_2165900_2187000 METAL6_2165900_2190300 0.0066
R_VDD3_12911 METAL6_2165900_2190300 METAL6_2165900_2222500 0.0644
R_VDD3_12912 METAL6_2165900_2222500 METAL6_2165900_2234500 0.024
R_VDD3_12913 METAL6_2165900_2234500 METAL6_2165900_2246500 0.024
R_VDD3_12914 METAL6_2165900_2246500 METAL6_2165900_2268500 0.044
R_VDD3_12915 METAL6_2165900_2268500 METAL6_2165900_2288000 0.039
R_VDD3_12916 METAL6_2165900_2288000 METAL6_2165900_2300000 0.024
R_VDD3_12917 METAL6_2165900_2300000 METAL6_2165900_2312000 0.024
R_VDD3_12918 METAL6_2165900_2312000 METAL6_2165900_2338000 0.052
R_VDD3_12919 METAL6_2165900_2338000 METAL6_2165900_2350000 0.024
R_VDD3_12920 METAL6_2165900_2350000 METAL6_2165900_2362000 0.024
R_VDD3_12921 METAL6_2165900_2362000 METAL6_2165900_2377000 0.03
R_VDD3_12922 METAL6_2165900_2377000 METAL6_2165900_2388000 0.022
R_VDD3_12923 METAL6_2165900_2388000 METAL6_2165900_2389000 0.002
R_VDD3_12924 METAL6_2165900_2389000 METAL6_2165900_2400000 0.022
R_VDD3_12925 METAL6_2165900_2400000 METAL6_2165900_2401000 0.002
R_VDD3_12926 METAL6_2165900_2401000 METAL6_2165900_2407000 0.012
R_VDD3_12927 METAL6_2165900_2407000 METAL6_2165900_2412000 0.01
R_VDD3_12928 METAL6_2165900_2412000 METAL6_2165900_2438000 0.052
R_VDD3_12929 METAL6_2165900_2438000 METAL6_2165900_2444000 0.012
R_VDD3_12930 METAL6_2165900_2444000 METAL6_2165900_2450000 0.012
R_VDD3_12931 METAL6_2165900_2450000 METAL6_2165900_2456000 0.012
R_VDD3_12932 METAL6_2165900_2456000 METAL6_2165900_2462000 0.012
R_VDD3_12933 METAL6_2165900_2462000 METAL6_2165900_2468000 0.012
R_VDD3_12934 METAL6_2165900_2468000 METAL6_2165900_2481000 0.026
R_VDD3_12935 METAL6_2165900_2481000 METAL6_2165900_2493000 0.024
R_VDD3_12936 METAL6_2165900_2493000 METAL6_2165900_2505000 0.024
R_VDD3_12937 METAL6_2165900_2505000 METAL6_2165900_2512000 0.014
R_VDD3_12938 METAL6_2165900_2512000 METAL6_2165900_2524000 0.024
R_VDD3_12939 METAL6_2165900_2524000 METAL6_2165900_2536000 0.024
R_VDD3_12940 METAL6_2165900_2536000 METAL6_2165900_2541700 0.0114
R_VDD3_12941 METAL6_2165900_2541700 METAL6_2165900_2548000 0.0126
R_VDD3_12942 METAL6_2165900_2548000 METAL6_2165900_2589000 0.082
R_VDD3_12943 METAL6_2165900_2589000 METAL6_2165900_2603000 0.028
R_VDD3_12944 METAL6_2165900_2603000 METAL6_2165900_2644000 0.082
R_VDD3_12945 METAL6_2165900_2644000 METAL6_2165900_2656000 0.024
R_VDD3_12946 METAL6_2165900_2656000 METAL6_2165900_2665700 0.0194
R_VDD3_12947 METAL6_2165900_2665700 METAL6_2165900_2668000 0.0046
R_VDD3_12948 METAL6_2165900_2668000 METAL6_2165900_2701700 0.0674
R_VDD3_12949 METAL6_2165900_2701700 METAL6_2165900_2713000 0.0226
R_VDD3_12950 METAL6_2165900_2713000 METAL6_2165900_2713700 0.0014
R_VDD3_12951 METAL6_2165900_2713700 METAL6_2165900_2724000 0.0206
R_VDD3_12952 METAL6_2165900_2724000 METAL6_2165900_2725000 0.002
R_VDD3_12953 METAL6_2165900_2725000 METAL6_2165900_2725700 0.0014
R_VDD3_12954 METAL6_2165900_2725700 METAL6_2165900_2736000 0.0206
R_VDD3_12955 METAL6_2165900_2736000 METAL6_2165900_2737000 0.002
R_VDD3_12956 METAL6_2165900_2737000 METAL6_2165900_2748000 0.022
R_VDD3_12957 METAL6_2165900_2748000 METAL6_2165900_2777000 0.058
R_VDD3_12958 METAL6_2165900_2777000 METAL6_2165900_2789000 0.024
R_VDD3_12959 METAL6_2165900_2789000 METAL6_2165400_2789000 0.001
R_VDD3_12960 METAL6_2165400_2789000 METAL6_2153400_2789000 0.024
R_VDD3_12961 METAL6_2153400_2789000 METAL6_2151900_2789000 0.003
R_VDD3_12962 METAL6_2151900_2789000 METAL6_2141400_2789000 0.021
R_VDD3_12963 METAL6_2141400_2789000 METAL6_2129700_2789000 0.0234
R_VDD3_12964 METAL6_2129700_2789000 METAL6_2125600_2789000 0.0082
R_VDD3_12965 METAL6_2125600_2789000 METAL6_2121400_2789000 0.0084
R_VDD3_12966 METAL6_2121400_2789000 METAL6_2113600_2789000 0.0156
R_VDD3_12967 METAL6_2113600_2789000 METAL6_2101900_2789000 0.0234
R_VDD3_12968 METAL6_2101900_2789000 METAL6_2101600_2789000 0.0006
R_VDD3_12969 METAL6_2101600_2789000 METAL6_2089900_2789000 0.0234
R_VDD3_12970 METAL6_2089900_2801000 METAL6_2089900_2789000 0.024
R_VDD3_12971 METAL6_695000_1061800 METAL6_707000_1061800 0.024
R_VDD3_12972 METAL6_1646800_794400 METAL6_1646800_794800 0.0008
R_VDD3_12973 METAL6_1646800_794800 METAL6_1646800_800000 0.0104
R_VDD3_12974 METAL6_1646800_800000 METAL6_1646800_802400 0.0048
R_VDD3_12975 METAL6_1646800_802400 METAL6_1646800_803200 0.0016
R_VDD3_12976 METAL6_1646800_803200 METAL6_1646800_806400 0.0064
R_VDD3_12977 METAL6_1646800_806400 METAL6_1632800_806400 0.028
R_VDD3_12978 METAL6_1632800_806400 METAL6_1615800_806400 0.034
R_VDD3_12979 METAL6_1615800_806400 METAL6_1612000_806400 0.0076
R_VDD3_12980 METAL6_1612000_806400 METAL6_1607900_806400 0.0082
R_VDD3_12981 METAL6_1607900_806400 METAL6_1600000_806400 0.0158
R_VDD3_12982 METAL6_1600000_806400 METAL6_1588700_806400 0.0226
R_VDD3_12983 METAL6_1588700_806400 METAL6_1588700_808000 0.0032
R_VDD3_12984 METAL6_1588700_808000 METAL6_1588700_812000 0.008
R_VDD3_12985 METAL6_1588700_812000 METAL6_1588700_814400 0.0048
R_VDD3_12986 METAL6_1588700_814400 METAL6_1588700_820000 0.0112
R_VDD3_12987 METAL6_1588700_820000 METAL6_1588700_832000 0.024
R_VDD3_12988 METAL6_1588700_832000 METAL6_1588700_839500 0.015
R_VDD3_12989 METAL6_1588700_839500 METAL6_1588700_840700 0.0024
R_VDD3_12990 METAL6_1588700_840700 METAL6_1588700_851500 0.0216
R_VDD3_12991 METAL6_1588700_851500 METAL6_1588700_858200 0.0134
R_VDD3_12992 METAL6_1588700_858200 METAL6_1588700_863500 0.0106
R_VDD3_12993 METAL6_1588700_863500 METAL6_1588700_887000 0.047
R_VDD3_12994 METAL6_1588700_887000 METAL6_1588700_888000 0.002
R_VDD3_12995 METAL6_1588700_888000 METAL6_1588700_900000 0.024
R_VDD3_12996 METAL6_1588700_900000 METAL6_1588000_900000 0.0014
R_VDD3_12997 METAL6_1588000_900000 METAL6_1576000_900000 0.024
R_VDD3_12998 METAL6_1576000_900000 METAL6_1574700_900000 0.0026
R_VDD3_12999 METAL6_1574700_900000 METAL6_1557000_900000 0.0354
R_VDD3_13000 METAL6_1557000_900000 METAL6_1555400_900000 0.0032
R_VDD3_13001 METAL6_1555400_900000 METAL6_1551800_900000 0.0072
R_VDD3_13002 METAL6_1551800_900000 METAL6_1539800_900000 0.024
R_VDD3_13003 METAL6_1539800_900000 METAL6_1527800_900000 0.024
R_VDD3_13004 METAL6_1527800_900000 METAL6_1512000_900000 0.0316
R_VDD3_13005 METAL6_1512000_900000 METAL6_1510400_900000 0.0032
R_VDD3_13006 METAL6_1510400_900000 METAL6_1503400_900000 0.014
R_VDD3_13007 METAL6_1503400_900000 METAL6_1500000_900000 0.0068
R_VDD3_13008 METAL6_1500000_900000 METAL6_1498300_900000 0.0034
R_VDD3_13009 METAL6_1498300_900000 METAL6_1491400_900000 0.0138
R_VDD3_13010 METAL6_1491400_900000 METAL6_1488000_900000 0.0068
R_VDD3_13011 METAL6_1488000_900000 METAL6_1479400_900000 0.0172
R_VDD3_13012 METAL6_1479400_900000 METAL6_1443700_900000 0.0714
R_VDD3_13013 METAL6_1443700_900000 METAL6_1432800_900000 0.0218
R_VDD3_13014 METAL6_1432800_900000 METAL6_1431700_900000 0.0022
R_VDD3_13015 METAL6_1431700_900000 METAL6_1424000_900000 0.0154
R_VDD3_13016 METAL6_1424000_900000 METAL6_1419700_900000 0.0086
R_VDD3_13017 METAL6_1419700_900000 METAL6_1412000_900000 0.0154
R_VDD3_13018 METAL6_1412000_900000 METAL6_1400000_900000 0.024
R_VDD3_13019 METAL6_1400000_900000 METAL6_1388000_900000 0.024
R_VDD3_13020 METAL6_1388000_900000 METAL6_1337000_900000 0.102
R_VDD3_13021 METAL6_1337000_900000 METAL6_1325000_900000 0.024
R_VDD3_13022 METAL6_1325000_900000 METAL6_1313000_900000 0.024
R_VDD3_13023 METAL6_1313000_900000 METAL6_1312000_900000 0.002
R_VDD3_13024 METAL6_1312000_900000 METAL6_1312000_900400 0.0008
R_VDD3_13025 METAL6_1312000_900400 METAL6_1312000_912000 0.0232
R_VDD3_13026 METAL6_1312000_912000 METAL6_1312000_927300 0.0306
R_VDD3_13027 METAL6_1312000_927300 METAL6_1312000_959000 0.0634
R_VDD3_13028 METAL6_1312000_959000 METAL6_1311800_959000 0.0004
R_VDD3_13029 METAL6_1311800_959000 METAL6_1301000_959000 0.0216
R_VDD3_13030 METAL6_1301000_959000 METAL6_1300000_959000 0.002
R_VDD3_13031 METAL6_1300000_959000 METAL6_1288000_959000 0.024
R_VDD3_13032 METAL6_1288000_959000 METAL6_1274700_959000 0.0266
R_VDD3_13033 METAL6_1274700_959000 METAL6_1266800_959000 0.0158
R_VDD3_13034 METAL6_1266800_959000 METAL6_1259800_959000 0.014
R_VDD3_13035 METAL6_1259800_959000 METAL6_1253300_959000 0.013
R_VDD3_13036 METAL6_1253300_959000 METAL6_1247800_959000 0.011
R_VDD3_13037 METAL6_1247800_959000 METAL6_1246300_959000 0.003
R_VDD3_13038 METAL6_1246300_959000 METAL6_1235800_959000 0.021
R_VDD3_13039 METAL6_1235800_959000 METAL6_1234300_959000 0.003
R_VDD3_13040 METAL6_1234300_959000 METAL6_1222300_959000 0.024
R_VDD3_13041 METAL6_1222300_959000 METAL6_1218700_959000 0.0072
R_VDD3_13042 METAL6_1218700_959000 METAL6_1212000_959000 0.0134
R_VDD3_13043 METAL6_1212000_959000 METAL6_1200000_959000 0.024
R_VDD3_13044 METAL6_1200000_959000 METAL6_1192400_959000 0.0152
R_VDD3_13045 METAL6_1192400_959000 METAL6_1188000_959000 0.0088
R_VDD3_13046 METAL6_1188000_959000 METAL6_1173700_959000 0.0286
R_VDD3_13047 METAL6_1173700_959000 METAL6_1166700_959000 0.014
R_VDD3_13048 METAL6_1166700_959000 METAL6_1154700_959000 0.024
R_VDD3_13049 METAL6_1154700_959000 METAL6_1154700_988000 0.058
R_VDD3_13050 METAL6_1154700_988000 METAL6_1142700_988000 0.024
R_VDD3_13051 METAL6_1142700_988000 METAL6_1142700_1000000 0.024
R_VDD3_13052 METAL6_1142700_1000000 METAL6_1142700_1007000 0.014
R_VDD3_13053 METAL6_1142700_1007000 METAL6_1137000_1007000 0.0114
R_VDD3_13054 METAL6_1137000_1007000 METAL6_1125000_1007000 0.024
R_VDD3_13055 METAL6_1125000_1007000 METAL6_1113000_1007000 0.024
R_VDD3_13056 METAL6_1113000_1007000 METAL6_1019000_1007000 0.188
R_VDD3_13057 METAL6_1019000_1007000 METAL6_1007000_1007000 0.024
R_VDD3_13058 METAL6_1007000_1007000 METAL6_995000_1007000 0.024
R_VDD3_13059 METAL6_995000_1007000 METAL6_988000_1007000 0.014
R_VDD3_13060 METAL6_988000_1007000 METAL6_947400_1007000 0.0812
R_VDD3_13061 METAL6_947400_1007000 METAL6_940400_1007000 0.014
R_VDD3_13062 METAL6_940400_1007000 METAL6_928400_1007000 0.024
R_VDD3_13063 METAL6_928400_1007000 METAL6_916400_1007000 0.024
R_VDD3_13064 METAL6_916400_1007000 METAL6_719000_1007000 0.3948
R_VDD3_13065 METAL6_719000_1007000 METAL6_707000_1007000 0.024
R_VDD3_13066 METAL6_707000_1007000 METAL6_707000_1012000 0.01
R_VDD3_13067 METAL6_707000_1012000 METAL6_707000_1014000 0.004
R_VDD3_13068 METAL6_707000_1014000 METAL6_707000_1019000 0.01
R_VDD3_13069 METAL6_707000_1019000 METAL6_707000_1026000 0.014
R_VDD3_13070 METAL6_707000_1026000 METAL6_707000_1029800 0.0076
R_VDD3_13071 METAL6_707000_1029800 METAL6_707000_1031000 0.0024
R_VDD3_13072 METAL6_707000_1031000 METAL6_707000_1035700 0.0094
R_VDD3_13073 METAL6_707000_1035700 METAL6_707000_1038000 0.0046
R_VDD3_13074 METAL6_707000_1038000 METAL6_707000_1041800 0.0076
R_VDD3_13075 METAL6_707000_1041800 METAL6_707000_1042700 0.0018
R_VDD3_13076 METAL6_707000_1042700 METAL6_707000_1049400 0.0134
R_VDD3_13077 METAL6_707000_1049400 METAL6_707000_1049800 0.0008
R_VDD3_13078 METAL6_707000_1049800 METAL6_707000_1053800 0.008
R_VDD3_13079 METAL6_707000_1053800 METAL6_707000_1054700 0.0018
R_VDD3_13080 METAL6_707000_1054700 METAL6_707000_1061800 0.0142
R_VDD3_13081 METAL5_2395100_3097700 METAL5_2393600_3097700 0.006
R_VDD3_13082 METAL5_2393600_3097700 METAL5_2383100_3097700 0.042
R_VDD3_13083 METAL6_1588000_516000 METAL6_1588700_516000 0.0014
R_VDD3_13084 METAL6_1588700_516000 METAL6_1600000_516000 0.0226
R_VDD3_13085 METAL6_1600000_516000 METAL6_1600000_528000 0.024
R_VDD3_13086 METAL6_1600000_528000 METAL6_1600000_535400 0.0148
R_VDD3_13087 METAL6_1600000_535400 METAL6_1600000_544200 0.0176
R_VDD3_13088 METAL6_1600000_544200 METAL6_1600000_547400 0.0064
R_VDD3_13089 METAL6_1600000_547400 METAL6_1600000_559400 0.024
R_VDD3_13090 METAL6_1600000_559400 METAL6_1600000_573000 0.0272
R_VDD3_13091 METAL6_1600000_573000 METAL6_1600000_579800 0.0136
R_VDD3_13092 METAL6_1600000_579800 METAL6_1600000_586400 0.0132
R_VDD3_13093 METAL6_1600000_586400 METAL6_1600000_588000 0.0032
R_VDD3_13094 METAL6_1600000_588000 METAL6_1600000_600000 0.024
R_VDD3_13095 METAL6_1600000_600000 METAL6_1600000_612000 0.024
R_VDD3_13096 METAL6_1600000_612000 METAL6_1600000_637800 0.0516
R_VDD3_13097 METAL6_1600000_637800 METAL6_1600000_641400 0.0072
R_VDD3_13098 METAL6_1600000_641400 METAL6_1600000_649800 0.0168
R_VDD3_13099 METAL6_1600000_649800 METAL6_1600000_653400 0.0072
R_VDD3_13100 METAL6_1600000_653400 METAL6_1600000_661800 0.0168
R_VDD3_13101 METAL6_1600000_661800 METAL6_1600000_665400 0.0072
R_VDD3_13102 METAL6_1600000_665400 METAL6_1600000_688000 0.0452
R_VDD3_13103 METAL6_1600000_688000 METAL6_1600000_700000 0.024
R_VDD3_13104 METAL6_1600000_700000 METAL6_1600000_702800 0.0056
R_VDD3_13105 METAL6_1600000_702800 METAL6_1600000_709800 0.014
R_VDD3_13106 METAL6_1600000_709800 METAL6_1600000_712000 0.0044
R_VDD3_13107 METAL6_1600000_712000 METAL6_1600000_716800 0.0096
R_VDD3_13108 METAL6_1600000_716800 METAL6_1600000_721800 0.01
R_VDD3_13109 METAL6_1600000_721800 METAL6_1600000_733800 0.024
R_VDD3_13110 METAL6_1600000_733800 METAL6_1600000_735400 0.0032
R_VDD3_13111 METAL6_1600000_735400 METAL6_1600000_763000 0.0552
R_VDD3_13112 METAL6_1600000_763000 METAL6_1600000_772000 0.018
R_VDD3_13113 METAL6_1600000_772000 METAL6_1600000_779200 0.0144
R_VDD3_13114 METAL6_1600000_779200 METAL6_1600000_782400 0.0064
R_VDD3_13115 METAL6_1600000_782400 METAL6_1600700_782400 0.0014
R_VDD3_13116 METAL6_1600700_782400 METAL6_1607900_782400 0.0144
R_VDD3_13117 METAL6_1607900_782400 METAL6_1612000_782400 0.0082
R_VDD3_13118 METAL6_1612000_782400 METAL6_1615800_782400 0.0076
R_VDD3_13119 METAL6_1615800_782400 METAL6_1632800_782400 0.034
R_VDD3_13120 METAL6_1632800_782400 METAL6_1634800_782400 0.004
R_VDD3_13121 METAL6_1634800_782400 METAL6_1646800_782400 0.024
R_VDD3_13122 METAL6_1646800_782400 METAL6_1658800_782400 0.024
R_VDD3_13123 METAL6_1658800_782400 METAL6_1668000_782400 0.0184
R_VDD3_13124 METAL6_1668000_782400 METAL6_1680000_782400 0.024
R_VDD3_13125 METAL6_1680000_782400 METAL6_1692000_782400 0.024
R_VDD3_13126 METAL6_1692000_782400 METAL6_1699000_782400 0.014
R_VDD3_13127 METAL6_1699000_782400 METAL6_1707700_782400 0.0174
R_VDD3_13128 METAL6_1707700_782400 METAL6_1710800_782400 0.0062
R_VDD3_13129 METAL6_1710800_782400 METAL6_1717800_782400 0.014
R_VDD3_13130 METAL6_1717800_782400 METAL6_1719700_782400 0.0038
R_VDD3_13131 METAL6_1719700_782400 METAL6_1727800_782400 0.0162
R_VDD3_13132 METAL6_1727800_782400 METAL6_1729800_782400 0.004
R_VDD3_13133 METAL6_1729800_782400 METAL6_1731700_782400 0.0038
R_VDD3_13134 METAL6_1731700_782400 METAL6_1739800_782400 0.0162
R_VDD3_13135 METAL6_1739800_782400 METAL6_1741800_782400 0.004
R_VDD3_13136 METAL6_1741800_782400 METAL6_1743700_782400 0.0038
R_VDD3_13137 METAL6_1743700_782400 METAL6_1744000_782400 0.0006
R_VDD3_13138 METAL6_1744000_782400 METAL6_1751400_782400 0.0148
R_VDD3_13139 METAL6_1751400_782400 METAL6_1751800_782400 0.0008
R_VDD3_13140 METAL6_1751800_782400 METAL6_1755700_782400 0.0078
R_VDD3_13141 METAL6_1755700_782400 METAL6_1788000_782400 0.0646
R_VDD3_13142 METAL6_1788000_782400 METAL6_1800000_782400 0.024
R_VDD3_13143 METAL6_1800000_782400 METAL6_1812000_782400 0.024
R_VDD3_13144 METAL6_1812000_782400 METAL6_1832800_782400 0.0416
R_VDD3_13145 METAL6_1832800_782400 METAL6_1832800_784500 0.0042
R_VDD3_13146 METAL6_1832800_784500 METAL6_1832800_788000 0.007
R_VDD3_13147 METAL6_1832800_788000 METAL6_1832800_790400 0.0048
R_VDD3_13148 METAL6_1832800_790400 METAL6_1834400_790400 0.0032
R_VDD3_13149 METAL6_1834400_790400 METAL6_1846400_790400 0.024
R_VDD3_13150 METAL6_1846400_790400 METAL6_1846400_791200 0.0016
R_VDD3_13151 METAL6_1846400_791200 METAL6_1846400_794400 0.0064
R_VDD3_13152 METAL6_1846400_794400 METAL6_1846400_794800 0.0008
R_VDD3_13153 METAL6_1846400_794800 METAL6_1846400_800000 0.0104
R_VDD3_13154 METAL6_1846400_800000 METAL6_1846400_802400 0.0048
R_VDD3_13155 METAL6_1846400_802400 METAL6_1846400_803200 0.0016
R_VDD3_13156 METAL6_1846400_803200 METAL6_1846400_806400 0.0064
R_VDD3_13157 METAL6_1846400_806400 METAL6_1846400_808000 0.0032
R_VDD3_13158 METAL6_1846400_808000 METAL6_1846400_812000 0.008
R_VDD3_13159 METAL6_1846400_812000 METAL6_1846400_814400 0.0048
R_VDD3_13160 METAL6_1846400_814400 METAL6_1846400_818400 0.008
R_VDD3_13161 METAL6_1846400_818400 METAL6_1846400_820000 0.0032
R_VDD3_13162 METAL6_1846400_820000 METAL6_1846400_832000 0.024
R_VDD3_13163 METAL6_1846400_832000 METAL6_1846400_839500 0.015
R_VDD3_13164 METAL6_1846400_839500 METAL6_1846400_840700 0.0024
R_VDD3_13165 METAL6_1846400_840700 METAL6_1846400_851500 0.0216
R_VDD3_13166 METAL6_1846400_851500 METAL6_1846400_858200 0.0134
R_VDD3_13167 METAL6_1846400_858200 METAL6_1846400_863500 0.0106
R_VDD3_13168 METAL6_1846400_863500 METAL6_1846400_887000 0.047
R_VDD3_13169 METAL6_1846400_887000 METAL6_1846400_888000 0.002
R_VDD3_13170 METAL6_1846400_888000 METAL6_1846400_900000 0.024
R_VDD3_13171 METAL6_1846400_900000 METAL6_1846400_900400 0.0008
R_VDD3_13172 METAL6_1846400_900400 METAL6_1846400_912000 0.0232
R_VDD3_13173 METAL6_1846400_912000 METAL6_1846400_927300 0.0306
R_VDD3_13174 METAL6_1846400_927300 METAL6_1846400_947000 0.0394
R_VDD3_13175 METAL6_1846400_947000 METAL6_1846400_959000 0.024
R_VDD3_13176 METAL6_1846400_959000 METAL6_1846400_971000 0.024
R_VDD3_13177 METAL6_1846400_971000 METAL6_1846400_976000 0.01
R_VDD3_13178 METAL6_1846400_976000 METAL6_1846400_988000 0.024
R_VDD3_13179 METAL6_1846400_988000 METAL6_1846400_995000 0.014
R_VDD3_13180 METAL6_1846400_995000 METAL6_1846400_1000000 0.01
R_VDD3_13181 METAL6_1846400_1000000 METAL6_1846400_1007000 0.014
R_VDD3_13182 METAL6_1846400_1007000 METAL6_1846400_1012000 0.01
R_VDD3_13183 METAL6_1846400_1012000 METAL6_1846400_1014000 0.004
R_VDD3_13184 METAL6_1846400_1014000 METAL6_1846400_1019000 0.01
R_VDD3_13185 METAL6_1846400_1019000 METAL6_1846400_1026000 0.014
R_VDD3_13186 METAL6_1846400_1026000 METAL6_1846400_1029800 0.0076
R_VDD3_13187 METAL6_1846400_1029800 METAL6_1846400_1031000 0.0024
R_VDD3_13188 METAL6_1846400_1031000 METAL6_1846400_1035700 0.0094
R_VDD3_13189 METAL6_1846400_1035700 METAL6_1846400_1038000 0.0046
R_VDD3_13190 METAL6_1846400_1038000 METAL6_1846400_1041800 0.0076
R_VDD3_13191 METAL6_1846400_1041800 METAL6_1846400_1042700 0.0018
R_VDD3_13192 METAL6_1846400_1042700 METAL6_1846400_1049400 0.0134
R_VDD3_13193 METAL6_1846400_1049400 METAL6_1846400_1049800 0.0008
R_VDD3_13194 METAL6_1846400_1049800 METAL6_1846400_1053800 0.008
R_VDD3_13195 METAL6_1846400_1053800 METAL6_1846400_1054700 0.0018
R_VDD3_13196 METAL6_1846400_1054700 METAL6_1846400_1061800 0.0142
R_VDD3_13197 METAL6_1846400_1061800 METAL6_1846400_1066700 0.0098
R_VDD3_13198 METAL6_1846400_1066700 METAL6_1846400_1073800 0.0142
R_VDD3_13199 METAL6_1846400_1073800 METAL6_1846400_1086000 0.0244
R_VDD3_13200 METAL6_1846400_1086000 METAL6_1846400_1088000 0.004
R_VDD3_13201 METAL6_1846400_1088000 METAL6_1846400_1098500 0.021
R_VDD3_13202 METAL6_1846400_1098500 METAL6_1846400_1100000 0.003
R_VDD3_13203 METAL6_1846400_1100000 METAL6_1846400_1108800 0.0176
R_VDD3_13204 METAL6_1846400_1108800 METAL6_1846400_1110300 0.003
R_VDD3_13205 METAL6_1846400_1110300 METAL6_1846600_1110300 0.0004
R_VDD3_13206 METAL6_1846600_1110300 METAL6_1846800_1110300 0.0004
R_VDD3_13207 METAL6_1846800_1110300 METAL6_1853400_1110300 0.0132
R_VDD3_13208 METAL6_1853400_1110300 METAL6_1858400_1110300 0.01
R_VDD3_13209 METAL6_1858400_1110300 METAL6_1865400_1110300 0.014
R_VDD3_13210 METAL6_1865400_1110300 METAL6_1874700_1110300 0.0186
R_VDD3_13211 METAL6_1874700_1110300 METAL6_1876700_1110300 0.004
R_VDD3_13212 METAL6_1876700_1110300 METAL6_1876700_1112000 0.0034
R_VDD3_13213 METAL6_1876700_1112000 METAL6_1876700_1122300 0.0206
R_VDD3_13214 METAL6_1876700_1122300 METAL6_1876700_1129300 0.014
R_VDD3_13215 METAL6_1876700_1129300 METAL6_1876700_1134300 0.01
R_VDD3_13216 METAL6_1876700_1134300 METAL6_1876700_1141300 0.014
R_VDD3_13217 METAL6_1876700_1141300 METAL6_1876700_1153300 0.024
R_VDD3_13218 METAL6_1876700_1153300 METAL6_1876700_1160600 0.0146
R_VDD3_13219 METAL6_1876700_1160600 METAL6_1876700_1172600 0.024
R_VDD3_13220 METAL6_1876700_1172600 METAL6_1876700_1184600 0.024
R_VDD3_13221 METAL6_1876700_1184600 METAL6_1876700_1191600 0.014
R_VDD3_13222 METAL6_1876700_1191600 METAL6_1876700_1193800 0.0044
R_VDD3_13223 METAL6_1876700_1193800 METAL6_1876700_1217700 0.0478
R_VDD3_13224 METAL6_1876700_1217700 METAL6_1876700_1238000 0.0406
R_VDD3_13225 METAL6_1876700_1238000 METAL6_1876700_1247700 0.0194
R_VDD3_13226 METAL6_1876700_1247700 METAL6_1876700_1250000 0.0046
R_VDD3_13227 METAL6_1876700_1250000 METAL6_1876700_1259700 0.0194
R_VDD3_13228 METAL6_1876700_1259700 METAL6_1876700_1262000 0.0046
R_VDD3_13229 METAL6_1876700_1262000 METAL6_1876700_1271700 0.0194
R_VDD3_13230 METAL6_1876700_1271700 METAL6_1876700_1273000 0.0026
R_VDD3_13231 METAL6_1876700_1273000 METAL6_1876700_1326000 0.106
R_VDD3_13232 METAL6_1876700_1326000 METAL6_1876700_1338000 0.024
R_VDD3_13233 METAL6_1876700_1338000 METAL6_1876700_1350000 0.024
R_VDD3_13234 METAL6_1876700_1350000 METAL6_1876700_1362000 0.024
R_VDD3_13235 METAL6_1876700_1362000 METAL6_1876700_1374000 0.024
R_VDD3_13236 METAL6_1876700_1374000 METAL6_1876700_1381000 0.014
R_VDD3_13237 METAL6_1876700_1381000 METAL6_1876700_1386600 0.0112
R_VDD3_13238 METAL6_1876700_1386600 METAL6_1876700_1393000 0.0128
R_VDD3_13239 METAL6_1876700_1393000 METAL6_1876700_1405000 0.024
R_VDD3_13240 METAL6_1876700_1405000 METAL6_1876700_1437700 0.0654
R_VDD3_13241 METAL6_1876700_1437700 METAL6_1876700_1449700 0.024
R_VDD3_13242 METAL6_1876700_1449700 METAL6_1876700_1461700 0.024
R_VDD3_13243 METAL6_1876700_1461700 METAL6_1876700_1516300 0.1092
R_VDD3_13244 METAL6_1876700_1516300 METAL6_1877400_1516300 0.0014
R_VDD3_13245 METAL6_1877400_1516300 METAL6_1888700_1516300 0.0226
R_VDD3_13246 METAL6_1888700_1516300 METAL6_1895200_1516300 0.013
R_VDD3_13247 METAL6_1895200_1516300 METAL6_1900700_1516300 0.011
R_VDD3_13248 METAL6_1900700_1516300 METAL6_1901600_1516300 0.0018
R_VDD3_13249 METAL6_1901600_1516300 METAL6_1907200_1516300 0.0112
R_VDD3_13250 METAL6_1907200_1516300 METAL6_1907400_1516300 0.0004
R_VDD3_13251 METAL6_1907400_1516300 METAL6_1913600_1516300 0.0124
R_VDD3_13252 METAL6_1913600_1516300 METAL6_1919200_1516300 0.0112
R_VDD3_13253 METAL6_1919200_1516300 METAL6_1925600_1516300 0.0128
R_VDD3_13254 METAL6_1925600_1516300 METAL6_1926200_1516300 0.0012
R_VDD3_13255 METAL6_1926200_1516300 METAL6_1927800_1516300 0.0032
R_VDD3_13256 METAL6_1927800_1516300 METAL6_1939800_1516300 0.024
R_VDD3_13257 METAL6_1939800_1516300 METAL6_1951800_1516300 0.024
R_VDD3_13258 METAL6_1951800_1516300 METAL6_1951900_1516300 0.0002
R_VDD3_13259 METAL6_1951900_1516300 METAL6_1988000_1516300 0.0722
R_VDD3_13260 METAL6_1988000_1516300 METAL6_2000000_1516300 0.024
R_VDD3_13261 METAL6_2000000_1516300 METAL6_2002400_1516300 0.0048
R_VDD3_13262 METAL6_2002400_1516300 METAL6_2006900_1516300 0.009
R_VDD3_13263 METAL6_2006900_1516300 METAL6_2012000_1516300 0.0102
R_VDD3_13264 METAL6_2012000_1516300 METAL6_2014400_1516300 0.0048
R_VDD3_13265 METAL6_2014400_1516300 METAL6_2018900_1516300 0.009
R_VDD3_13266 METAL6_2018900_1516300 METAL6_2019700_1516300 0.0016
R_VDD3_13267 METAL6_2019700_1516300 METAL6_2021200_1516300 0.003
R_VDD3_13268 METAL6_2021200_1516300 METAL6_2026400_1516300 0.0104
R_VDD3_13269 METAL6_2026400_1516300 METAL6_2030900_1516300 0.009
R_VDD3_13270 METAL6_2030900_1516300 METAL6_2031700_1516300 0.0016
R_VDD3_13271 METAL6_2031700_1516300 METAL6_2043700_1516300 0.024
R_VDD3_13272 METAL6_2043700_1516300 METAL6_2046400_1516300 0.0054
R_VDD3_13273 METAL6_2046400_1516300 METAL6_2046600_1516300 0.0004
R_VDD3_13274 METAL6_2046600_1516300 METAL6_2046800_1516300 0.0004
R_VDD3_13275 METAL6_2046800_1516300 METAL6_2055700_1516300 0.0178
R_VDD3_13276 METAL6_2055700_1516300 METAL6_2055700_1528300 0.024
R_VDD3_13277 METAL6_2055700_1528300 METAL6_2060600_1528300 0.0098
R_VDD3_13278 METAL6_2060600_1528300 METAL6_2077900_1528300 0.0346
R_VDD3_13279 METAL6_2077900_1528300 METAL6_2089900_1528300 0.024
R_VDD3_13280 METAL6_2089900_1528300 METAL6_2101600_1528300 0.0234
R_VDD3_13281 METAL6_2101600_1528300 METAL6_2101900_1528300 0.0006
R_VDD3_13282 METAL6_2101900_1528300 METAL6_2113600_1528300 0.0234
R_VDD3_13283 METAL6_2113600_1528300 METAL6_2121400_1528300 0.0156
R_VDD3_13284 METAL6_2121400_1528300 METAL6_2125600_1528300 0.0084
R_VDD3_13285 METAL6_2125600_1528300 METAL6_2129700_1528300 0.0082
R_VDD3_13286 METAL6_2129700_1528300 METAL6_2141400_1528300 0.0234
R_VDD3_13287 METAL6_2141400_1528300 METAL6_2151900_1528300 0.021
R_VDD3_13288 METAL6_2151900_1528300 METAL6_2153400_1528300 0.003
R_VDD3_13289 METAL6_2153400_1528300 METAL6_2153900_1528300 0.001
R_VDD3_13290 METAL6_2153900_1528300 METAL6_2165400_1528300 0.023
R_VDD3_13291 METAL6_2165400_1528300 METAL6_2165900_1528300 0.001
R_VDD3_13292 METAL6_2165900_1528300 METAL6_2176700_1528300 0.0216
R_VDD3_13293 METAL6_2176700_1528300 METAL6_2177900_1528300 0.0024
R_VDD3_13294 METAL6_2177900_1528300 METAL6_2188700_1528300 0.0216
R_VDD3_13295 METAL6_2188700_1528300 METAL6_2200700_1528300 0.024
R_VDD3_13296 METAL6_2200700_1528300 METAL5_2200700_1528300 0.1
R_VDD3_13297 METAL5_2200700_1528300 METAL5_2200700_1540300 0.048
R_VDD3_13298 METAL5_2200700_1540300 METAL5_2200700_1552300 0.048
R_VDD3_13299 METAL5_2200700_1552300 METAL6_2200700_1552300 0.1
R_VDD3_13300 METAL6_2200700_1552300 METAL6_2221900_1552300 0.0424
R_VDD3_13301 METAL6_2221900_1552300 METAL6_2224700_1552300 0.0056
R_VDD3_13302 METAL6_2224700_1552300 METAL6_2236700_1552300 0.024
R_VDD3_13303 METAL6_2236700_1552300 METAL6_2246600_1552300 0.0198
R_VDD3_13304 METAL6_2246600_1552300 METAL6_2246600_1554500 0.0044
R_VDD3_13305 METAL6_2246600_1554500 METAL6_2246600_1564300 0.0196
R_VDD3_13306 METAL6_2246600_1564300 METAL6_2246600_1571300 0.014
R_VDD3_13307 METAL6_2246600_1571300 METAL6_2246600_1714500 0.2864
R_VDD3_13308 METAL6_2246600_1714500 METAL6_2246600_1720500 0.012
R_VDD3_13309 METAL6_2246600_1720500 METAL6_2246600_1726500 0.012
R_VDD3_13310 METAL6_2246600_1726500 METAL6_2246600_1731700 0.0104
R_VDD3_13311 METAL6_2246600_1731700 METAL6_2246600_1738500 0.0136
R_VDD3_13312 METAL6_2246600_1738500 METAL6_2246600_1750500 0.024
R_VDD3_13313 METAL6_2246600_1750500 METAL6_2246600_1762500 0.024
R_VDD3_13314 METAL6_2246600_1762500 METAL6_2246600_1774500 0.024
R_VDD3_13315 METAL6_2246600_1774500 METAL6_2246600_1814500 0.08
R_VDD3_13316 METAL6_2246600_1814500 METAL6_2246600_1826500 0.024
R_VDD3_13317 METAL6_2246600_1826500 METAL6_2246600_1838500 0.024
R_VDD3_13318 METAL6_2246600_1838500 METAL6_2246600_1852300 0.0276
R_VDD3_13319 METAL6_2246600_1852300 METAL6_2246600_1866300 0.028
R_VDD3_13320 METAL6_2246600_1866300 METAL6_2246600_1914500 0.0964
R_VDD3_13321 METAL6_2246600_1914500 METAL6_2246600_1926500 0.024
R_VDD3_13322 METAL6_2246600_1926500 METAL6_2246600_1938500 0.024
R_VDD3_13323 METAL6_2246600_1938500 METAL6_2248700_1938500 0.0042
R_VDD3_13324 METAL6_2248700_1938500 METAL6_2260400_1938500 0.0234
R_VDD3_13325 METAL6_2260400_1938500 METAL6_2260400_1940500 0.004
R_VDD3_13326 METAL6_2260400_1940500 METAL6_2260400_1952500 0.024
R_VDD3_13327 METAL6_2260400_1952500 METAL6_2260400_1963000 0.021
R_VDD3_13328 METAL6_2260400_1963000 METAL6_2260400_1964500 0.003
R_VDD3_13329 METAL6_2260400_1964500 METAL6_2260400_1975000 0.021
R_VDD3_13330 METAL6_2260400_1975000 METAL6_2260400_1976500 0.003
R_VDD3_13331 METAL6_2260400_1976500 METAL6_2260400_1987000 0.021
R_VDD3_13332 METAL6_2260400_1987000 METAL6_2260400_2014500 0.055
R_VDD3_13333 METAL6_2260400_2014500 METAL6_2260400_2026500 0.024
R_VDD3_13334 METAL6_2260400_2026500 METAL6_2260400_2038500 0.024
R_VDD3_13335 METAL6_2260400_2038500 METAL6_2260400_2114500 0.152
R_VDD3_13336 METAL6_2260400_2114500 METAL6_2260400_2126500 0.024
R_VDD3_13337 METAL6_2260400_2126500 METAL6_2260400_2138500 0.024
R_VDD3_13338 METAL6_2260400_2138500 METAL6_2260400_2147300 0.0176
R_VDD3_13339 METAL6_2260400_2147300 METAL6_2260400_2154300 0.014
R_VDD3_13340 METAL6_2260400_2154300 METAL6_2260400_2163000 0.0174
R_VDD3_13341 METAL6_2260400_2163000 METAL6_2260400_2166300 0.0066
R_VDD3_13342 METAL6_2260400_2166300 METAL6_2260400_2175000 0.0174
R_VDD3_13343 METAL6_2260400_2175000 METAL6_2260400_2178300 0.0066
R_VDD3_13344 METAL6_2260400_2178300 METAL6_2260400_2187000 0.0174
R_VDD3_13345 METAL6_2260400_2187000 METAL6_2260400_2190300 0.0066
R_VDD3_13346 METAL6_2260400_2190300 METAL6_2260400_2222500 0.0644
R_VDD3_13347 METAL6_2260400_2222500 METAL6_2260400_2234500 0.024
R_VDD3_13348 METAL6_2260400_2234500 METAL6_2260400_2246500 0.024
R_VDD3_13349 METAL6_2260400_2246500 METAL6_2260400_2268500 0.044
R_VDD3_13350 METAL6_2260400_2268500 METAL6_2260400_2288000 0.039
R_VDD3_13351 METAL6_2260400_2288000 METAL6_2260400_2300000 0.024
R_VDD3_13352 METAL6_2260400_2300000 METAL6_2260400_2312000 0.024
R_VDD3_13353 METAL6_2260400_2312000 METAL6_2260400_2338000 0.052
R_VDD3_13354 METAL6_2260400_2338000 METAL6_2260400_2350000 0.024
R_VDD3_13355 METAL6_2260400_2350000 METAL6_2260400_2362000 0.024
R_VDD3_13356 METAL6_2260400_2362000 METAL6_2260400_2377000 0.03
R_VDD3_13357 METAL6_2260400_2377000 METAL6_2260400_2388000 0.022
R_VDD3_13358 METAL6_2260400_2388000 METAL6_2260400_2389000 0.002
R_VDD3_13359 METAL6_2260400_2389000 METAL6_2260400_2400000 0.022
R_VDD3_13360 METAL6_2260400_2400000 METAL6_2260400_2401000 0.002
R_VDD3_13361 METAL6_2260400_2401000 METAL6_2260400_2407000 0.012
R_VDD3_13362 METAL6_2260400_2407000 METAL6_2260400_2412000 0.01
R_VDD3_13363 METAL6_2260400_2412000 METAL6_2260400_2438000 0.052
R_VDD3_13364 METAL6_2260400_2438000 METAL6_2260400_2444000 0.012
R_VDD3_13365 METAL6_2260400_2444000 METAL6_2260400_2450000 0.012
R_VDD3_13366 METAL6_2260400_2450000 METAL6_2260400_2456000 0.012
R_VDD3_13367 METAL6_2260400_2456000 METAL6_2260400_2462000 0.012
R_VDD3_13368 METAL6_2260400_2462000 METAL6_2260400_2468000 0.012
R_VDD3_13369 METAL6_2260400_2468000 METAL6_2260400_2481000 0.026
R_VDD3_13370 METAL6_2260400_2481000 METAL6_2260400_2493000 0.024
R_VDD3_13371 METAL6_2260400_2493000 METAL6_2260400_2505000 0.024
R_VDD3_13372 METAL6_2260400_2505000 METAL6_2260400_2512000 0.014
R_VDD3_13373 METAL6_2260400_2512000 METAL6_2260400_2524000 0.024
R_VDD3_13374 METAL6_2260400_2524000 METAL6_2260400_2536000 0.024
R_VDD3_13375 METAL6_2260400_2536000 METAL6_2260400_2541700 0.0114
R_VDD3_13376 METAL6_2260400_2541700 METAL6_2260400_2548000 0.0126
R_VDD3_13377 METAL6_2260400_2548000 METAL6_2260400_2589000 0.082
R_VDD3_13378 METAL6_2260400_2589000 METAL6_2260400_2603000 0.028
R_VDD3_13379 METAL6_2260400_2603000 METAL6_2260400_2644000 0.082
R_VDD3_13380 METAL6_2260400_2644000 METAL6_2260400_2656000 0.024
R_VDD3_13381 METAL6_2260400_2656000 METAL6_2260400_2665700 0.0194
R_VDD3_13382 METAL6_2260400_2665700 METAL6_2260400_2668000 0.0046
R_VDD3_13383 METAL6_2260400_2668000 METAL6_2260400_2701700 0.0674
R_VDD3_13384 METAL6_2260400_2701700 METAL6_2260400_2713000 0.0226
R_VDD3_13385 METAL6_2260400_2713000 METAL6_2260400_2713700 0.0014
R_VDD3_13386 METAL6_2260400_2713700 METAL6_2260400_2724000 0.0206
R_VDD3_13387 METAL6_2260400_2724000 METAL6_2260400_2725000 0.002
R_VDD3_13388 METAL6_2260400_2725000 METAL6_2260400_2725700 0.0014
R_VDD3_13389 METAL6_2260400_2725700 METAL6_2260400_2736000 0.0206
R_VDD3_13390 METAL6_2260400_2736000 METAL6_2260400_2737000 0.002
R_VDD3_13391 METAL6_2260400_2737000 METAL6_2260400_2748000 0.022
R_VDD3_13392 METAL6_2260400_2748000 METAL6_2260400_2777000 0.058
R_VDD3_13393 METAL6_2260400_2777000 METAL6_2260400_2789000 0.024
R_VDD3_13394 METAL6_2260400_2789000 METAL6_2260400_2801000 0.024
R_VDD3_13395 METAL6_2260400_2801000 METAL6_2260400_2801700 0.0014
R_VDD3_13396 METAL6_2260400_2801700 METAL6_2260400_2803000 0.0026
R_VDD3_13397 METAL6_2260400_2803000 METAL6_2260400_2808000 0.01
R_VDD3_13398 METAL6_2260400_2808000 METAL6_2260400_2813700 0.0114
R_VDD3_13399 METAL6_2260400_2813700 METAL6_2260400_2825700 0.024
R_VDD3_13400 METAL6_2260400_2825700 METAL6_2260400_2901700 0.152
R_VDD3_13401 METAL6_2260400_2901700 METAL6_2260400_2913000 0.0226
R_VDD3_13402 METAL6_2260400_2913000 METAL6_2260400_2913700 0.0014
R_VDD3_13403 METAL6_2260400_2913700 METAL6_2260400_2925000 0.0226
R_VDD3_13404 METAL6_2260400_2925000 METAL6_2260400_2925700 0.0014
R_VDD3_13405 METAL6_2260400_2925700 METAL6_2260400_2937000 0.0226
R_VDD3_13406 METAL6_2260400_2937000 METAL6_2260400_3001700 0.1294
R_VDD3_13407 METAL6_2260400_3001700 METAL6_2260400_3013700 0.024
R_VDD3_13408 METAL6_2260400_3013700 METAL6_2260400_3025700 0.024
R_VDD3_13409 METAL6_2260400_3025700 METAL6_2260400_3063000 0.0746
R_VDD3_13410 METAL6_2260400_3063000 METAL6_2260400_3075000 0.024
R_VDD3_13411 METAL6_2260400_3075000 METAL6_2260400_3085700 0.0214
R_VDD3_13412 METAL6_2260400_3085700 METAL6_2260400_3087000 0.0026
R_VDD3_13413 METAL6_2260400_3087000 METAL6_2260400_3097700 0.0214
R_VDD3_13414 METAL6_2260400_3097700 METAL6_2260600_3097700 0.0004
R_VDD3_13415 METAL6_2260600_3097700 METAL6_2286900_3097700 0.0526
R_VDD3_13416 METAL6_2286900_3097700 METAL6_2298900_3097700 0.024
R_VDD3_13417 METAL6_2298900_3097700 METAL6_2310900_3097700 0.024
R_VDD3_13418 METAL6_2310900_3097700 METAL6_2343700_3097700 0.0656
R_VDD3_13419 METAL6_2343700_3097700 METAL6_2351900_3097700 0.0164
R_VDD3_13420 METAL6_2351900_3097700 METAL6_2365900_3097700 0.028
R_VDD3_13421 METAL6_2365900_3097700 METAL6_2371100_3097700 0.0104
R_VDD3_13422 METAL6_2371100_3097700 METAL6_2381600_3097700 0.021
R_VDD3_13423 METAL6_2381600_3097700 METAL6_2383100_3097700 0.003
R_VDD3_13424 METAL6_2383100_3097700 METAL5_2383100_3097700 0.1
I_VDD3_44 METAL6_2089900_2801000 gnd 0.003
I_VDD3_45 METAL6_695000_1061800 gnd 0.003
I_VDD3_46 METAL5_2395100_3097700 gnd 0.01

V_VDD4_21 METAL6_1500000_0 gnd 2
R_VDD4_13425 METAL6_1500000_0 METAL6_1500000_9500 0.019
R_VDD4_13426 METAL6_1500000_9500 METAL6_1500000_16000 0.013
R_VDD4_13427 METAL6_1500000_16000 METAL6_1500000_16600 0.0012
R_VDD4_13428 METAL6_1500000_16600 METAL6_1500000_21500 0.0098
R_VDD4_13429 METAL6_1500000_21500 METAL6_1500000_28000 0.013
R_VDD4_13430 METAL6_1500000_28000 METAL6_1498300_28000 0.0034
R_VDD4_13431 METAL6_1498300_28000 METAL6_1491400_28000 0.0138
R_VDD4_13432 METAL6_1491400_28000 METAL6_1488000_28000 0.0068
R_VDD4_13433 METAL6_1488000_28000 METAL6_1479400_28000 0.0172
R_VDD4_13434 METAL6_1479400_28000 METAL6_1444800_28000 0.0692
R_VDD4_13435 METAL6_1444800_28000 METAL6_1443700_28000 0.0022
R_VDD4_13436 METAL6_1443700_28000 METAL6_1432800_28000 0.0218
R_VDD4_13437 METAL6_1432800_28000 METAL6_1431700_28000 0.0022
R_VDD4_13438 METAL6_1431700_28000 METAL6_1424000_28000 0.0154
R_VDD4_13439 METAL6_1424000_28000 METAL5_1424000_28000 0.1
R_VDD4_13440 METAL5_1424000_28000 METAL5_1420800_28000 0.0128
R_VDD4_13441 METAL5_1420800_28000 METAL5_1419700_28000 0.0044
R_VDD4_13442 METAL5_1419700_28000 METAL5_1412000_28000 0.0308
R_VDD4_13443 METAL5_1412000_28000 METAL5_1408800_28000 0.0128
R_VDD4_13444 METAL5_1408800_28000 METAL5_1400000_28000 0.0352
R_VDD4_13445 METAL5_1400000_28000 METAL5_1396800_28000 0.0128
R_VDD4_13446 METAL5_1396800_28000 METAL5_1388000_28000 0.0352
R_VDD4_13447 METAL5_1388000_28000 METAL5_1349000_28000 0.156
R_VDD4_13448 METAL5_1349000_28000 METAL5_1348000_28000 0.004
R_VDD4_13449 METAL5_1348000_28000 METAL5_1337000_28000 0.044
R_VDD4_13450 METAL5_1337000_28000 METAL5_1336000_28000 0.004
R_VDD4_13451 METAL5_1336000_28000 METAL5_1325000_28000 0.044
R_VDD4_13452 METAL5_1325000_28000 METAL5_1324000_28000 0.004
R_VDD4_13453 METAL5_1324000_28000 METAL5_1323800_28000 0.0008
R_VDD4_13454 METAL5_1323800_28000 METAL5_1313000_28000 0.0432
R_VDD4_13455 METAL5_1313000_28000 METAL5_1312000_28000 0.004
R_VDD4_13456 METAL5_1312000_28000 METAL5_1311800_28000 0.0008
R_VDD4_13457 METAL5_1311800_28000 METAL5_1301000_28000 0.0432
R_VDD4_13458 METAL5_1301000_28000 METAL5_1300000_28000 0.004
R_VDD4_13459 METAL5_1300000_28000 METAL5_1299800_28000 0.0008
R_VDD4_13460 METAL5_1299800_28000 METAL5_1294300_28000 0.022
R_VDD4_13461 METAL5_1294300_28000 METAL5_1289000_28000 0.0212
R_VDD4_13462 METAL5_1289000_28000 METAL5_1288000_28000 0.004
R_VDD4_13463 METAL5_1288000_28000 METAL5_1287800_28000 0.0008
R_VDD4_13464 METAL5_1287800_28000 METAL5_1286700_28000 0.0044
R_VDD4_13465 METAL5_1286700_28000 METAL5_1282300_28000 0.0176
R_VDD4_13466 METAL5_1282300_28000 METAL5_1276000_28000 0.0252
R_VDD4_13467 METAL5_1276000_28000 METAL5_1274700_28000 0.0052
R_VDD4_13468 METAL5_1274700_28000 METAL5_1270300_28000 0.0176
R_VDD4_13469 METAL5_1270300_28000 METAL5_1266800_28000 0.014
R_VDD4_13470 METAL5_1266800_28000 METAL5_1262700_28000 0.0164
R_VDD4_13471 METAL5_1262700_28000 METAL5_1259800_28000 0.0116
R_VDD4_13472 METAL5_1259800_28000 METAL5_1258300_28000 0.006
R_VDD4_13473 METAL5_1258300_28000 METAL5_1254700_28000 0.0144
R_VDD4_13474 METAL5_1254700_28000 METAL5_1253300_28000 0.0056
R_VDD4_13475 METAL5_1253300_28000 METAL5_1248000_28000 0.0212
R_VDD4_13476 METAL5_1248000_28000 METAL5_1247800_28000 0.0008
R_VDD4_13477 METAL5_1247800_28000 METAL5_1246300_28000 0.006
R_VDD4_13478 METAL5_1246300_28000 METAL5_1242700_28000 0.0144
R_VDD4_13479 METAL5_1242700_28000 METAL5_1236000_28000 0.0268
R_VDD4_13480 METAL5_1236000_28000 METAL5_1235800_28000 0.0008
R_VDD4_13481 METAL5_1235800_28000 METAL5_1234300_28000 0.006
R_VDD4_13482 METAL5_1234300_28000 METAL5_1230700_28000 0.0144
R_VDD4_13483 METAL5_1230700_28000 METAL5_1224000_28000 0.0268
R_VDD4_13484 METAL5_1224000_28000 METAL5_1223800_28000 0.0008
R_VDD4_13485 METAL5_1223800_28000 METAL5_1222300_28000 0.006
R_VDD4_13486 METAL5_1222300_28000 METAL5_1218700_28000 0.0144
R_VDD4_13487 METAL5_1218700_28000 METAL5_1216400_28000 0.0092
R_VDD4_13488 METAL5_1216400_28000 METAL5_1212000_28000 0.0176
R_VDD4_13489 METAL5_1212000_28000 METAL5_1211800_28000 0.0008
R_VDD4_13490 METAL5_1211800_28000 METAL5_1210300_28000 0.006
R_VDD4_13491 METAL5_1210300_28000 METAL5_1206700_28000 0.0144
R_VDD4_13492 METAL5_1206700_28000 METAL5_1204400_28000 0.0092
R_VDD4_13493 METAL5_1204400_28000 METAL5_1200000_28000 0.0176
R_VDD4_13494 METAL5_1200000_28000 METAL5_1199800_28000 0.0008
R_VDD4_13495 METAL5_1199800_28000 METAL5_1198300_28000 0.006
R_VDD4_13496 METAL5_1198300_28000 METAL5_1194700_28000 0.0144
R_VDD4_13497 METAL5_1194700_28000 METAL5_1192400_28000 0.0092
R_VDD4_13498 METAL5_1192400_28000 METAL5_1188000_28000 0.0176
R_VDD4_13499 METAL5_1188000_28000 METAL6_1188000_28000 0.1
R_VDD4_13500 METAL6_1188000_28000 METAL6_1188000_28600 0.0012
R_VDD4_13501 METAL6_1188000_28600 METAL6_1188000_33500 0.0098
R_VDD4_13502 METAL6_1188000_33500 METAL6_1188000_40000 0.013
R_VDD4_13503 METAL6_1188000_40000 METAL6_1188000_40600 0.0012
R_VDD4_13504 METAL6_1188000_40600 METAL6_1188000_52000 0.0228
R_VDD4_13505 METAL6_1188000_52000 METAL6_1188000_52600 0.0012
R_VDD4_13506 METAL6_1188000_52600 METAL6_1188000_64000 0.0228
R_VDD4_13507 METAL6_1188000_64000 METAL6_1188000_64600 0.0012
R_VDD4_13508 METAL6_1188000_64600 METAL6_1188000_71600 0.014
R_VDD4_13509 METAL6_1188000_71600 METAL6_1188000_76000 0.0088
R_VDD4_13510 METAL6_1188000_76000 METAL6_1188000_76600 0.0012
R_VDD4_13511 METAL6_1188000_76600 METAL6_1188000_83600 0.014
R_VDD4_13512 METAL6_1188000_83600 METAL6_1188000_88000 0.0088
R_VDD4_13513 METAL6_1188000_88000 METAL6_1188000_88600 0.0012
R_VDD4_13514 METAL6_1188000_88600 METAL6_1188000_95600 0.014
R_VDD4_13515 METAL6_1188000_95600 METAL6_1188000_100000 0.0088
R_VDD4_13516 METAL6_1188000_100000 METAL6_1188000_100600 0.0012
R_VDD4_13517 METAL6_1188000_100600 METAL6_1188000_112000 0.0228
R_VDD4_13518 METAL6_1188000_112000 METAL6_1188000_147600 0.0712
R_VDD4_13519 METAL6_1188000_147600 METAL6_1188000_159600 0.024
R_VDD4_13520 METAL6_1188000_159600 METAL6_1188000_164000 0.0088
R_VDD4_13521 METAL6_1188000_164000 METAL6_1188000_166600 0.0052
R_VDD4_13522 METAL6_1188000_166600 METAL6_1188000_171600 0.01
R_VDD4_13523 METAL6_1188000_171600 METAL6_1188000_176000 0.0088
R_VDD4_13524 METAL6_1188000_176000 METAL6_1188000_178600 0.0052
R_VDD4_13525 METAL6_1188000_178600 METAL6_1188000_188000 0.0188
R_VDD4_13526 METAL6_1188000_188000 METAL6_1188000_190600 0.0052
R_VDD4_13527 METAL6_1188000_190600 METAL6_1188000_200000 0.0188
R_VDD4_13528 METAL6_1188000_200000 METAL6_1188000_202600 0.0052
R_VDD4_13529 METAL6_1188000_202600 METAL6_1188000_212000 0.0188
R_VDD4_13530 METAL6_1188000_212000 METAL6_1188000_214600 0.0052
R_VDD4_13531 METAL6_1188000_214600 METAL6_1188000_224300 0.0194
R_VDD4_13532 METAL6_1188000_224300 METAL6_1188000_226600 0.0046
R_VDD4_13533 METAL6_1188000_226600 METAL6_1188000_236300 0.0194
R_VDD4_13534 METAL6_1188000_236300 METAL6_1188000_248300 0.024
R_VDD4_13535 METAL6_1188000_248300 METAL6_1188000_251000 0.0054
R_VDD4_13536 METAL6_1188000_251000 METAL6_1188000_260300 0.0186
R_VDD4_13537 METAL6_1188000_260300 METAL6_1188000_263000 0.0054
R_VDD4_13538 METAL6_1188000_263000 METAL6_1188000_272300 0.0186
R_VDD4_13539 METAL6_1188000_272300 METAL6_1188000_275000 0.0054
R_VDD4_13540 METAL6_1188000_275000 METAL6_1187800_275000 0.0004
R_VDD4_13541 METAL6_1187800_275000 METAL6_1186300_275000 0.003
R_VDD4_13542 METAL6_1186300_275000 METAL6_1182700_275000 0.0072
R_VDD4_13543 METAL6_1182700_275000 METAL6_1180400_275000 0.0046
R_VDD4_13544 METAL6_1180400_275000 METAL6_1176000_275000 0.0088
R_VDD4_13545 METAL6_1176000_275000 METAL6_1174300_275000 0.0034
R_VDD4_13546 METAL6_1174300_275000 METAL6_1173700_275000 0.0012
R_VDD4_13547 METAL6_1173700_275000 METAL6_1168400_275000 0.0106
R_VDD4_13548 METAL6_1168400_275000 METAL6_1166700_275000 0.0034
R_VDD4_13549 METAL6_1166700_275000 METAL6_1162300_275000 0.0088
R_VDD4_13550 METAL6_1162300_275000 METAL6_1154700_275000 0.0152
R_VDD4_13551 METAL6_1154700_275000 METAL6_1150300_275000 0.0088
R_VDD4_13552 METAL6_1150300_275000 METAL6_1142700_275000 0.0152
R_VDD4_13553 METAL6_1142700_275000 METAL6_1137000_275000 0.0114
R_VDD4_13554 METAL6_1137000_275000 METAL6_1130700_275000 0.0126
R_VDD4_13555 METAL6_1130700_275000 METAL6_1125000_275000 0.0114
R_VDD4_13556 METAL6_1125000_275000 METAL6_1118700_275000 0.0126
R_VDD4_13557 METAL6_1118700_275000 METAL6_1113000_275000 0.0114
R_VDD4_13558 METAL6_1113000_275000 METAL6_1019000_275000 0.188
R_VDD4_13559 METAL6_1019000_275000 METAL6_1007000_275000 0.024
R_VDD4_13560 METAL6_995000_275000 METAL6_1007000_275000 0.024
R_VDD4_13561 METAL4_2236700_1042700 METAL4_2236700_1049400 0.0536
R_VDD4_13562 METAL4_2236700_1049400 METAL4_2236700_1054700 0.0424
R_VDD4_13563 METAL6_1500000_9500 METAL6_1503400_9500 0.0068
R_VDD4_13564 METAL6_1503400_9500 METAL6_1510400_9500 0.014
R_VDD4_13565 METAL6_1510400_9500 METAL6_1512000_9500 0.0032
R_VDD4_13566 METAL6_1512000_9500 METAL6_1527800_9500 0.0316
R_VDD4_13567 METAL6_1527800_9500 METAL6_1527800_16000 0.013
R_VDD4_13568 METAL6_1527800_16000 METAL6_1527800_16600 0.0012
R_VDD4_13569 METAL6_1527800_16600 METAL6_1527800_21500 0.0098
R_VDD4_13570 METAL6_1527800_21500 METAL6_1527800_28000 0.013
R_VDD4_13571 METAL6_1527800_28000 METAL6_1527800_28600 0.0012
R_VDD4_13572 METAL6_1527800_28600 METAL6_1527800_33500 0.0098
R_VDD4_13573 METAL6_1527800_33500 METAL6_1527800_40000 0.013
R_VDD4_13574 METAL6_1527800_40000 METAL6_1527800_40600 0.0012
R_VDD4_13575 METAL6_1527800_40600 METAL6_1527800_52000 0.0228
R_VDD4_13576 METAL6_1527800_52000 METAL6_1528000_52000 0.0004
R_VDD4_13577 METAL6_1528000_52000 METAL6_1539800_52000 0.0236
R_VDD4_13578 METAL6_1539800_52000 METAL6_1540000_52000 0.0004
R_VDD4_13579 METAL6_1540000_52000 METAL6_1545000_52000 0.01
R_VDD4_13580 METAL6_1545000_52000 METAL6_1551800_52000 0.0136
R_VDD4_13581 METAL6_1551800_52000 METAL6_1552000_52000 0.0004
R_VDD4_13582 METAL6_1552000_52000 METAL6_1555400_52000 0.0068
R_VDD4_13583 METAL6_1555400_52000 METAL6_1557000_52000 0.0032
R_VDD4_13584 METAL6_1557000_52000 METAL6_1564000_52000 0.014
R_VDD4_13585 METAL6_1564000_52000 METAL6_1567800_52000 0.0076
R_VDD4_13586 METAL6_1567800_52000 METAL5_1567800_52000 0.1
R_VDD4_13587 METAL5_1567800_52000 METAL5_1569000_52000 0.0048
R_VDD4_13588 METAL5_1569000_52000 METAL5_1574700_52000 0.0228
R_VDD4_13589 METAL5_1574700_52000 METAL5_1576000_52000 0.0052
R_VDD4_13590 METAL5_1576000_52000 METAL5_1576700_52000 0.0028
R_VDD4_13591 METAL5_1576700_52000 METAL5_1579800_52000 0.0124
R_VDD4_13592 METAL5_1579800_52000 METAL5_1588000_52000 0.0328
R_VDD4_13593 METAL5_1588000_52000 METAL5_1588700_52000 0.0028
R_VDD4_13594 METAL5_1588700_52000 METAL5_1591800_52000 0.0124
R_VDD4_13595 METAL5_1591800_52000 METAL5_1600000_52000 0.0328
R_VDD4_13596 METAL5_1600000_52000 METAL5_1600700_52000 0.0028
R_VDD4_13597 METAL5_1600700_52000 METAL5_1603800_52000 0.0124
R_VDD4_13598 METAL5_1603800_52000 METAL5_1607900_52000 0.0164
R_VDD4_13599 METAL5_1607900_52000 METAL5_1612000_52000 0.0164
R_VDD4_13600 METAL5_1612000_52000 METAL6_1612000_52000 0.1
R_VDD4_13601 METAL6_1612000_52000 METAL6_1612700_52000 0.0014
R_VDD4_13602 METAL6_1612700_52000 METAL6_1615800_52000 0.0062
R_VDD4_13603 METAL6_1615800_52000 METAL6_1624000_52000 0.0164
R_VDD4_13604 METAL6_1624000_52000 METAL6_1624700_52000 0.0014
R_VDD4_13605 METAL6_1624700_52000 METAL6_1627800_52000 0.0062
R_VDD4_13606 METAL6_1627800_52000 METAL6_1632800_52000 0.01
R_VDD4_13607 METAL6_1632800_52000 METAL6_1634800_52000 0.004
R_VDD4_13608 METAL6_1634800_52000 METAL6_1636000_52000 0.0024
R_VDD4_13609 METAL6_1636000_52000 METAL6_1636700_52000 0.0014
R_VDD4_13610 METAL6_1636700_52000 METAL6_1646800_52000 0.0202
R_VDD4_13611 METAL6_1646800_52000 METAL6_1648000_52000 0.0024
R_VDD4_13612 METAL6_1648000_52000 METAL6_1648700_52000 0.0014
R_VDD4_13613 METAL6_1648700_52000 METAL6_1658800_52000 0.0202
R_VDD4_13614 METAL6_1658800_52000 METAL6_1660700_52000 0.0038
R_VDD4_13615 METAL6_1660700_52000 METAL6_1668000_52000 0.0146
R_VDD4_13616 METAL6_1668000_52000 METAL6_1670800_52000 0.0056
R_VDD4_13617 METAL6_1670800_52000 METAL6_1680000_52000 0.0184
R_VDD4_13618 METAL6_1680000_52000 METAL6_1682800_52000 0.0056
R_VDD4_13619 METAL6_1682800_52000 METAL6_1692000_52000 0.0184
R_VDD4_13620 METAL6_1692000_52000 METAL6_1699000_52000 0.014
R_VDD4_13621 METAL6_1699000_52000 METAL6_1707700_52000 0.0174
R_VDD4_13622 METAL6_1707700_52000 METAL6_1710800_52000 0.0062
R_VDD4_13623 METAL6_1710800_52000 METAL6_1717800_52000 0.014
R_VDD4_13624 METAL6_1717800_52000 METAL6_1719700_52000 0.0038
R_VDD4_13625 METAL6_1719700_52000 METAL6_1727800_52000 0.0162
R_VDD4_13626 METAL6_1727800_52000 METAL6_1729800_52000 0.004
R_VDD4_13627 METAL6_1729800_52000 METAL6_1731700_52000 0.0038
R_VDD4_13628 METAL6_1731700_52000 METAL6_1731700_52600 0.0012
R_VDD4_13629 METAL6_1731700_52600 METAL6_1731700_64000 0.0228
R_VDD4_13630 METAL6_1731700_64000 METAL6_1731700_64600 0.0012
R_VDD4_13631 METAL6_1731700_64600 METAL6_1731700_71600 0.014
R_VDD4_13632 METAL6_1731700_71600 METAL6_1731700_76000 0.0088
R_VDD4_13633 METAL6_1731700_76000 METAL6_1731700_76600 0.0012
R_VDD4_13634 METAL6_1731700_76600 METAL6_1731700_83600 0.014
R_VDD4_13635 METAL6_1731700_83600 METAL6_1731700_88000 0.0088
R_VDD4_13636 METAL6_1731700_88000 METAL6_1731700_88600 0.0012
R_VDD4_13637 METAL6_1731700_88600 METAL6_1731700_95600 0.014
R_VDD4_13638 METAL6_1731700_95600 METAL6_1731700_100000 0.0088
R_VDD4_13639 METAL6_1731700_100000 METAL6_1731700_100600 0.0012
R_VDD4_13640 METAL6_1731700_100600 METAL6_1731700_112000 0.0228
R_VDD4_13641 METAL6_1731700_112000 METAL6_1731700_147600 0.0712
R_VDD4_13642 METAL6_1731700_147600 METAL6_1731700_159600 0.024
R_VDD4_13643 METAL6_1731700_159600 METAL6_1731700_164000 0.0088
R_VDD4_13644 METAL6_1731700_164000 METAL6_1731700_166600 0.0052
R_VDD4_13645 METAL6_1731700_166600 METAL6_1731700_171600 0.01
R_VDD4_13646 METAL6_1731700_171600 METAL6_1731700_176000 0.0088
R_VDD4_13647 METAL6_1731700_176000 METAL6_1731700_178600 0.0052
R_VDD4_13648 METAL6_1731700_178600 METAL6_1731700_188000 0.0188
R_VDD4_13649 METAL6_1731700_188000 METAL6_1731700_190600 0.0052
R_VDD4_13650 METAL6_1731700_190600 METAL6_1731700_200000 0.0188
R_VDD4_13651 METAL6_1731700_200000 METAL6_1731700_202600 0.0052
R_VDD4_13652 METAL6_1731700_202600 METAL6_1731700_212000 0.0188
R_VDD4_13653 METAL6_1731700_212000 METAL6_1731700_214600 0.0052
R_VDD4_13654 METAL6_1731700_214600 METAL6_1731700_224300 0.0194
R_VDD4_13655 METAL6_1731700_224300 METAL6_1731700_226600 0.0046
R_VDD4_13656 METAL6_1731700_226600 METAL6_1731700_236300 0.0194
R_VDD4_13657 METAL6_1731700_236300 METAL6_1731700_248300 0.024
R_VDD4_13658 METAL6_1731700_248300 METAL6_1731700_251000 0.0054
R_VDD4_13659 METAL6_1731700_251000 METAL6_1731700_260300 0.0186
R_VDD4_13660 METAL6_1731700_260300 METAL6_1731700_263000 0.0054
R_VDD4_13661 METAL6_1731700_263000 METAL6_1731700_272300 0.0186
R_VDD4_13662 METAL6_1731700_272300 METAL6_1731700_275000 0.0054
R_VDD4_13663 METAL6_1731700_275000 METAL6_1731700_279300 0.0086
R_VDD4_13664 METAL6_1731700_279300 METAL6_1731700_287000 0.0154
R_VDD4_13665 METAL6_1731700_287000 METAL6_1731700_288000 0.002
R_VDD4_13666 METAL6_1731700_288000 METAL6_1731700_299000 0.022
R_VDD4_13667 METAL6_1731700_299000 METAL6_1731700_300000 0.002
R_VDD4_13668 METAL6_1731700_300000 METAL6_1731700_311000 0.022
R_VDD4_13669 METAL6_1731700_311000 METAL6_1731700_312000 0.002
R_VDD4_13670 METAL6_1731700_312000 METAL6_1731700_323000 0.022
R_VDD4_13671 METAL6_1731700_323000 METAL6_1731700_354800 0.0636
R_VDD4_13672 METAL6_1731700_354800 METAL6_1731700_355300 0.001
R_VDD4_13673 METAL6_1731700_355300 METAL6_1731700_362300 0.014
R_VDD4_13674 METAL6_1731700_362300 METAL6_1731700_366800 0.009
R_VDD4_13675 METAL6_1731700_366800 METAL6_1731700_374300 0.015
R_VDD4_13676 METAL6_1731700_374300 METAL6_1731700_377000 0.0054
R_VDD4_13677 METAL6_1731700_377000 METAL6_1731700_378800 0.0036
R_VDD4_13678 METAL6_1731700_378800 METAL6_1731700_386300 0.015
R_VDD4_13679 METAL6_1731700_386300 METAL6_1731700_388000 0.0034
R_VDD4_13680 METAL6_1731700_388000 METAL6_1731700_389000 0.002
R_VDD4_13681 METAL6_1731700_389000 METAL6_1731700_390800 0.0036
R_VDD4_13682 METAL6_1731700_390800 METAL6_1731700_400000 0.0184
R_VDD4_13683 METAL6_1731700_400000 METAL6_1731700_401000 0.002
R_VDD4_13684 METAL6_1731700_401000 METAL6_1731700_402800 0.0036
R_VDD4_13685 METAL6_1731700_402800 METAL6_1731700_412000 0.0184
R_VDD4_13686 METAL6_1731700_412000 METAL6_1731700_413000 0.002
R_VDD4_13687 METAL6_1731700_413000 METAL6_1732000_413000 0.0006
R_VDD4_13688 METAL6_1732000_413000 METAL6_1739400_413000 0.0148
R_VDD4_13689 METAL6_1739400_413000 METAL6_1739800_413000 0.0008
R_VDD4_13690 METAL6_1739800_413000 METAL5_1739800_413000 0.1
R_VDD4_13691 METAL5_1739800_413000 METAL5_1741800_413000 0.008
R_VDD4_13692 METAL5_1741800_413000 METAL5_1743700_413000 0.0076
R_VDD4_13693 METAL5_1743700_413000 METAL5_1744000_413000 0.0012
R_VDD4_13694 METAL5_1744000_413000 METAL5_1751400_413000 0.0296
R_VDD4_13695 METAL5_1751400_413000 METAL5_1751800_413000 0.0016
R_VDD4_13696 METAL5_1751800_413000 METAL5_1753800_413000 0.008
R_VDD4_13697 METAL5_1753800_413000 METAL5_1755700_413000 0.0076
R_VDD4_13698 METAL5_1755700_413000 METAL5_1756000_413000 0.0012
R_VDD4_13699 METAL5_1756000_413000 METAL5_1763400_413000 0.0296
R_VDD4_13700 METAL5_1763400_413000 METAL5_1763800_413000 0.0016
R_VDD4_13701 METAL5_1763800_413000 METAL5_1767700_413000 0.0156
R_VDD4_13702 METAL5_1767700_413000 METAL5_1768000_413000 0.0012
R_VDD4_13703 METAL5_1768000_413000 METAL5_1775400_413000 0.0296
R_VDD4_13704 METAL5_1775400_413000 METAL5_1787400_413000 0.048
R_VDD4_13705 METAL5_1787400_413000 METAL5_1788000_413000 0.0024
R_VDD4_13706 METAL5_1788000_413000 METAL5_1800000_413000 0.048
R_VDD4_13707 METAL5_1800000_413000 METAL5_1810600_413000 0.0424
R_VDD4_13708 METAL5_1810600_413000 METAL5_1812000_413000 0.0056
R_VDD4_13709 METAL5_1812000_413000 METAL5_1820800_413000 0.0352
R_VDD4_13710 METAL5_1820800_413000 METAL5_1822400_413000 0.0064
R_VDD4_13711 METAL5_1822400_413000 METAL5_1822600_413000 0.0008
R_VDD4_13712 METAL5_1822600_413000 METAL5_1832800_413000 0.0408
R_VDD4_13713 METAL5_1832800_413000 METAL5_1834400_413000 0.0064
R_VDD4_13714 METAL5_1834400_413000 METAL5_1834600_413000 0.0008
R_VDD4_13715 METAL5_1834600_413000 METAL5_1841400_413000 0.0272
R_VDD4_13716 METAL5_1841400_413000 METAL5_1844800_413000 0.0136
R_VDD4_13717 METAL5_1844800_413000 METAL5_1846400_413000 0.0064
R_VDD4_13718 METAL5_1846400_413000 METAL5_1846600_413000 0.0008
R_VDD4_13719 METAL5_1846600_413000 METAL5_1846800_413000 0.0008
R_VDD4_13720 METAL5_1846800_413000 METAL5_1847200_413000 0.0016
R_VDD4_13721 METAL5_1847200_413000 METAL5_1852700_413000 0.022
R_VDD4_13722 METAL5_1852700_413000 METAL5_1853400_413000 0.0028
R_VDD4_13723 METAL5_1853400_413000 METAL5_1858400_413000 0.02
R_VDD4_13724 METAL5_1858400_413000 METAL5_1858600_413000 0.0008
R_VDD4_13725 METAL5_1858600_413000 METAL5_1859200_413000 0.0024
R_VDD4_13726 METAL5_1859200_413000 METAL5_1864700_413000 0.022
R_VDD4_13727 METAL5_1864700_413000 METAL5_1865400_413000 0.0028
R_VDD4_13728 METAL5_1865400_413000 METAL5_1865600_413000 0.0008
R_VDD4_13729 METAL5_1865600_413000 METAL5_1870600_413000 0.02
R_VDD4_13730 METAL5_1870600_413000 METAL5_1871200_413000 0.0024
R_VDD4_13731 METAL5_1871200_413000 METAL5_1874700_413000 0.014
R_VDD4_13732 METAL5_1874700_413000 METAL5_1876700_413000 0.008
R_VDD4_13733 METAL5_1876700_413000 METAL5_1877400_413000 0.0028
R_VDD4_13734 METAL5_1877400_413000 METAL5_1877600_413000 0.0008
R_VDD4_13735 METAL5_1877600_413000 METAL5_1883200_413000 0.0224
R_VDD4_13736 METAL5_1883200_413000 METAL5_1888700_413000 0.022
R_VDD4_13737 METAL5_1888700_413000 METAL5_1888700_414800 0.0072
R_VDD4_13738 METAL5_1888700_414800 METAL5_1888700_424000 0.0368
R_VDD4_13739 METAL5_1888700_424000 METAL5_1888700_425000 0.004
R_VDD4_13740 METAL5_1888700_425000 METAL5_1889400_425000 0.0028
R_VDD4_13741 METAL5_1889400_425000 METAL5_1889600_425000 0.0008
R_VDD4_13742 METAL5_1889600_425000 METAL5_1895200_425000 0.0224
R_VDD4_13743 METAL5_1895200_425000 METAL5_1900700_425000 0.022
R_VDD4_13744 METAL5_1900700_425000 METAL5_1900700_426800 0.0072
R_VDD4_13745 METAL5_1900700_426800 METAL5_1900700_432400 0.0224
R_VDD4_13746 METAL5_1900700_432400 METAL5_1900700_437000 0.0184
R_VDD4_13747 METAL5_1900700_437000 METAL5_1900700_438800 0.0072
R_VDD4_13748 METAL5_1900700_438800 METAL5_1900700_444400 0.0224
R_VDD4_13749 METAL5_1900700_444400 METAL5_1900700_447000 0.0104
R_VDD4_13750 METAL5_1900700_447000 METAL5_1900700_449000 0.008
R_VDD4_13751 METAL5_1900700_449000 METAL5_1900700_453000 0.016
R_VDD4_13752 METAL5_1900700_453000 METAL5_1900700_456400 0.0136
R_VDD4_13753 METAL5_1900700_456400 METAL5_1900700_459000 0.0104
R_VDD4_13754 METAL5_1900700_459000 METAL5_1900700_461000 0.008
R_VDD4_13755 METAL5_1900700_461000 METAL6_1900700_461000 0.1
R_VDD4_13756 METAL6_1900700_461000 METAL6_1900700_465000 0.008
R_VDD4_13757 METAL6_1900700_465000 METAL6_1900700_468400 0.0068
R_VDD4_13758 METAL6_1900700_468400 METAL6_1900700_471000 0.0052
R_VDD4_13759 METAL6_1900700_471000 METAL6_1900700_473000 0.004
R_VDD4_13760 METAL6_1900700_473000 METAL6_1900700_477000 0.008
R_VDD4_13761 METAL6_1900700_477000 METAL6_1900700_480400 0.0068
R_VDD4_13762 METAL6_1900700_480400 METAL6_1900700_483000 0.0052
R_VDD4_13763 METAL6_1900700_483000 METAL6_1900700_488000 0.01
R_VDD4_13764 METAL6_1900700_488000 METAL6_1900700_492000 0.008
R_VDD4_13765 METAL6_1900700_492000 METAL6_1901400_492000 0.0014
R_VDD4_13766 METAL6_1901400_492000 METAL6_1901400_492400 0.0008
R_VDD4_13767 METAL6_1901400_492400 METAL6_1901400_495000 0.0052
R_VDD4_13768 METAL6_1901400_495000 METAL6_1901400_500000 0.01
R_VDD4_13769 METAL6_1901400_500000 METAL6_1901400_504000 0.008
R_VDD4_13770 METAL6_1901400_504000 METAL6_1901400_504400 0.0008
R_VDD4_13771 METAL6_1901400_504400 METAL6_1901400_507000 0.0052
R_VDD4_13772 METAL6_1901400_507000 METAL6_1901400_507800 0.0016
R_VDD4_13773 METAL6_1901400_507800 METAL6_1901400_512000 0.0084
R_VDD4_13774 METAL6_1901400_512000 METAL6_1901400_516000 0.008
R_VDD4_13775 METAL6_1901400_516000 METAL6_1901400_516400 0.0008
R_VDD4_13776 METAL6_1901400_516400 METAL6_1901400_519000 0.0052
R_VDD4_13777 METAL6_1901400_519000 METAL6_1901400_520200 0.0024
R_VDD4_13778 METAL6_1901400_520200 METAL6_1901400_528000 0.0156
R_VDD4_13779 METAL6_1901400_528000 METAL6_1901400_532200 0.0084
R_VDD4_13780 METAL6_1901400_532200 METAL6_1901400_535400 0.0064
R_VDD4_13781 METAL6_1901400_535400 METAL6_1901400_538400 0.006
R_VDD4_13782 METAL6_1901400_538400 METAL6_1901400_544200 0.0116
R_VDD4_13783 METAL6_1901400_544200 METAL6_1901400_547400 0.0064
R_VDD4_13784 METAL6_1901400_547400 METAL6_1901400_550400 0.006
R_VDD4_13785 METAL6_1901400_550400 METAL6_1901400_556200 0.0116
R_VDD4_13786 METAL6_1901400_556200 METAL6_1901400_559400 0.0064
R_VDD4_13787 METAL6_1901400_559400 METAL6_1901400_561000 0.0032
R_VDD4_13788 METAL6_1901400_561000 METAL6_1901400_562400 0.0028
R_VDD4_13789 METAL6_1901400_562400 METAL6_1901400_568200 0.0116
R_VDD4_13790 METAL6_1901400_568200 METAL6_1901400_571400 0.0064
R_VDD4_13791 METAL6_1901400_571400 METAL6_1901400_573000 0.0032
R_VDD4_13792 METAL6_1901400_573000 METAL6_1901400_574400 0.0028
R_VDD4_13793 METAL6_1901400_574400 METAL6_1901400_579800 0.0108
R_VDD4_13794 METAL6_1901400_579800 METAL6_1901400_585000 0.0104
R_VDD4_13795 METAL6_1901400_585000 METAL6_1901400_586400 0.0028
R_VDD4_13796 METAL6_1901400_586400 METAL6_1901400_588000 0.0032
R_VDD4_13797 METAL6_1901400_588000 METAL6_1901400_597000 0.018
R_VDD4_13798 METAL6_1901400_597000 METAL6_1901400_598400 0.0028
R_VDD4_13799 METAL6_1901400_598400 METAL6_1901400_600000 0.0032
R_VDD4_13800 METAL6_1901400_600000 METAL6_1901400_605400 0.0108
R_VDD4_13801 METAL6_1901400_605400 METAL6_1901400_610400 0.01
R_VDD4_13802 METAL6_1901400_610400 METAL6_1901400_612000 0.0032
R_VDD4_13803 METAL6_1901400_612000 METAL6_1901400_617400 0.0108
R_VDD4_13804 METAL6_1901400_617400 METAL6_1901400_629400 0.024
R_VDD4_13805 METAL6_1901400_629400 METAL6_1901400_637800 0.0168
R_VDD4_13806 METAL6_1901400_637800 METAL6_1901400_641400 0.0072
R_VDD4_13807 METAL6_1901400_641400 METAL6_1901400_649800 0.0168
R_VDD4_13808 METAL6_1901400_649800 METAL6_1901400_653400 0.0072
R_VDD4_13809 METAL6_1901400_653400 METAL6_1901400_661800 0.0168
R_VDD4_13810 METAL6_1901400_661800 METAL6_1901400_665400 0.0072
R_VDD4_13811 METAL6_1901400_665400 METAL6_1901400_685800 0.0408
R_VDD4_13812 METAL6_1901400_685800 METAL6_1901400_688000 0.0044
R_VDD4_13813 METAL6_1901400_688000 METAL6_1901400_697800 0.0196
R_VDD4_13814 METAL6_1901400_697800 METAL6_1901400_700000 0.0044
R_VDD4_13815 METAL6_1901400_700000 METAL6_1901400_702800 0.0056
R_VDD4_13816 METAL6_1901400_702800 METAL6_1901400_704800 0.004
R_VDD4_13817 METAL6_1901400_704800 METAL6_1901400_709800 0.01
R_VDD4_13818 METAL6_1901400_709800 METAL6_1901400_712000 0.0044
R_VDD4_13819 METAL6_1901400_712000 METAL6_1901400_716800 0.0096
R_VDD4_13820 METAL6_1901400_716800 METAL6_1901400_721800 0.01
R_VDD4_13821 METAL6_1901400_721800 METAL6_1901400_722400 0.0012
R_VDD4_13822 METAL6_1901400_722400 METAL6_1901400_728800 0.0128
R_VDD4_13823 METAL6_1901400_728800 METAL6_1901400_733800 0.01
R_VDD4_13824 METAL6_1901400_733800 METAL6_1901400_734400 0.0012
R_VDD4_13825 METAL6_1901400_734400 METAL6_1901400_735400 0.002
R_VDD4_13826 METAL6_1901400_735400 METAL6_1901400_742400 0.014
R_VDD4_13827 METAL6_1901400_742400 METAL6_1901400_745800 0.0068
R_VDD4_13828 METAL6_1901400_745800 METAL6_1901400_746400 0.0012
R_VDD4_13829 METAL6_1901400_746400 METAL6_1901400_754400 0.016
R_VDD4_13830 METAL6_1901400_754400 METAL6_1901400_757800 0.0068
R_VDD4_13831 METAL6_1901400_757800 METAL6_1901400_758400 0.0012
R_VDD4_13832 METAL6_1901400_758400 METAL6_1901600_758400 0.0004
R_VDD4_13833 METAL6_1901600_758400 METAL6_1907200_758400 0.0112
R_VDD4_13834 METAL6_1907200_758400 METAL6_1907400_758400 0.0004
R_VDD4_13835 METAL6_1907400_758400 METAL6_1913600_758400 0.0124
R_VDD4_13836 METAL6_1913600_758400 METAL6_1919200_758400 0.0112
R_VDD4_13837 METAL6_1919200_758400 METAL6_1925600_758400 0.0128
R_VDD4_13838 METAL6_1925600_758400 METAL6_1926200_758400 0.0012
R_VDD4_13839 METAL6_1926200_758400 METAL6_1927800_758400 0.0032
R_VDD4_13840 METAL6_1927800_758400 METAL6_1931200_758400 0.0068
R_VDD4_13841 METAL6_1931200_758400 METAL6_1937600_758400 0.0128
R_VDD4_13842 METAL6_1937600_758400 METAL6_1939800_758400 0.0044
R_VDD4_13843 METAL6_1939800_758400 METAL6_1939900_758400 0.0002
R_VDD4_13844 METAL6_1939900_758400 METAL6_1951800_758400 0.0238
R_VDD4_13845 METAL6_1951800_758400 METAL6_1951800_760000 0.0032
R_VDD4_13846 METAL6_1951800_760000 METAL6_1951800_763000 0.006
R_VDD4_13847 METAL6_1951800_763000 METAL6_1951800_766400 0.0068
R_VDD4_13848 METAL6_1951800_766400 METAL6_1951800_769800 0.0068
R_VDD4_13849 METAL6_1951800_769800 METAL6_1951800_770400 0.0012
R_VDD4_13850 METAL6_1951800_770400 METAL6_1951900_770400 0.0002
R_VDD4_13851 METAL6_1951900_770400 METAL6_1963800_770400 0.0238
R_VDD4_13852 METAL6_1963800_770400 METAL6_1963800_772000 0.0032
R_VDD4_13853 METAL6_1963800_772000 METAL6_1963800_772500 0.001
R_VDD4_13854 METAL6_1963800_772500 METAL6_1963800_778400 0.0118
R_VDD4_13855 METAL6_1963800_778400 METAL6_1963800_779200 0.0016
R_VDD4_13856 METAL6_1963800_779200 METAL6_1963800_781800 0.0052
R_VDD4_13857 METAL6_1963800_781800 METAL6_1963800_782400 0.0012
R_VDD4_13858 METAL6_1963800_782400 METAL6_1963800_782800 0.0008
R_VDD4_13859 METAL6_1963800_782800 METAL6_1963800_784000 0.0024
R_VDD4_13860 METAL6_1963800_784000 METAL6_1963800_784500 0.001
R_VDD4_13861 METAL6_1963800_784500 METAL6_1963800_788000 0.007
R_VDD4_13862 METAL6_1963800_788000 METAL6_1963800_790400 0.0048
R_VDD4_13863 METAL6_1963800_790400 METAL6_1963800_791200 0.0016
R_VDD4_13864 METAL6_1963800_791200 METAL6_1963800_794400 0.0064
R_VDD4_13865 METAL6_1963800_794400 METAL6_1963800_794800 0.0008
R_VDD4_13866 METAL6_1963800_794800 METAL6_1963800_796500 0.0034
R_VDD4_13867 METAL6_1963800_796500 METAL6_1963800_800000 0.007
R_VDD4_13868 METAL6_1963800_800000 METAL6_1963800_802400 0.0048
R_VDD4_13869 METAL6_1963800_802400 METAL6_1963800_803200 0.0016
R_VDD4_13870 METAL6_1963800_803200 METAL6_1963800_806400 0.0064
R_VDD4_13871 METAL6_1963800_806400 METAL6_1963800_806800 0.0008
R_VDD4_13872 METAL6_1963800_806800 METAL6_1963800_808000 0.0024
R_VDD4_13873 METAL6_1963800_808000 METAL6_1963800_812000 0.008
R_VDD4_13874 METAL6_1963800_812000 METAL6_1963800_814400 0.0048
R_VDD4_13875 METAL6_1963800_814400 METAL6_1963800_818400 0.008
R_VDD4_13876 METAL6_1963800_818400 METAL6_1963800_820000 0.0032
R_VDD4_13877 METAL6_1963800_820000 METAL6_1963800_828700 0.0174
R_VDD4_13878 METAL6_1963800_828700 METAL6_1963800_830400 0.0034
R_VDD4_13879 METAL6_1963800_830400 METAL6_1963800_832000 0.0032
R_VDD4_13880 METAL6_1963800_832000 METAL6_1963800_839500 0.015
R_VDD4_13881 METAL6_1963800_839500 METAL6_1963800_840700 0.0024
R_VDD4_13882 METAL6_1963800_840700 METAL6_1963800_842400 0.0034
R_VDD4_13883 METAL6_1963800_842400 METAL6_1963800_851500 0.0182
R_VDD4_13884 METAL6_1963800_851500 METAL6_1963800_852700 0.0024
R_VDD4_13885 METAL6_1963800_852700 METAL6_1963800_854400 0.0034
R_VDD4_13886 METAL6_1963800_854400 METAL6_1963800_858200 0.0076
R_VDD4_13887 METAL6_1963800_858200 METAL6_1963800_863500 0.0106
R_VDD4_13888 METAL6_1963800_863500 METAL6_1963800_875000 0.023
R_VDD4_13889 METAL6_1963800_875000 METAL6_1963800_887000 0.024
R_VDD4_13890 METAL6_1963800_887000 METAL6_1963800_888000 0.002
R_VDD4_13891 METAL6_1963800_888000 METAL6_1963800_888400 0.0008
R_VDD4_13892 METAL6_1963800_888400 METAL6_1963800_899000 0.0212
R_VDD4_13893 METAL6_1963800_899000 METAL6_1963800_900000 0.002
R_VDD4_13894 METAL6_1963800_900000 METAL6_1963800_900400 0.0008
R_VDD4_13895 METAL6_1963800_900400 METAL6_1963800_911000 0.0212
R_VDD4_13896 METAL6_1963800_911000 METAL6_1963800_912000 0.002
R_VDD4_13897 METAL6_1963800_912000 METAL6_1963800_912400 0.0008
R_VDD4_13898 METAL6_1963800_912400 METAL6_1963800_923000 0.0212
R_VDD4_13899 METAL6_1963800_923000 METAL6_1963800_924000 0.002
R_VDD4_13900 METAL6_1963800_924000 METAL6_1963800_927300 0.0066
R_VDD4_13901 METAL6_1963800_927300 METAL6_1963800_935000 0.0154
R_VDD4_13902 METAL6_1963800_935000 METAL6_1963800_947000 0.024
R_VDD4_13903 METAL6_1963800_947000 METAL6_1963900_947000 0.0002
R_VDD4_13904 METAL6_1963900_947000 METAL6_1975900_947000 0.024
R_VDD4_13905 METAL6_1975900_947000 METAL6_1976000_947000 0.0002
R_VDD4_13906 METAL6_1976000_947000 METAL6_1988000_947000 0.024
R_VDD4_13907 METAL6_1988000_947000 METAL6_2000000_947000 0.024
R_VDD4_13908 METAL6_2000000_947000 METAL6_2002400_947000 0.0048
R_VDD4_13909 METAL6_2002400_947000 METAL6_2006900_947000 0.009
R_VDD4_13910 METAL6_2006900_947000 METAL6_2007700_947000 0.0016
R_VDD4_13911 METAL6_2007700_947000 METAL6_2012000_947000 0.0086
R_VDD4_13912 METAL6_2012000_947000 METAL6_2014400_947000 0.0048
R_VDD4_13913 METAL6_2014400_947000 METAL6_2018900_947000 0.009
R_VDD4_13914 METAL6_2018900_947000 METAL6_2019700_947000 0.0016
R_VDD4_13915 METAL6_2019700_947000 METAL6_2021200_947000 0.003
R_VDD4_13916 METAL6_2021200_947000 METAL6_2026400_947000 0.0104
R_VDD4_13917 METAL6_2026400_947000 METAL6_2030900_947000 0.009
R_VDD4_13918 METAL6_2030900_947000 METAL6_2031700_947000 0.0016
R_VDD4_13919 METAL6_2031700_947000 METAL6_2034800_947000 0.0062
R_VDD4_13920 METAL6_2034800_947000 METAL6_2043700_947000 0.0178
R_VDD4_13921 METAL6_2043700_947000 METAL6_2046400_947000 0.0054
R_VDD4_13922 METAL6_2046400_947000 METAL6_2046600_947000 0.0004
R_VDD4_13923 METAL6_2046600_947000 METAL6_2046800_947000 0.0004
R_VDD4_13924 METAL6_2046800_947000 METAL6_2055700_947000 0.0178
R_VDD4_13925 METAL6_2055700_947000 METAL6_2058800_947000 0.0062
R_VDD4_13926 METAL6_2058800_947000 METAL6_2060600_947000 0.0036
R_VDD4_13927 METAL6_2060600_947000 METAL6_2067700_947000 0.0142
R_VDD4_13928 METAL6_2067700_947000 METAL6_2077900_947000 0.0204
R_VDD4_13929 METAL6_2077900_947000 METAL6_2079700_947000 0.0036
R_VDD4_13930 METAL6_2079700_947000 METAL6_2089900_947000 0.0204
R_VDD4_13931 METAL6_2089900_947000 METAL6_2091700_947000 0.0036
R_VDD4_13932 METAL6_2091700_947000 METAL6_2101600_947000 0.0198
R_VDD4_13933 METAL6_2101600_947000 METAL6_2101900_947000 0.0006
R_VDD4_13934 METAL6_2101900_947000 METAL6_2105900_947000 0.008
R_VDD4_13935 METAL6_2105900_947000 METAL6_2113600_947000 0.0154
R_VDD4_13936 METAL6_2113600_947000 METAL6_2113900_947000 0.0006
R_VDD4_13937 METAL6_2113900_947000 METAL6_2117900_947000 0.008
R_VDD4_13938 METAL6_2117900_947000 METAL6_2121400_947000 0.007
R_VDD4_13939 METAL6_2121400_947000 METAL6_2125600_947000 0.0084
R_VDD4_13940 METAL6_2125600_947000 METAL6_2125900_947000 0.0006
R_VDD4_13941 METAL6_2125900_947000 METAL6_2129700_947000 0.0076
R_VDD4_13942 METAL6_2129700_947000 METAL6_2129900_947000 0.0004
R_VDD4_13943 METAL6_2129900_947000 METAL6_2141400_947000 0.023
R_VDD4_13944 METAL6_2141400_947000 METAL6_2141900_947000 0.001
R_VDD4_13945 METAL6_2141900_947000 METAL6_2151900_947000 0.02
R_VDD4_13946 METAL6_2151900_947000 METAL6_2153400_947000 0.003
R_VDD4_13947 METAL6_2153400_947000 METAL6_2153900_947000 0.001
R_VDD4_13948 METAL6_2153900_947000 METAL6_2165400_947000 0.023
R_VDD4_13949 METAL6_2165400_947000 METAL6_2165900_947000 0.001
R_VDD4_13950 METAL6_2165900_947000 METAL6_2176700_947000 0.0216
R_VDD4_13951 METAL6_2176700_947000 METAL6_2177900_947000 0.0024
R_VDD4_13952 METAL6_2177900_947000 METAL6_2188700_947000 0.0216
R_VDD4_13953 METAL6_2188700_947000 METAL6_2189900_947000 0.0024
R_VDD4_13954 METAL6_2189900_947000 METAL6_2200700_947000 0.0216
R_VDD4_13955 METAL6_2200700_947000 METAL6_2209900_947000 0.0184
R_VDD4_13956 METAL6_2209900_947000 METAL6_2210600_947000 0.0014
R_VDD4_13957 METAL6_2210600_947000 METAL6_2212600_947000 0.004
R_VDD4_13958 METAL6_2212600_947000 METAL6_2212700_947000 0.0002
R_VDD4_13959 METAL6_2212700_947000 METAL5_2212700_947000 0.1
R_VDD4_13960 METAL5_2212700_947000 METAL5_2221900_947000 0.0368
R_VDD4_13961 METAL5_2221900_947000 METAL5_2222600_947000 0.0028
R_VDD4_13962 METAL5_2222600_947000 METAL5_2224600_947000 0.008
R_VDD4_13963 METAL5_2224600_947000 METAL5_2224700_947000 0.0004
R_VDD4_13964 METAL5_2224700_947000 METAL5_2224700_959000 0.048
R_VDD4_13965 METAL5_2224700_959000 METAL5_2233900_959000 0.0368
R_VDD4_13966 METAL5_2233900_959000 METAL5_2233900_971000 0.048
R_VDD4_13967 METAL5_2233900_971000 METAL5_2233900_976000 0.02
R_VDD4_13968 METAL5_2233900_976000 METAL5_2233900_983000 0.028
R_VDD4_13969 METAL5_2233900_983000 METAL5_2233900_988000 0.02
R_VDD4_13970 METAL5_2233900_988000 METAL5_2233900_995000 0.028
R_VDD4_13971 METAL5_2233900_995000 METAL5_2233900_1000000 0.02
R_VDD4_13972 METAL5_2233900_1000000 METAL5_2233900_1001400 0.0056
R_VDD4_13973 METAL5_2233900_1001400 METAL5_2234600_1001400 0.0028
R_VDD4_13974 METAL5_2234600_1001400 METAL5_2236400_1001400 0.0072
R_VDD4_13975 METAL5_2236400_1001400 METAL5_2236600_1001400 0.0008
R_VDD4_13976 METAL5_2236600_1001400 METAL5_2236600_1007000 0.0224
R_VDD4_13977 METAL5_2236600_1007000 METAL5_2236600_1012000 0.02
R_VDD4_13978 METAL5_2236600_1012000 METAL5_2236600_1013400 0.0056
R_VDD4_13979 METAL5_2236600_1013400 METAL5_2236600_1014000 0.0024
R_VDD4_13980 METAL5_2236600_1014000 METAL5_2236600_1019000 0.02
R_VDD4_13981 METAL5_2236600_1019000 METAL5_2236600_1023700 0.0188
R_VDD4_13982 METAL5_2236600_1023700 METAL5_2236600_1025400 0.0068
R_VDD4_13983 METAL5_2236600_1025400 METAL5_2236600_1026000 0.0024
R_VDD4_13984 METAL5_2236600_1026000 METAL5_2236600_1029800 0.0152
R_VDD4_13985 METAL5_2236600_1029800 METAL5_2236600_1031000 0.0048
R_VDD4_13986 METAL5_2236600_1031000 METAL5_2236600_1035700 0.0188
R_VDD4_13987 METAL5_2236600_1035700 METAL5_2236700_1035700 0.0004
R_VDD4_13988 METAL5_2236700_1035700 METAL5_2245900_1035700 0.0368
R_VDD4_13989 METAL5_2245900_1035700 METAL5_2246600_1035700 0.0028
R_VDD4_13990 METAL5_2246600_1035700 METAL5_2248400_1035700 0.0072
R_VDD4_13991 METAL5_2248400_1035700 METAL5_2248600_1035700 0.0008
R_VDD4_13992 METAL5_2248600_1035700 METAL5_2248700_1035700 0.0004
R_VDD4_13993 METAL5_2248700_1035700 METAL5_2248700_1037400 0.0068
R_VDD4_13994 METAL5_2248700_1037400 METAL5_2248700_1038000 0.0024
R_VDD4_13995 METAL5_2248700_1038000 METAL5_2248700_1041800 0.0152
R_VDD4_13996 METAL5_2248700_1041800 METAL5_2248700_1042700 0.0036
R_VDD4_13997 METAL5_2248700_1042700 METAL5_2248700_1043000 0.0012
R_VDD4_13998 METAL5_2248700_1043000 METAL5_2248700_1047700 0.0188
R_VDD4_13999 METAL5_2248700_1047700 METAL5_2248700_1049400 0.0068
R_VDD4_14000 METAL5_2248700_1049400 METAL5_2248700_1049800 0.0016
R_VDD4_14001 METAL5_2248700_1049800 METAL5_2248700_1053800 0.016
R_VDD4_14002 METAL5_2248700_1053800 METAL5_2248700_1054700 0.0036
R_VDD4_14003 METAL5_2248700_1054700 METAL5_2248600_1054700 0.0004
R_VDD4_14004 METAL5_2248600_1054700 METAL5_2248400_1054700 0.0008
R_VDD4_14005 METAL5_2248400_1054700 METAL5_2246600_1054700 0.0072
R_VDD4_14006 METAL5_2246600_1054700 METAL5_2245900_1054700 0.0028
R_VDD4_14007 METAL5_2245900_1054700 METAL5_2236700_1054700 0.0368
R_VDD4_14008 METAL5_2236700_1054700 METAL4_2236700_1054700 0.1
R_VDD4_14009 METAL4_2014400_1184600 METAL4_2014400_1172600 0.096
R_VDD4_14010 METAL6_1988000_947000 METAL5_1988000_947000 0.1
R_VDD4_14011 METAL5_1988000_947000 METAL5_1988000_959000 0.048
R_VDD4_14012 METAL5_1988000_959000 METAL5_1988000_971000 0.048
R_VDD4_14013 METAL5_1988000_971000 METAL5_1988000_976000 0.02
R_VDD4_14014 METAL5_1988000_976000 METAL5_1988000_983000 0.028
R_VDD4_14015 METAL5_1988000_983000 METAL6_1988000_983000 0.1
R_VDD4_14016 METAL6_1988000_983000 METAL6_2000000_983000 0.024
R_VDD4_14017 METAL6_2000000_983000 METAL6_2000000_988000 0.01
R_VDD4_14018 METAL6_2000000_988000 METAL6_2002400_988000 0.0048
R_VDD4_14019 METAL6_2002400_988000 METAL6_2006900_988000 0.009
R_VDD4_14020 METAL6_2006900_988000 METAL6_2006900_989400 0.0028
R_VDD4_14021 METAL6_2006900_989400 METAL6_2006900_995000 0.0112
R_VDD4_14022 METAL6_2006900_995000 METAL6_2006900_1000000 0.01
R_VDD4_14023 METAL6_2006900_1000000 METAL6_2006900_1001400 0.0028
R_VDD4_14024 METAL6_2006900_1001400 METAL6_2006900_1007000 0.0112
R_VDD4_14025 METAL6_2006900_1007000 METAL6_2006900_1012000 0.01
R_VDD4_14026 METAL6_2006900_1012000 METAL6_2006900_1013400 0.0028
R_VDD4_14027 METAL6_2006900_1013400 METAL6_2007700_1013400 0.0016
R_VDD4_14028 METAL6_2007700_1013400 METAL6_2012000_1013400 0.0086
R_VDD4_14029 METAL6_2012000_1013400 METAL6_2014400_1013400 0.0048
R_VDD4_14030 METAL6_2014400_1013400 METAL6_2014400_1014000 0.0012
R_VDD4_14031 METAL6_2014400_1014000 METAL6_2014400_1019000 0.01
R_VDD4_14032 METAL6_2014400_1019000 METAL6_2014400_1023700 0.0094
R_VDD4_14033 METAL6_2014400_1023700 METAL6_2014400_1025400 0.0034
R_VDD4_14034 METAL6_2014400_1025400 METAL6_2014400_1026000 0.0012
R_VDD4_14035 METAL6_2014400_1026000 METAL6_2014400_1029800 0.0076
R_VDD4_14036 METAL6_2014400_1029800 METAL6_2014400_1031000 0.0024
R_VDD4_14037 METAL6_2014400_1031000 METAL6_2014400_1035700 0.0094
R_VDD4_14038 METAL6_2014400_1035700 METAL6_2014400_1037400 0.0034
R_VDD4_14039 METAL6_2014400_1037400 METAL6_2014400_1038000 0.0012
R_VDD4_14040 METAL6_2014400_1038000 METAL6_2014400_1041800 0.0076
R_VDD4_14041 METAL6_2014400_1041800 METAL6_2014400_1042700 0.0018
R_VDD4_14042 METAL6_2014400_1042700 METAL6_2014400_1043000 0.0006
R_VDD4_14043 METAL6_2014400_1043000 METAL6_2014400_1047700 0.0094
R_VDD4_14044 METAL6_2014400_1047700 METAL6_2014400_1049400 0.0034
R_VDD4_14045 METAL6_2014400_1049400 METAL6_2014400_1049800 0.0008
R_VDD4_14046 METAL6_2014400_1049800 METAL6_2014400_1053800 0.008
R_VDD4_14047 METAL6_2014400_1053800 METAL6_2014400_1054700 0.0018
R_VDD4_14048 METAL6_2014400_1054700 METAL6_2014400_1061400 0.0134
R_VDD4_14049 METAL6_2014400_1061400 METAL6_2014400_1061800 0.0008
R_VDD4_14050 METAL6_2014400_1061800 METAL6_2014400_1066700 0.0098
R_VDD4_14051 METAL6_2014400_1066700 METAL6_2014400_1073400 0.0134
R_VDD4_14052 METAL6_2014400_1073400 METAL6_2014400_1073800 0.0008
R_VDD4_14053 METAL6_2014400_1073800 METAL6_2014400_1074000 0.0004
R_VDD4_14054 METAL6_2014400_1074000 METAL6_2014400_1074500 0.001
R_VDD4_14055 METAL6_2014400_1074500 METAL6_2014400_1078700 0.0084
R_VDD4_14056 METAL6_2014400_1078700 METAL6_2014400_1084800 0.0122
R_VDD4_14057 METAL6_2014400_1084800 METAL6_2014400_1085400 0.0012
R_VDD4_14058 METAL6_2014400_1085400 METAL6_2014400_1085800 0.0008
R_VDD4_14059 METAL6_2014400_1085800 METAL6_2014400_1086000 0.0004
R_VDD4_14060 METAL6_2014400_1086000 METAL6_2014400_1086300 0.0006
R_VDD4_14061 METAL6_2014400_1086300 METAL6_2014400_1086500 0.0004
R_VDD4_14062 METAL6_2014400_1086500 METAL6_2014400_1088000 0.003
R_VDD4_14063 METAL6_2014400_1088000 METAL6_2014400_1096800 0.0176
R_VDD4_14064 METAL6_2014400_1096800 METAL6_2014400_1097800 0.002
R_VDD4_14065 METAL6_2014400_1097800 METAL6_2014400_1098000 0.0004
R_VDD4_14066 METAL6_2014400_1098000 METAL6_2014400_1098300 0.0006
R_VDD4_14067 METAL6_2014400_1098300 METAL5_2014400_1098300 0.1
R_VDD4_14068 METAL5_2014400_1098300 METAL5_2014400_1098500 0.0008
R_VDD4_14069 METAL5_2014400_1098500 METAL5_2014400_1100000 0.006
R_VDD4_14070 METAL5_2014400_1100000 METAL5_2014400_1108800 0.0352
R_VDD4_14071 METAL5_2014400_1108800 METAL5_2014400_1110000 0.0048
R_VDD4_14072 METAL5_2014400_1110000 METAL5_2014400_1110300 0.0012
R_VDD4_14073 METAL5_2014400_1110300 METAL5_2014400_1110500 0.0008
R_VDD4_14074 METAL5_2014400_1110500 METAL5_2014400_1112000 0.006
R_VDD4_14075 METAL5_2014400_1112000 METAL5_2014400_1120800 0.0352
R_VDD4_14076 METAL5_2014400_1120800 METAL5_2014400_1122300 0.006
R_VDD4_14077 METAL5_2014400_1122300 METAL5_2014400_1122500 0.0008
R_VDD4_14078 METAL5_2014400_1122500 METAL5_2014400_1129300 0.0272
R_VDD4_14079 METAL5_2014400_1129300 METAL5_2014400_1132800 0.014
R_VDD4_14080 METAL5_2014400_1132800 METAL5_2014400_1134300 0.006
R_VDD4_14081 METAL5_2014400_1134300 METAL5_2014400_1134500 0.0008
R_VDD4_14082 METAL5_2014400_1134500 METAL5_2014400_1141300 0.0272
R_VDD4_14083 METAL5_2014400_1141300 METAL5_2014400_1144800 0.014
R_VDD4_14084 METAL5_2014400_1144800 METAL5_2014400_1146300 0.006
R_VDD4_14085 METAL5_2014400_1146300 METAL5_2014400_1146500 0.0008
R_VDD4_14086 METAL5_2014400_1146500 METAL5_2014400_1153300 0.0272
R_VDD4_14087 METAL5_2014400_1153300 METAL5_2014400_1157700 0.0176
R_VDD4_14088 METAL5_2014400_1157700 METAL5_2014400_1160600 0.0116
R_VDD4_14089 METAL5_2014400_1160600 METAL5_2014400_1165300 0.0188
R_VDD4_14090 METAL5_2014400_1165300 METAL5_2014400_1169700 0.0176
R_VDD4_14091 METAL5_2014400_1169700 METAL5_2014400_1172600 0.0116
R_VDD4_14092 METAL5_2014400_1172600 METAL4_2014400_1172600 0.1
R_VDD4_14093 METAL4_1939800_1129300 METAL4_1939800_1141300 0.096
R_VDD4_14094 METAL5_2014400_1146500 METAL5_2012000_1146500 0.0096
R_VDD4_14095 METAL5_2012000_1146500 METAL5_2007700_1146500 0.0172
R_VDD4_14096 METAL5_2007700_1146500 METAL5_2006900_1146500 0.0032
R_VDD4_14097 METAL5_2006900_1146500 METAL5_2002400_1146500 0.018
R_VDD4_14098 METAL5_2002400_1146500 METAL5_2000000_1146500 0.0096
R_VDD4_14099 METAL5_2000000_1146500 METAL5_1994900_1146500 0.0204
R_VDD4_14100 METAL5_1994900_1146500 METAL5_1988000_1146500 0.0276
R_VDD4_14101 METAL5_1988000_1146500 METAL5_1976000_1146500 0.048
R_VDD4_14102 METAL5_1976000_1146500 METAL5_1976000_1146300 0.0008
R_VDD4_14103 METAL5_1976000_1146300 METAL5_1976000_1144800 0.006
R_VDD4_14104 METAL5_1976000_1144800 METAL5_1976000_1141300 0.014
R_VDD4_14105 METAL5_1976000_1141300 METAL5_1975900_1141300 0.0004
R_VDD4_14106 METAL5_1975900_1141300 METAL5_1975800_1141300 0.0004
R_VDD4_14107 METAL5_1975800_1141300 METAL5_1963900_1141300 0.0476
R_VDD4_14108 METAL5_1963900_1141300 METAL5_1963800_1141300 0.0004
R_VDD4_14109 METAL5_1963800_1141300 METAL5_1951900_1141300 0.0476
R_VDD4_14110 METAL5_1951900_1141300 METAL5_1951800_1141300 0.0004
R_VDD4_14111 METAL5_1951800_1141300 METAL5_1939900_1141300 0.0476
R_VDD4_14112 METAL5_1939900_1141300 METAL5_1939800_1141300 0.0004
R_VDD4_14113 METAL5_1939800_1141300 METAL4_1939800_1141300 0.1
R_VDD4_14114 METAL4_1739800_1129300 METAL4_1739800_1141300 0.096
R_VDD4_14115 METAL5_1988000_983000 METAL5_1976000_983000 0.048
R_VDD4_14116 METAL5_1976000_983000 METAL5_1975900_983000 0.0004
R_VDD4_14117 METAL5_1975900_983000 METAL5_1975800_983000 0.0004
R_VDD4_14118 METAL5_1975800_983000 METAL5_1964000_983000 0.0472
R_VDD4_14119 METAL5_1964000_983000 METAL5_1963900_983000 0.0004
R_VDD4_14120 METAL5_1963900_983000 METAL5_1963800_983000 0.0004
R_VDD4_14121 METAL5_1963800_983000 METAL5_1951900_983000 0.0476
R_VDD4_14122 METAL5_1951900_983000 METAL5_1951800_983000 0.0004
R_VDD4_14123 METAL5_1951800_983000 METAL5_1939900_983000 0.0476
R_VDD4_14124 METAL5_1939900_983000 METAL5_1939800_983000 0.0004
R_VDD4_14125 METAL5_1939800_983000 METAL5_1937600_983000 0.0088
R_VDD4_14126 METAL5_1937600_983000 METAL5_1931200_983000 0.0256
R_VDD4_14127 METAL5_1931200_983000 METAL5_1927800_983000 0.0136
R_VDD4_14128 METAL5_1927800_983000 METAL6_1927800_983000 0.1
R_VDD4_14129 METAL6_1927800_983000 METAL6_1927800_988000 0.01
R_VDD4_14130 METAL6_1927800_988000 METAL6_1926200_988000 0.0032
R_VDD4_14131 METAL6_1926200_988000 METAL6_1926200_989400 0.0028
R_VDD4_14132 METAL6_1926200_989400 METAL6_1926200_995000 0.0112
R_VDD4_14133 METAL6_1926200_995000 METAL6_1926200_1000000 0.01
R_VDD4_14134 METAL6_1926200_1000000 METAL6_1926200_1001400 0.0028
R_VDD4_14135 METAL6_1926200_1001400 METAL6_1926200_1007000 0.0112
R_VDD4_14136 METAL6_1926200_1007000 METAL6_1926200_1012000 0.01
R_VDD4_14137 METAL6_1926200_1012000 METAL6_1926200_1013400 0.0028
R_VDD4_14138 METAL6_1926200_1013400 METAL6_1925600_1013400 0.0012
R_VDD4_14139 METAL6_1925600_1013400 METAL6_1919200_1013400 0.0128
R_VDD4_14140 METAL6_1919200_1013400 METAL6_1919200_1014000 0.0012
R_VDD4_14141 METAL6_1919200_1014000 METAL6_1919200_1019000 0.01
R_VDD4_14142 METAL6_1919200_1019000 METAL6_1919200_1023700 0.0094
R_VDD4_14143 METAL6_1919200_1023700 METAL6_1919200_1025400 0.0034
R_VDD4_14144 METAL6_1919200_1025400 METAL6_1919200_1026000 0.0012
R_VDD4_14145 METAL6_1919200_1026000 METAL6_1919200_1029800 0.0076
R_VDD4_14146 METAL6_1919200_1029800 METAL6_1919200_1031000 0.0024
R_VDD4_14147 METAL6_1919200_1031000 METAL6_1919200_1035700 0.0094
R_VDD4_14148 METAL6_1919200_1035700 METAL6_1919200_1037400 0.0034
R_VDD4_14149 METAL6_1919200_1037400 METAL6_1919200_1038000 0.0012
R_VDD4_14150 METAL6_1919200_1038000 METAL6_1919200_1041800 0.0076
R_VDD4_14151 METAL6_1919200_1041800 METAL6_1919200_1042700 0.0018
R_VDD4_14152 METAL6_1919200_1042700 METAL6_1919200_1043000 0.0006
R_VDD4_14153 METAL6_1919200_1043000 METAL6_1919200_1047700 0.0094
R_VDD4_14154 METAL6_1919200_1047700 METAL6_1919200_1049400 0.0034
R_VDD4_14155 METAL6_1919200_1049400 METAL6_1919200_1049800 0.0008
R_VDD4_14156 METAL6_1919200_1049800 METAL6_1919200_1053800 0.008
R_VDD4_14157 METAL6_1919200_1053800 METAL6_1919200_1054700 0.0018
R_VDD4_14158 METAL6_1919200_1054700 METAL6_1919200_1061400 0.0134
R_VDD4_14159 METAL6_1919200_1061400 METAL6_1919200_1061800 0.0008
R_VDD4_14160 METAL6_1919200_1061800 METAL6_1919200_1066700 0.0098
R_VDD4_14161 METAL6_1919200_1066700 METAL6_1919200_1073400 0.0134
R_VDD4_14162 METAL6_1919200_1073400 METAL6_1919200_1073800 0.0008
R_VDD4_14163 METAL6_1919200_1073800 METAL6_1919200_1074000 0.0004
R_VDD4_14164 METAL6_1919200_1074000 METAL6_1919200_1074500 0.001
R_VDD4_14165 METAL6_1919200_1074500 METAL6_1919200_1078700 0.0084
R_VDD4_14166 METAL6_1919200_1078700 METAL6_1919200_1084800 0.0122
R_VDD4_14167 METAL6_1919200_1084800 METAL6_1919200_1085400 0.0012
R_VDD4_14168 METAL6_1919200_1085400 METAL6_1919200_1085800 0.0008
R_VDD4_14169 METAL6_1919200_1085800 METAL6_1919200_1086000 0.0004
R_VDD4_14170 METAL6_1919200_1086000 METAL6_1919200_1086300 0.0006
R_VDD4_14171 METAL6_1919200_1086300 METAL6_1919200_1086500 0.0004
R_VDD4_14172 METAL6_1919200_1086500 METAL6_1919200_1088000 0.003
R_VDD4_14173 METAL6_1919200_1088000 METAL6_1919200_1096800 0.0176
R_VDD4_14174 METAL6_1919200_1096800 METAL6_1919200_1097800 0.002
R_VDD4_14175 METAL6_1919200_1097800 METAL6_1919200_1098000 0.0004
R_VDD4_14176 METAL6_1919200_1098000 METAL6_1919200_1098300 0.0006
R_VDD4_14177 METAL6_1919200_1098300 METAL6_1919200_1098500 0.0004
R_VDD4_14178 METAL6_1919200_1098500 METAL6_1919200_1100000 0.003
R_VDD4_14179 METAL6_1919200_1100000 METAL6_1919200_1108800 0.0176
R_VDD4_14180 METAL6_1919200_1108800 METAL6_1919200_1110000 0.0024
R_VDD4_14181 METAL6_1919200_1110000 METAL6_1919200_1110300 0.0006
R_VDD4_14182 METAL6_1919200_1110300 METAL6_1919200_1110500 0.0004
R_VDD4_14183 METAL6_1919200_1110500 METAL6_1919200_1112000 0.003
R_VDD4_14184 METAL6_1919200_1112000 METAL6_1919200_1120800 0.0176
R_VDD4_14185 METAL6_1919200_1120800 METAL6_1919200_1122300 0.003
R_VDD4_14186 METAL6_1919200_1122300 METAL6_1919200_1122500 0.0004
R_VDD4_14187 METAL6_1919200_1122500 METAL6_1919200_1129300 0.0136
R_VDD4_14188 METAL6_1919200_1129300 METAL6_1919200_1132800 0.007
R_VDD4_14189 METAL6_1919200_1132800 METAL6_1919200_1134300 0.003
R_VDD4_14190 METAL6_1919200_1134300 METAL5_1919200_1134300 0.1
R_VDD4_14191 METAL5_1919200_1134300 METAL5_1913600_1134300 0.0224
R_VDD4_14192 METAL5_1913600_1134300 METAL5_1913400_1134300 0.0008
R_VDD4_14193 METAL5_1913400_1134300 METAL5_1912700_1134300 0.0028
R_VDD4_14194 METAL5_1912700_1134300 METAL5_1907400_1134300 0.0212
R_VDD4_14195 METAL5_1907400_1134300 METAL5_1907200_1134300 0.0008
R_VDD4_14196 METAL5_1907200_1134300 METAL5_1901600_1134300 0.0224
R_VDD4_14197 METAL5_1901600_1134300 METAL5_1901400_1134300 0.0008
R_VDD4_14198 METAL5_1901400_1134300 METAL5_1900700_1134300 0.0028
R_VDD4_14199 METAL5_1900700_1134300 METAL5_1895200_1134300 0.022
R_VDD4_14200 METAL5_1895200_1134300 METAL5_1889600_1134300 0.0224
R_VDD4_14201 METAL5_1889600_1134300 METAL5_1889400_1134300 0.0008
R_VDD4_14202 METAL5_1889400_1134300 METAL5_1888700_1134300 0.0028
R_VDD4_14203 METAL5_1888700_1134300 METAL5_1883200_1134300 0.022
R_VDD4_14204 METAL5_1883200_1134300 METAL5_1877600_1134300 0.0224
R_VDD4_14205 METAL5_1877600_1134300 METAL5_1877400_1134300 0.0008
R_VDD4_14206 METAL5_1877400_1134300 METAL5_1876700_1134300 0.0028
R_VDD4_14207 METAL5_1876700_1134300 METAL5_1874700_1134300 0.008
R_VDD4_14208 METAL5_1874700_1134300 METAL5_1871200_1134300 0.014
R_VDD4_14209 METAL5_1871200_1134300 METAL5_1870600_1134300 0.0024
R_VDD4_14210 METAL5_1870600_1134300 METAL5_1865600_1134300 0.02
R_VDD4_14211 METAL5_1865600_1134300 METAL5_1865400_1134300 0.0008
R_VDD4_14212 METAL5_1865400_1134300 METAL5_1864700_1134300 0.0028
R_VDD4_14213 METAL5_1864700_1134300 METAL5_1859200_1134300 0.022
R_VDD4_14214 METAL5_1859200_1134300 METAL5_1858600_1134300 0.0024
R_VDD4_14215 METAL5_1858600_1134300 METAL5_1858400_1134300 0.0008
R_VDD4_14216 METAL5_1858400_1134300 METAL5_1853400_1134300 0.02
R_VDD4_14217 METAL5_1853400_1134300 METAL5_1852700_1134300 0.0028
R_VDD4_14218 METAL5_1852700_1134300 METAL5_1847200_1134300 0.022
R_VDD4_14219 METAL5_1847200_1134300 METAL5_1846800_1134300 0.0016
R_VDD4_14220 METAL5_1846800_1134300 METAL5_1846600_1134300 0.0008
R_VDD4_14221 METAL5_1846600_1134300 METAL5_1846400_1134300 0.0008
R_VDD4_14222 METAL5_1846400_1134300 METAL5_1844800_1134300 0.0064
R_VDD4_14223 METAL5_1844800_1134300 METAL5_1841400_1134300 0.0136
R_VDD4_14224 METAL5_1841400_1134300 METAL5_1834600_1134300 0.0272
R_VDD4_14225 METAL5_1834600_1134300 METAL5_1834400_1134300 0.0008
R_VDD4_14226 METAL5_1834400_1134300 METAL6_1834400_1134300 0.1
R_VDD4_14227 METAL6_1834400_1134300 METAL6_1832800_1134300 0.0032
R_VDD4_14228 METAL6_1832800_1134300 METAL6_1822600_1134300 0.0204
R_VDD4_14229 METAL6_1822600_1134300 METAL6_1822600_1134500 0.0004
R_VDD4_14230 METAL6_1822600_1134500 METAL6_1822600_1141300 0.0136
R_VDD4_14231 METAL6_1822600_1141300 METAL6_1822400_1141300 0.0004
R_VDD4_14232 METAL6_1822400_1141300 METAL6_1820800_1141300 0.0032
R_VDD4_14233 METAL6_1820800_1141300 METAL6_1812000_1141300 0.0176
R_VDD4_14234 METAL6_1812000_1141300 METAL6_1810600_1141300 0.0028
R_VDD4_14235 METAL6_1810600_1141300 METAL6_1800000_1141300 0.0212
R_VDD4_14236 METAL6_1800000_1141300 METAL6_1788000_1141300 0.024
R_VDD4_14237 METAL6_1788000_1141300 METAL6_1787400_1141300 0.0012
R_VDD4_14238 METAL6_1787400_1141300 METAL6_1775400_1141300 0.024
R_VDD4_14239 METAL6_1775400_1141300 METAL6_1768000_1141300 0.0148
R_VDD4_14240 METAL6_1768000_1141300 METAL6_1767700_1141300 0.0006
R_VDD4_14241 METAL6_1767700_1141300 METAL6_1763800_1141300 0.0078
R_VDD4_14242 METAL6_1763800_1141300 METAL6_1763400_1141300 0.0008
R_VDD4_14243 METAL6_1763400_1141300 METAL6_1756000_1141300 0.0148
R_VDD4_14244 METAL6_1756000_1141300 METAL6_1755700_1141300 0.0006
R_VDD4_14245 METAL6_1755700_1141300 METAL6_1753800_1141300 0.0038
R_VDD4_14246 METAL6_1753800_1141300 METAL6_1751800_1141300 0.004
R_VDD4_14247 METAL6_1751800_1141300 METAL6_1751400_1141300 0.0008
R_VDD4_14248 METAL6_1751400_1141300 METAL6_1744000_1141300 0.0148
R_VDD4_14249 METAL6_1744000_1141300 METAL6_1743700_1141300 0.0006
R_VDD4_14250 METAL6_1743700_1141300 METAL6_1741800_1141300 0.0038
R_VDD4_14251 METAL6_1741800_1141300 METAL6_1739800_1141300 0.004
R_VDD4_14252 METAL6_1739800_1141300 METAL5_1739800_1141300 0.1
R_VDD4_14253 METAL5_1739800_1141300 METAL4_1739800_1141300 0.1
R_VDD4_14254 METAL4_2153400_709800 METAL4_2153400_712000 0.0176
R_VDD4_14255 METAL4_2153400_712000 METAL4_2153400_716800 0.0384
R_VDD4_14256 METAL4_2153400_716800 METAL4_2153400_721800 0.04
R_VDD4_14257 METAL6_1500000_9500 METAL5_1500000_9500 0.1
R_VDD4_14258 METAL5_1500000_9500 METAL5_1500000_16000 0.026
R_VDD4_14259 METAL5_1500000_16000 METAL5_1500000_16600 0.0024
R_VDD4_14260 METAL5_1500000_16600 METAL5_1500000_21500 0.0196
R_VDD4_14261 METAL5_1500000_21500 METAL5_1503400_21500 0.0136
R_VDD4_14262 METAL5_1503400_21500 METAL5_1510400_21500 0.028
R_VDD4_14263 METAL5_1510400_21500 METAL5_1512000_21500 0.0064
R_VDD4_14264 METAL5_1512000_21500 METAL5_1515800_21500 0.0152
R_VDD4_14265 METAL5_1515800_21500 METAL5_1527800_21500 0.048
R_VDD4_14266 METAL5_1527800_21500 METAL5_1528000_21500 0.0008
R_VDD4_14267 METAL5_1528000_21500 METAL5_1539800_21500 0.0472
R_VDD4_14268 METAL5_1539800_21500 METAL5_1540000_21500 0.0008
R_VDD4_14269 METAL5_1540000_21500 METAL5_1545000_21500 0.02
R_VDD4_14270 METAL5_1545000_21500 METAL5_1551800_21500 0.0272
R_VDD4_14271 METAL5_1551800_21500 METAL5_1552000_21500 0.0008
R_VDD4_14272 METAL5_1552000_21500 METAL5_1555400_21500 0.0136
R_VDD4_14273 METAL5_1555400_21500 METAL5_1555800_21500 0.0016
R_VDD4_14274 METAL5_1555800_21500 METAL5_1557000_21500 0.0048
R_VDD4_14275 METAL5_1557000_21500 METAL5_1564000_21500 0.028
R_VDD4_14276 METAL5_1564000_21500 METAL5_1567800_21500 0.0152
R_VDD4_14277 METAL5_1567800_21500 METAL5_1569000_21500 0.0048
R_VDD4_14278 METAL5_1569000_21500 METAL5_1574700_21500 0.0228
R_VDD4_14279 METAL5_1574700_21500 METAL5_1576000_21500 0.0052
R_VDD4_14280 METAL5_1576000_21500 METAL5_1576700_21500 0.0028
R_VDD4_14281 METAL5_1576700_21500 METAL5_1579800_21500 0.0124
R_VDD4_14282 METAL5_1579800_21500 METAL5_1588000_21500 0.0328
R_VDD4_14283 METAL5_1588000_21500 METAL5_1588700_21500 0.0028
R_VDD4_14284 METAL5_1588700_21500 METAL5_1591800_21500 0.0124
R_VDD4_14285 METAL5_1591800_21500 METAL5_1600000_21500 0.0328
R_VDD4_14286 METAL5_1600000_21500 METAL5_1600700_21500 0.0028
R_VDD4_14287 METAL5_1600700_21500 METAL5_1603800_21500 0.0124
R_VDD4_14288 METAL5_1603800_21500 METAL5_1607900_21500 0.0164
R_VDD4_14289 METAL5_1607900_21500 METAL5_1612000_21500 0.0164
R_VDD4_14290 METAL5_1612000_21500 METAL6_1612000_21500 0.1
R_VDD4_14291 METAL6_1612000_21500 METAL6_1612000_28000 0.013
R_VDD4_14292 METAL6_1612000_28000 METAL6_1612700_28000 0.0014
R_VDD4_14293 METAL6_1612700_28000 METAL6_1615800_28000 0.0062
R_VDD4_14294 METAL6_1615800_28000 METAL6_1624000_28000 0.0164
R_VDD4_14295 METAL6_1624000_28000 METAL6_1624700_28000 0.0014
R_VDD4_14296 METAL6_1624700_28000 METAL6_1627800_28000 0.0062
R_VDD4_14297 METAL6_1627800_28000 METAL6_1632800_28000 0.01
R_VDD4_14298 METAL6_1632800_28000 METAL6_1634800_28000 0.004
R_VDD4_14299 METAL6_1634800_28000 METAL6_1636000_28000 0.0024
R_VDD4_14300 METAL6_1636000_28000 METAL6_1636700_28000 0.0014
R_VDD4_14301 METAL6_1636700_28000 METAL6_1646800_28000 0.0202
R_VDD4_14302 METAL6_1646800_28000 METAL6_1648000_28000 0.0024
R_VDD4_14303 METAL6_1648000_28000 METAL6_1648700_28000 0.0014
R_VDD4_14304 METAL6_1648700_28000 METAL6_1658800_28000 0.0202
R_VDD4_14305 METAL6_1658800_28000 METAL6_1660700_28000 0.0038
R_VDD4_14306 METAL6_1660700_28000 METAL6_1668000_28000 0.0146
R_VDD4_14307 METAL6_1668000_28000 METAL6_1670800_28000 0.0056
R_VDD4_14308 METAL6_1670800_28000 METAL6_1680000_28000 0.0184
R_VDD4_14309 METAL6_1680000_28000 METAL6_1682800_28000 0.0056
R_VDD4_14310 METAL6_1682800_28000 METAL6_1692000_28000 0.0184
R_VDD4_14311 METAL6_1692000_28000 METAL6_1699000_28000 0.014
R_VDD4_14312 METAL6_1699000_28000 METAL6_1707700_28000 0.0174
R_VDD4_14313 METAL6_1707700_28000 METAL6_1710800_28000 0.0062
R_VDD4_14314 METAL6_1710800_28000 METAL6_1717800_28000 0.014
R_VDD4_14315 METAL6_1717800_28000 METAL6_1719700_28000 0.0038
R_VDD4_14316 METAL6_1719700_28000 METAL6_1727800_28000 0.0162
R_VDD4_14317 METAL6_1727800_28000 METAL6_1729800_28000 0.004
R_VDD4_14318 METAL6_1729800_28000 METAL6_1731700_28000 0.0038
R_VDD4_14319 METAL6_1731700_28000 METAL6_1731700_28600 0.0012
R_VDD4_14320 METAL6_1731700_28600 METAL6_1731700_33500 0.0098
R_VDD4_14321 METAL6_1731700_33500 METAL6_1731700_40000 0.013
R_VDD4_14322 METAL6_1731700_40000 METAL6_1732000_40000 0.0006
R_VDD4_14323 METAL6_1732000_40000 METAL6_1739400_40000 0.0148
R_VDD4_14324 METAL6_1739400_40000 METAL6_1739800_40000 0.0008
R_VDD4_14325 METAL6_1739800_40000 METAL6_1741800_40000 0.004
R_VDD4_14326 METAL6_1741800_40000 METAL6_1743700_40000 0.0038
R_VDD4_14327 METAL6_1743700_40000 METAL6_1743700_40600 0.0012
R_VDD4_14328 METAL6_1743700_40600 METAL5_1743700_40600 0.1
R_VDD4_14329 METAL5_1743700_40600 METAL5_1744000_40600 0.0012
R_VDD4_14330 METAL5_1744000_40600 METAL5_1751400_40600 0.0296
R_VDD4_14331 METAL5_1751400_40600 METAL5_1751800_40600 0.0016
R_VDD4_14332 METAL5_1751800_40600 METAL5_1753800_40600 0.008
R_VDD4_14333 METAL5_1753800_40600 METAL5_1755700_40600 0.0076
R_VDD4_14334 METAL5_1755700_40600 METAL5_1756000_40600 0.0012
R_VDD4_14335 METAL5_1756000_40600 METAL5_1763400_40600 0.0296
R_VDD4_14336 METAL5_1763400_40600 METAL5_1763800_40600 0.0016
R_VDD4_14337 METAL5_1763800_40600 METAL5_1767700_40600 0.0156
R_VDD4_14338 METAL5_1767700_40600 METAL5_1768000_40600 0.0012
R_VDD4_14339 METAL5_1768000_40600 METAL5_1775400_40600 0.0296
R_VDD4_14340 METAL5_1775400_40600 METAL5_1787400_40600 0.048
R_VDD4_14341 METAL5_1787400_40600 METAL6_1787400_40600 0.1
R_VDD4_14342 METAL6_1787400_40600 METAL6_1787400_52000 0.0228
R_VDD4_14343 METAL6_1787400_52000 METAL6_1788000_52000 0.0012
R_VDD4_14344 METAL6_1788000_52000 METAL6_1800000_52000 0.024
R_VDD4_14345 METAL6_1800000_52000 METAL6_1810600_52000 0.0212
R_VDD4_14346 METAL6_1810600_52000 METAL6_1810600_52600 0.0012
R_VDD4_14347 METAL6_1810600_52600 METAL6_1810600_64000 0.0228
R_VDD4_14348 METAL6_1810600_64000 METAL6_1810600_64600 0.0012
R_VDD4_14349 METAL6_1810600_64600 METAL6_1810600_71600 0.014
R_VDD4_14350 METAL6_1810600_71600 METAL6_1810600_76000 0.0088
R_VDD4_14351 METAL6_1810600_76000 METAL6_1810600_76600 0.0012
R_VDD4_14352 METAL6_1810600_76600 METAL6_1810600_83600 0.014
R_VDD4_14353 METAL6_1810600_83600 METAL6_1810600_88000 0.0088
R_VDD4_14354 METAL6_1810600_88000 METAL6_1810600_88600 0.0012
R_VDD4_14355 METAL6_1810600_88600 METAL6_1810600_95600 0.014
R_VDD4_14356 METAL6_1810600_95600 METAL6_1810600_100000 0.0088
R_VDD4_14357 METAL6_1810600_100000 METAL6_1810600_100600 0.0012
R_VDD4_14358 METAL6_1810600_100600 METAL6_1810600_112000 0.0228
R_VDD4_14359 METAL6_1810600_112000 METAL6_1810600_147600 0.0712
R_VDD4_14360 METAL6_1810600_147600 METAL6_1810600_159600 0.024
R_VDD4_14361 METAL6_1810600_159600 METAL6_1810600_164000 0.0088
R_VDD4_14362 METAL6_1810600_164000 METAL6_1810600_166600 0.0052
R_VDD4_14363 METAL6_1810600_166600 METAL6_1810600_171600 0.01
R_VDD4_14364 METAL6_1810600_171600 METAL6_1810600_176000 0.0088
R_VDD4_14365 METAL6_1810600_176000 METAL6_1810600_178600 0.0052
R_VDD4_14366 METAL6_1810600_178600 METAL6_1810600_188000 0.0188
R_VDD4_14367 METAL6_1810600_188000 METAL6_1810600_190600 0.0052
R_VDD4_14368 METAL6_1810600_190600 METAL6_1810600_200000 0.0188
R_VDD4_14369 METAL6_1810600_200000 METAL6_1810600_202600 0.0052
R_VDD4_14370 METAL6_1810600_202600 METAL6_1810600_212000 0.0188
R_VDD4_14371 METAL6_1810600_212000 METAL6_1810600_214600 0.0052
R_VDD4_14372 METAL6_1810600_214600 METAL6_1810600_224300 0.0194
R_VDD4_14373 METAL6_1810600_224300 METAL6_1810600_226600 0.0046
R_VDD4_14374 METAL6_1810600_226600 METAL6_1810600_236300 0.0194
R_VDD4_14375 METAL6_1810600_236300 METAL6_1810600_248300 0.024
R_VDD4_14376 METAL6_1810600_248300 METAL6_1810600_251000 0.0054
R_VDD4_14377 METAL6_1810600_251000 METAL6_1810600_260300 0.0186
R_VDD4_14378 METAL6_1810600_260300 METAL6_1810600_263000 0.0054
R_VDD4_14379 METAL6_1810600_263000 METAL6_1810600_272300 0.0186
R_VDD4_14380 METAL6_1810600_272300 METAL6_1810600_275000 0.0054
R_VDD4_14381 METAL6_1810600_275000 METAL6_1810600_279300 0.0086
R_VDD4_14382 METAL6_1810600_279300 METAL6_1810600_287000 0.0154
R_VDD4_14383 METAL6_1810600_287000 METAL6_1810600_288000 0.002
R_VDD4_14384 METAL6_1810600_288000 METAL6_1810600_299000 0.022
R_VDD4_14385 METAL6_1810600_299000 METAL6_1810600_300000 0.002
R_VDD4_14386 METAL6_1810600_300000 METAL6_1810600_311000 0.022
R_VDD4_14387 METAL6_1810600_311000 METAL6_1810600_312000 0.002
R_VDD4_14388 METAL6_1810600_312000 METAL6_1810600_323000 0.022
R_VDD4_14389 METAL6_1810600_323000 METAL6_1810600_354800 0.0636
R_VDD4_14390 METAL6_1810600_354800 METAL6_1810600_355300 0.001
R_VDD4_14391 METAL6_1810600_355300 METAL6_1810600_362300 0.014
R_VDD4_14392 METAL6_1810600_362300 METAL6_1810600_366800 0.009
R_VDD4_14393 METAL6_1810600_366800 METAL6_1810600_374300 0.015
R_VDD4_14394 METAL6_1810600_374300 METAL6_1810600_377000 0.0054
R_VDD4_14395 METAL6_1810600_377000 METAL6_1810600_378800 0.0036
R_VDD4_14396 METAL6_1810600_378800 METAL6_1810600_386300 0.015
R_VDD4_14397 METAL6_1810600_386300 METAL6_1810600_388000 0.0034
R_VDD4_14398 METAL6_1810600_388000 METAL6_1810600_389000 0.002
R_VDD4_14399 METAL6_1810600_389000 METAL6_1810600_390800 0.0036
R_VDD4_14400 METAL6_1810600_390800 METAL6_1810600_400000 0.0184
R_VDD4_14401 METAL6_1810600_400000 METAL6_1810600_401000 0.002
R_VDD4_14402 METAL6_1810600_401000 METAL6_1810600_402800 0.0036
R_VDD4_14403 METAL6_1810600_402800 METAL6_1810600_412000 0.0184
R_VDD4_14404 METAL6_1810600_412000 METAL6_1810600_413000 0.002
R_VDD4_14405 METAL6_1810600_413000 METAL6_1810600_414800 0.0036
R_VDD4_14406 METAL6_1810600_414800 METAL6_1810600_424000 0.0184
R_VDD4_14407 METAL6_1810600_424000 METAL6_1810600_425000 0.002
R_VDD4_14408 METAL6_1810600_425000 METAL6_1810600_426800 0.0036
R_VDD4_14409 METAL6_1810600_426800 METAL6_1810600_432400 0.0112
R_VDD4_14410 METAL6_1810600_432400 METAL6_1810600_437000 0.0092
R_VDD4_14411 METAL6_1810600_437000 METAL6_1810600_438800 0.0036
R_VDD4_14412 METAL6_1810600_438800 METAL6_1810600_444400 0.0112
R_VDD4_14413 METAL6_1810600_444400 METAL6_1810600_447000 0.0052
R_VDD4_14414 METAL6_1810600_447000 METAL6_1810600_449000 0.004
R_VDD4_14415 METAL6_1810600_449000 METAL6_1810600_453000 0.008
R_VDD4_14416 METAL6_1810600_453000 METAL6_1810600_456400 0.0068
R_VDD4_14417 METAL6_1810600_456400 METAL6_1810600_459000 0.0052
R_VDD4_14418 METAL6_1810600_459000 METAL6_1810600_461000 0.004
R_VDD4_14419 METAL6_1810600_461000 METAL6_1810600_465000 0.008
R_VDD4_14420 METAL6_1810600_465000 METAL6_1810600_468400 0.0068
R_VDD4_14421 METAL6_1810600_468400 METAL6_1810600_471000 0.0052
R_VDD4_14422 METAL6_1810600_471000 METAL6_1810600_473000 0.004
R_VDD4_14423 METAL6_1810600_473000 METAL5_1810600_473000 0.1
R_VDD4_14424 METAL5_1810600_473000 METAL5_1812000_473000 0.0056
R_VDD4_14425 METAL5_1812000_473000 METAL5_1820800_473000 0.0352
R_VDD4_14426 METAL5_1820800_473000 METAL5_1822400_473000 0.0064
R_VDD4_14427 METAL5_1822400_473000 METAL5_1822600_473000 0.0008
R_VDD4_14428 METAL5_1822600_473000 METAL5_1832800_473000 0.0408
R_VDD4_14429 METAL5_1832800_473000 METAL5_1834400_473000 0.0064
R_VDD4_14430 METAL5_1834400_473000 METAL5_1834600_473000 0.0008
R_VDD4_14431 METAL5_1834600_473000 METAL5_1841400_473000 0.0272
R_VDD4_14432 METAL5_1841400_473000 METAL5_1844800_473000 0.0136
R_VDD4_14433 METAL5_1844800_473000 METAL5_1846400_473000 0.0064
R_VDD4_14434 METAL5_1846400_473000 METAL5_1846600_473000 0.0008
R_VDD4_14435 METAL5_1846600_473000 METAL5_1846800_473000 0.0008
R_VDD4_14436 METAL5_1846800_473000 METAL5_1847200_473000 0.0016
R_VDD4_14437 METAL5_1847200_473000 METAL5_1852700_473000 0.022
R_VDD4_14438 METAL5_1852700_473000 METAL5_1853400_473000 0.0028
R_VDD4_14439 METAL5_1853400_473000 METAL5_1858400_473000 0.02
R_VDD4_14440 METAL5_1858400_473000 METAL5_1858600_473000 0.0008
R_VDD4_14441 METAL5_1858600_473000 METAL5_1859200_473000 0.0024
R_VDD4_14442 METAL5_1859200_473000 METAL5_1864700_473000 0.022
R_VDD4_14443 METAL5_1864700_473000 METAL5_1865400_473000 0.0028
R_VDD4_14444 METAL5_1865400_473000 METAL5_1865600_473000 0.0008
R_VDD4_14445 METAL5_1865600_473000 METAL5_1870600_473000 0.02
R_VDD4_14446 METAL5_1870600_473000 METAL5_1871200_473000 0.0024
R_VDD4_14447 METAL5_1871200_473000 METAL5_1874700_473000 0.014
R_VDD4_14448 METAL5_1874700_473000 METAL5_1876700_473000 0.008
R_VDD4_14449 METAL5_1876700_473000 METAL5_1877400_473000 0.0028
R_VDD4_14450 METAL5_1877400_473000 METAL5_1877600_473000 0.0008
R_VDD4_14451 METAL5_1877600_473000 METAL5_1883200_473000 0.0224
R_VDD4_14452 METAL5_1883200_473000 METAL5_1888700_473000 0.022
R_VDD4_14453 METAL5_1888700_473000 METAL5_1889400_473000 0.0028
R_VDD4_14454 METAL5_1889400_473000 METAL5_1889600_473000 0.0008
R_VDD4_14455 METAL5_1889600_473000 METAL5_1895200_473000 0.0224
R_VDD4_14456 METAL5_1895200_473000 METAL5_1900700_473000 0.022
R_VDD4_14457 METAL5_1900700_473000 METAL5_1901400_473000 0.0028
R_VDD4_14458 METAL5_1901400_473000 METAL5_1901600_473000 0.0008
R_VDD4_14459 METAL5_1901600_473000 METAL5_1907200_473000 0.0224
R_VDD4_14460 METAL5_1907200_473000 METAL5_1907400_473000 0.0008
R_VDD4_14461 METAL5_1907400_473000 METAL5_1912700_473000 0.0212
R_VDD4_14462 METAL5_1912700_473000 METAL6_1912700_473000 0.1
R_VDD4_14463 METAL6_1912700_473000 METAL6_1912700_477000 0.008
R_VDD4_14464 METAL6_1912700_477000 METAL6_1912700_480000 0.006
R_VDD4_14465 METAL6_1912700_480000 METAL6_1913400_480000 0.0014
R_VDD4_14466 METAL6_1913400_480000 METAL6_1913400_480400 0.0008
R_VDD4_14467 METAL6_1913400_480400 METAL6_1913400_483000 0.0052
R_VDD4_14468 METAL6_1913400_483000 METAL6_1913400_488000 0.01
R_VDD4_14469 METAL6_1913400_488000 METAL6_1913400_492000 0.008
R_VDD4_14470 METAL6_1913400_492000 METAL6_1913400_492400 0.0008
R_VDD4_14471 METAL6_1913400_492400 METAL6_1913400_495000 0.0052
R_VDD4_14472 METAL6_1913400_495000 METAL6_1913400_500000 0.01
R_VDD4_14473 METAL6_1913400_500000 METAL6_1913400_504000 0.008
R_VDD4_14474 METAL6_1913400_504000 METAL6_1913400_504400 0.0008
R_VDD4_14475 METAL6_1913400_504400 METAL6_1913400_507000 0.0052
R_VDD4_14476 METAL6_1913400_507000 METAL6_1913400_507800 0.0016
R_VDD4_14477 METAL6_1913400_507800 METAL6_1913400_512000 0.0084
R_VDD4_14478 METAL6_1913400_512000 METAL6_1913400_516000 0.008
R_VDD4_14479 METAL6_1913400_516000 METAL6_1913400_516400 0.0008
R_VDD4_14480 METAL6_1913400_516400 METAL6_1913400_519000 0.0052
R_VDD4_14481 METAL6_1913400_519000 METAL6_1913400_520200 0.0024
R_VDD4_14482 METAL6_1913400_520200 METAL6_1913400_528000 0.0156
R_VDD4_14483 METAL6_1913400_528000 METAL6_1913400_532200 0.0084
R_VDD4_14484 METAL6_1913400_532200 METAL6_1913400_535400 0.0064
R_VDD4_14485 METAL6_1913400_535400 METAL6_1913400_538400 0.006
R_VDD4_14486 METAL6_1913400_538400 METAL6_1913400_544200 0.0116
R_VDD4_14487 METAL6_1913400_544200 METAL6_1913400_547400 0.0064
R_VDD4_14488 METAL6_1913400_547400 METAL6_1913400_550400 0.006
R_VDD4_14489 METAL6_1913400_550400 METAL6_1913400_556200 0.0116
R_VDD4_14490 METAL6_1913400_556200 METAL6_1913400_559400 0.0064
R_VDD4_14491 METAL6_1913400_559400 METAL6_1913400_561000 0.0032
R_VDD4_14492 METAL6_1913400_561000 METAL6_1913400_562400 0.0028
R_VDD4_14493 METAL6_1913400_562400 METAL6_1913400_568200 0.0116
R_VDD4_14494 METAL6_1913400_568200 METAL6_1913400_571400 0.0064
R_VDD4_14495 METAL6_1913400_571400 METAL6_1913400_573000 0.0032
R_VDD4_14496 METAL6_1913400_573000 METAL6_1913400_574400 0.0028
R_VDD4_14497 METAL6_1913400_574400 METAL6_1913400_579800 0.0108
R_VDD4_14498 METAL6_1913400_579800 METAL6_1913400_585000 0.0104
R_VDD4_14499 METAL6_1913400_585000 METAL6_1913400_586400 0.0028
R_VDD4_14500 METAL6_1913400_586400 METAL6_1913400_588000 0.0032
R_VDD4_14501 METAL6_1913400_588000 METAL6_1913400_597000 0.018
R_VDD4_14502 METAL6_1913400_597000 METAL6_1913400_598400 0.0028
R_VDD4_14503 METAL6_1913400_598400 METAL6_1913400_600000 0.0032
R_VDD4_14504 METAL6_1913400_600000 METAL6_1913400_605400 0.0108
R_VDD4_14505 METAL6_1913400_605400 METAL6_1913400_610400 0.01
R_VDD4_14506 METAL6_1913400_610400 METAL6_1913400_612000 0.0032
R_VDD4_14507 METAL6_1913400_612000 METAL6_1913400_617400 0.0108
R_VDD4_14508 METAL6_1913400_617400 METAL6_1913400_629400 0.024
R_VDD4_14509 METAL6_1913400_629400 METAL6_1913400_637800 0.0168
R_VDD4_14510 METAL6_1913400_637800 METAL6_1913400_641400 0.0072
R_VDD4_14511 METAL6_1913400_641400 METAL6_1913400_649800 0.0168
R_VDD4_14512 METAL6_1913400_649800 METAL6_1913400_653400 0.0072
R_VDD4_14513 METAL6_1913400_653400 METAL6_1913400_661800 0.0168
R_VDD4_14514 METAL6_1913400_661800 METAL6_1913400_665400 0.0072
R_VDD4_14515 METAL6_1913400_665400 METAL6_1913400_685800 0.0408
R_VDD4_14516 METAL6_1913400_685800 METAL6_1913400_688000 0.0044
R_VDD4_14517 METAL6_1913400_688000 METAL6_1913400_697800 0.0196
R_VDD4_14518 METAL6_1913400_697800 METAL6_1913400_700000 0.0044
R_VDD4_14519 METAL6_1913400_700000 METAL6_1913400_702800 0.0056
R_VDD4_14520 METAL6_1913400_702800 METAL6_1913400_704800 0.004
R_VDD4_14521 METAL6_1913400_704800 METAL6_1913400_709800 0.01
R_VDD4_14522 METAL6_1913400_709800 METAL6_1913400_712000 0.0044
R_VDD4_14523 METAL6_1913400_712000 METAL6_1913400_716800 0.0096
R_VDD4_14524 METAL6_1913400_716800 METAL6_1913400_721800 0.01
R_VDD4_14525 METAL6_1913400_721800 METAL6_1913600_721800 0.0004
R_VDD4_14526 METAL6_1913600_721800 METAL6_1914200_721800 0.0012
R_VDD4_14527 METAL6_1914200_721800 METAL6_1915800_721800 0.0032
R_VDD4_14528 METAL6_1915800_721800 METAL6_1919200_721800 0.0068
R_VDD4_14529 METAL6_1919200_721800 METAL6_1925600_721800 0.0128
R_VDD4_14530 METAL6_1925600_721800 METAL6_1926200_721800 0.0012
R_VDD4_14531 METAL6_1926200_721800 METAL6_1927800_721800 0.0032
R_VDD4_14532 METAL6_1927800_721800 METAL6_1931200_721800 0.0068
R_VDD4_14533 METAL6_1931200_721800 METAL6_1937600_721800 0.0128
R_VDD4_14534 METAL6_1937600_721800 METAL6_1938200_721800 0.0012
R_VDD4_14535 METAL6_1938200_721800 METAL6_1939800_721800 0.0032
R_VDD4_14536 METAL6_1939800_721800 METAL6_1939900_721800 0.0002
R_VDD4_14537 METAL6_1939900_721800 METAL6_1951800_721800 0.0238
R_VDD4_14538 METAL6_1951800_721800 METAL6_1951900_721800 0.0002
R_VDD4_14539 METAL6_1951900_721800 METAL6_1963800_721800 0.0238
R_VDD4_14540 METAL6_1963800_721800 METAL6_1963900_721800 0.0002
R_VDD4_14541 METAL6_1963900_721800 METAL6_1964000_721800 0.0002
R_VDD4_14542 METAL6_1964000_721800 METAL6_1975800_721800 0.0236
R_VDD4_14543 METAL6_1975800_721800 METAL6_1975900_721800 0.0002
R_VDD4_14544 METAL6_1975900_721800 METAL6_1976000_721800 0.0002
R_VDD4_14545 METAL6_1976000_721800 METAL6_1988000_721800 0.024
R_VDD4_14546 METAL6_1988000_721800 METAL6_1994900_721800 0.0138
R_VDD4_14547 METAL6_1994900_721800 METAL6_2000000_721800 0.0102
R_VDD4_14548 METAL6_2000000_721800 METAL6_2002400_721800 0.0048
R_VDD4_14549 METAL6_2002400_721800 METAL6_2006900_721800 0.009
R_VDD4_14550 METAL6_2006900_721800 METAL6_2007700_721800 0.0016
R_VDD4_14551 METAL6_2007700_721800 METAL6_2012000_721800 0.0086
R_VDD4_14552 METAL6_2012000_721800 METAL6_2014400_721800 0.0048
R_VDD4_14553 METAL6_2014400_721800 METAL6_2018900_721800 0.009
R_VDD4_14554 METAL6_2018900_721800 METAL6_2019700_721800 0.0016
R_VDD4_14555 METAL6_2019700_721800 METAL6_2021200_721800 0.003
R_VDD4_14556 METAL6_2021200_721800 METAL6_2026400_721800 0.0104
R_VDD4_14557 METAL6_2026400_721800 METAL6_2030900_721800 0.009
R_VDD4_14558 METAL6_2030900_721800 METAL6_2031700_721800 0.0016
R_VDD4_14559 METAL6_2031700_721800 METAL6_2034800_721800 0.0062
R_VDD4_14560 METAL6_2034800_721800 METAL6_2043700_721800 0.0178
R_VDD4_14561 METAL6_2043700_721800 METAL6_2046400_721800 0.0054
R_VDD4_14562 METAL6_2046400_721800 METAL6_2046600_721800 0.0004
R_VDD4_14563 METAL6_2046600_721800 METAL6_2046800_721800 0.0004
R_VDD4_14564 METAL6_2046800_721800 METAL6_2055700_721800 0.0178
R_VDD4_14565 METAL6_2055700_721800 METAL6_2058800_721800 0.0062
R_VDD4_14566 METAL6_2058800_721800 METAL6_2060600_721800 0.0036
R_VDD4_14567 METAL6_2060600_721800 METAL6_2067700_721800 0.0142
R_VDD4_14568 METAL6_2067700_721800 METAL6_2077900_721800 0.0204
R_VDD4_14569 METAL6_2077900_721800 METAL6_2079700_721800 0.0036
R_VDD4_14570 METAL6_2079700_721800 METAL6_2089900_721800 0.0204
R_VDD4_14571 METAL6_2089900_721800 METAL6_2091700_721800 0.0036
R_VDD4_14572 METAL6_2091700_721800 METAL6_2101600_721800 0.0198
R_VDD4_14573 METAL6_2101600_721800 METAL6_2101900_721800 0.0006
R_VDD4_14574 METAL6_2101900_721800 METAL6_2105900_721800 0.008
R_VDD4_14575 METAL6_2105900_721800 METAL6_2113600_721800 0.0154
R_VDD4_14576 METAL6_2113600_721800 METAL6_2113900_721800 0.0006
R_VDD4_14577 METAL6_2113900_721800 METAL6_2117900_721800 0.008
R_VDD4_14578 METAL6_2117900_721800 METAL6_2121400_721800 0.007
R_VDD4_14579 METAL6_2121400_721800 METAL6_2125600_721800 0.0084
R_VDD4_14580 METAL6_2125600_721800 METAL6_2125900_721800 0.0006
R_VDD4_14581 METAL6_2125900_721800 METAL6_2129700_721800 0.0076
R_VDD4_14582 METAL6_2129700_721800 METAL6_2129900_721800 0.0004
R_VDD4_14583 METAL6_2129900_721800 METAL6_2141400_721800 0.023
R_VDD4_14584 METAL6_2141400_721800 METAL6_2141900_721800 0.001
R_VDD4_14585 METAL6_2141900_721800 METAL6_2151900_721800 0.02
R_VDD4_14586 METAL6_2151900_721800 METAL6_2153400_721800 0.003
R_VDD4_14587 METAL6_2153400_721800 METAL5_2153400_721800 0.1
R_VDD4_14588 METAL5_2153400_721800 METAL4_2153400_721800 0.1
R_VDD4_14589 METAL4_1539800_1129300 METAL4_1539800_1141300 0.096
R_VDD4_14590 METAL6_1913400_688000 METAL5_1913400_688000 0.1
R_VDD4_14591 METAL5_1913400_688000 METAL5_1913400_697800 0.0392
R_VDD4_14592 METAL5_1913400_697800 METAL5_1913400_700000 0.0088
R_VDD4_14593 METAL5_1913400_700000 METAL5_1913400_702800 0.0112
R_VDD4_14594 METAL5_1913400_702800 METAL5_1913400_704800 0.008
R_VDD4_14595 METAL5_1913400_704800 METAL5_1913400_709800 0.02
R_VDD4_14596 METAL5_1913400_709800 METAL5_1913400_712000 0.0088
R_VDD4_14597 METAL5_1913400_712000 METAL5_1913400_716800 0.0192
R_VDD4_14598 METAL5_1913400_716800 METAL5_1913400_721800 0.02
R_VDD4_14599 METAL5_1913400_721800 METAL5_1912700_721800 0.0028
R_VDD4_14600 METAL5_1912700_721800 METAL5_1907400_721800 0.0212
R_VDD4_14601 METAL5_1907400_721800 METAL5_1907400_722400 0.0024
R_VDD4_14602 METAL5_1907400_722400 METAL5_1907400_728800 0.0256
R_VDD4_14603 METAL5_1907400_728800 METAL5_1907400_733800 0.02
R_VDD4_14604 METAL5_1907400_733800 METAL5_1907400_734400 0.0024
R_VDD4_14605 METAL5_1907400_734400 METAL5_1907400_735400 0.004
R_VDD4_14606 METAL5_1907400_735400 METAL5_1907400_742400 0.028
R_VDD4_14607 METAL5_1907400_742400 METAL5_1907400_745800 0.0136
R_VDD4_14608 METAL5_1907400_745800 METAL5_1907400_746400 0.0024
R_VDD4_14609 METAL5_1907400_746400 METAL5_1907400_754400 0.032
R_VDD4_14610 METAL5_1907400_754400 METAL5_1907400_757800 0.0136
R_VDD4_14611 METAL5_1907400_757800 METAL5_1907400_758400 0.0024
R_VDD4_14612 METAL5_1907400_758400 METAL5_1907400_760000 0.0064
R_VDD4_14613 METAL5_1907400_760000 METAL5_1907400_763000 0.012
R_VDD4_14614 METAL5_1907400_763000 METAL5_1907400_766400 0.0136
R_VDD4_14615 METAL5_1907400_766400 METAL5_1907400_769800 0.0136
R_VDD4_14616 METAL5_1907400_769800 METAL5_1907400_770400 0.0024
R_VDD4_14617 METAL5_1907400_770400 METAL5_1907400_772000 0.0064
R_VDD4_14618 METAL5_1907400_772000 METAL5_1907400_772500 0.002
R_VDD4_14619 METAL5_1907400_772500 METAL5_1907400_778400 0.0236
R_VDD4_14620 METAL5_1907400_778400 METAL5_1907400_779200 0.0032
R_VDD4_14621 METAL5_1907400_779200 METAL5_1907400_781800 0.0104
R_VDD4_14622 METAL5_1907400_781800 METAL5_1907400_782400 0.0024
R_VDD4_14623 METAL5_1907400_782400 METAL5_1907400_782800 0.0016
R_VDD4_14624 METAL5_1907400_782800 METAL5_1907400_784000 0.0048
R_VDD4_14625 METAL5_1907400_784000 METAL5_1907400_784500 0.002
R_VDD4_14626 METAL5_1907400_784500 METAL5_1907400_788000 0.014
R_VDD4_14627 METAL5_1907400_788000 METAL5_1907400_790400 0.0096
R_VDD4_14628 METAL5_1907400_790400 METAL5_1907400_791200 0.0032
R_VDD4_14629 METAL5_1907400_791200 METAL5_1907400_794400 0.0128
R_VDD4_14630 METAL5_1907400_794400 METAL5_1907400_794800 0.0016
R_VDD4_14631 METAL5_1907400_794800 METAL5_1907400_796500 0.0068
R_VDD4_14632 METAL5_1907400_796500 METAL5_1907400_800000 0.014
R_VDD4_14633 METAL5_1907400_800000 METAL5_1907400_802400 0.0096
R_VDD4_14634 METAL5_1907400_802400 METAL5_1907400_803200 0.0032
R_VDD4_14635 METAL5_1907400_803200 METAL5_1907400_806400 0.0128
R_VDD4_14636 METAL5_1907400_806400 METAL5_1907200_806400 0.0008
R_VDD4_14637 METAL5_1907200_806400 METAL5_1901600_806400 0.0224
R_VDD4_14638 METAL5_1901600_806400 METAL5_1901400_806400 0.0008
R_VDD4_14639 METAL5_1901400_806400 METAL5_1900700_806400 0.0028
R_VDD4_14640 METAL5_1900700_806400 METAL5_1895200_806400 0.022
R_VDD4_14641 METAL5_1895200_806400 METAL6_1895200_806400 0.1
R_VDD4_14642 METAL6_1895200_806400 METAL6_1889600_806400 0.0112
R_VDD4_14643 METAL6_1889600_806400 METAL6_1889600_806800 0.0008
R_VDD4_14644 METAL6_1889600_806800 METAL6_1889600_808000 0.0024
R_VDD4_14645 METAL6_1889600_808000 METAL6_1889600_812000 0.008
R_VDD4_14646 METAL6_1889600_812000 METAL6_1889600_814400 0.0048
R_VDD4_14647 METAL6_1889600_814400 METAL6_1889600_818400 0.008
R_VDD4_14648 METAL6_1889600_818400 METAL6_1889600_820000 0.0032
R_VDD4_14649 METAL6_1889600_820000 METAL6_1889600_828700 0.0174
R_VDD4_14650 METAL6_1889600_828700 METAL6_1889600_830400 0.0034
R_VDD4_14651 METAL6_1889600_830400 METAL6_1889600_832000 0.0032
R_VDD4_14652 METAL6_1889600_832000 METAL6_1889600_839500 0.015
R_VDD4_14653 METAL6_1889600_839500 METAL6_1889600_840700 0.0024
R_VDD4_14654 METAL6_1889600_840700 METAL6_1889600_842400 0.0034
R_VDD4_14655 METAL6_1889600_842400 METAL6_1889600_851500 0.0182
R_VDD4_14656 METAL6_1889600_851500 METAL6_1889600_852700 0.0024
R_VDD4_14657 METAL6_1889600_852700 METAL6_1889600_854400 0.0034
R_VDD4_14658 METAL6_1889600_854400 METAL6_1889600_858200 0.0076
R_VDD4_14659 METAL6_1889600_858200 METAL6_1889600_863500 0.0106
R_VDD4_14660 METAL6_1889600_863500 METAL6_1889600_875000 0.023
R_VDD4_14661 METAL6_1889600_875000 METAL6_1889600_887000 0.024
R_VDD4_14662 METAL6_1889600_887000 METAL6_1889600_888000 0.002
R_VDD4_14663 METAL6_1889600_888000 METAL6_1889600_888400 0.0008
R_VDD4_14664 METAL6_1889600_888400 METAL6_1889600_899000 0.0212
R_VDD4_14665 METAL6_1889600_899000 METAL6_1889600_900000 0.002
R_VDD4_14666 METAL6_1889600_900000 METAL6_1889600_900400 0.0008
R_VDD4_14667 METAL6_1889600_900400 METAL6_1889600_911000 0.0212
R_VDD4_14668 METAL6_1889600_911000 METAL6_1889600_912000 0.002
R_VDD4_14669 METAL6_1889600_912000 METAL6_1889600_912400 0.0008
R_VDD4_14670 METAL6_1889600_912400 METAL6_1889600_923000 0.0212
R_VDD4_14671 METAL6_1889600_923000 METAL6_1889600_924000 0.002
R_VDD4_14672 METAL6_1889600_924000 METAL6_1889600_927300 0.0066
R_VDD4_14673 METAL6_1889600_927300 METAL6_1889600_935000 0.0154
R_VDD4_14674 METAL6_1889600_935000 METAL6_1889600_947000 0.024
R_VDD4_14675 METAL6_1889600_947000 METAL6_1889600_959000 0.024
R_VDD4_14676 METAL6_1889600_959000 METAL6_1889600_971000 0.024
R_VDD4_14677 METAL6_1889600_971000 METAL6_1889600_976000 0.01
R_VDD4_14678 METAL6_1889600_976000 METAL6_1889600_983000 0.014
R_VDD4_14679 METAL6_1889600_983000 METAL6_1889600_988000 0.01
R_VDD4_14680 METAL6_1889600_988000 METAL6_1889600_989400 0.0028
R_VDD4_14681 METAL6_1889600_989400 METAL6_1889600_995000 0.0112
R_VDD4_14682 METAL6_1889600_995000 METAL6_1889600_1000000 0.01
R_VDD4_14683 METAL6_1889600_1000000 METAL6_1889600_1001400 0.0028
R_VDD4_14684 METAL6_1889600_1001400 METAL6_1889600_1007000 0.0112
R_VDD4_14685 METAL6_1889600_1007000 METAL6_1889600_1012000 0.01
R_VDD4_14686 METAL6_1889600_1012000 METAL6_1889600_1013400 0.0028
R_VDD4_14687 METAL6_1889600_1013400 METAL6_1889600_1014000 0.0012
R_VDD4_14688 METAL6_1889600_1014000 METAL6_1889600_1019000 0.01
R_VDD4_14689 METAL6_1889600_1019000 METAL6_1889600_1023700 0.0094
R_VDD4_14690 METAL6_1889600_1023700 METAL6_1889600_1025400 0.0034
R_VDD4_14691 METAL6_1889600_1025400 METAL6_1889600_1026000 0.0012
R_VDD4_14692 METAL6_1889600_1026000 METAL6_1889600_1029800 0.0076
R_VDD4_14693 METAL6_1889600_1029800 METAL6_1889600_1031000 0.0024
R_VDD4_14694 METAL6_1889600_1031000 METAL6_1889600_1035700 0.0094
R_VDD4_14695 METAL6_1889600_1035700 METAL6_1889600_1037400 0.0034
R_VDD4_14696 METAL6_1889600_1037400 METAL6_1889600_1038000 0.0012
R_VDD4_14697 METAL6_1889600_1038000 METAL6_1889600_1041800 0.0076
R_VDD4_14698 METAL6_1889600_1041800 METAL6_1889600_1042700 0.0018
R_VDD4_14699 METAL6_1889600_1042700 METAL6_1889600_1043000 0.0006
R_VDD4_14700 METAL6_1889600_1043000 METAL6_1889600_1047700 0.0094
R_VDD4_14701 METAL6_1889600_1047700 METAL6_1889600_1049400 0.0034
R_VDD4_14702 METAL6_1889600_1049400 METAL6_1889600_1049800 0.0008
R_VDD4_14703 METAL6_1889600_1049800 METAL6_1889600_1053800 0.008
R_VDD4_14704 METAL6_1889600_1053800 METAL6_1889600_1054700 0.0018
R_VDD4_14705 METAL6_1889600_1054700 METAL6_1889600_1061400 0.0134
R_VDD4_14706 METAL6_1889600_1061400 METAL6_1889600_1061800 0.0008
R_VDD4_14707 METAL6_1889600_1061800 METAL6_1889600_1066700 0.0098
R_VDD4_14708 METAL6_1889600_1066700 METAL6_1889600_1073400 0.0134
R_VDD4_14709 METAL6_1889600_1073400 METAL6_1889600_1073800 0.0008
R_VDD4_14710 METAL6_1889600_1073800 METAL6_1889400_1073800 0.0004
R_VDD4_14711 METAL6_1889400_1073800 METAL6_1888700_1073800 0.0014
R_VDD4_14712 METAL6_1888700_1073800 METAL6_1888700_1074000 0.0004
R_VDD4_14713 METAL6_1888700_1074000 METAL6_1888700_1074500 0.001
R_VDD4_14714 METAL6_1888700_1074500 METAL6_1888700_1078700 0.0084
R_VDD4_14715 METAL6_1888700_1078700 METAL6_1888700_1084800 0.0122
R_VDD4_14716 METAL6_1888700_1084800 METAL6_1888700_1085400 0.0012
R_VDD4_14717 METAL6_1888700_1085400 METAL6_1888700_1085800 0.0008
R_VDD4_14718 METAL6_1888700_1085800 METAL6_1888700_1086000 0.0004
R_VDD4_14719 METAL6_1888700_1086000 METAL6_1888700_1086300 0.0006
R_VDD4_14720 METAL6_1888700_1086300 METAL6_1888700_1086500 0.0004
R_VDD4_14721 METAL6_1888700_1086500 METAL6_1888700_1088000 0.003
R_VDD4_14722 METAL6_1888700_1088000 METAL6_1888700_1096800 0.0176
R_VDD4_14723 METAL6_1888700_1096800 METAL6_1888700_1097800 0.002
R_VDD4_14724 METAL6_1888700_1097800 METAL6_1888700_1098000 0.0004
R_VDD4_14725 METAL6_1888700_1098000 METAL6_1888700_1098300 0.0006
R_VDD4_14726 METAL6_1888700_1098300 METAL6_1888700_1098500 0.0004
R_VDD4_14727 METAL6_1888700_1098500 METAL6_1888700_1100000 0.003
R_VDD4_14728 METAL6_1888700_1100000 METAL6_1888700_1108800 0.0176
R_VDD4_14729 METAL6_1888700_1108800 METAL6_1888700_1110000 0.0024
R_VDD4_14730 METAL6_1888700_1110000 METAL6_1888700_1110300 0.0006
R_VDD4_14731 METAL6_1888700_1110300 METAL6_1888700_1110500 0.0004
R_VDD4_14732 METAL6_1888700_1110500 METAL6_1888700_1112000 0.003
R_VDD4_14733 METAL6_1888700_1112000 METAL6_1888700_1120800 0.0176
R_VDD4_14734 METAL6_1888700_1120800 METAL6_1888700_1122300 0.003
R_VDD4_14735 METAL6_1888700_1122300 METAL6_1888700_1122500 0.0004
R_VDD4_14736 METAL6_1888700_1122500 METAL6_1888700_1129300 0.0136
R_VDD4_14737 METAL6_1888700_1129300 METAL6_1888700_1132800 0.007
R_VDD4_14738 METAL6_1888700_1132800 METAL6_1888700_1134300 0.003
R_VDD4_14739 METAL6_1888700_1134300 METAL6_1888700_1134500 0.0004
R_VDD4_14740 METAL6_1888700_1134500 METAL6_1888700_1141300 0.0136
R_VDD4_14741 METAL6_1888700_1141300 METAL6_1888700_1144800 0.007
R_VDD4_14742 METAL6_1888700_1144800 METAL6_1888700_1146300 0.003
R_VDD4_14743 METAL6_1888700_1146300 METAL6_1888700_1146500 0.0004
R_VDD4_14744 METAL6_1888700_1146500 METAL6_1888700_1153300 0.0136
R_VDD4_14745 METAL6_1888700_1153300 METAL6_1888700_1157700 0.0088
R_VDD4_14746 METAL6_1888700_1157700 METAL6_1888700_1158500 0.0016
R_VDD4_14747 METAL6_1888700_1158500 METAL6_1888700_1160600 0.0042
R_VDD4_14748 METAL6_1888700_1160600 METAL6_1888700_1165300 0.0094
R_VDD4_14749 METAL6_1888700_1165300 METAL5_1888700_1165300 0.1
R_VDD4_14750 METAL5_1888700_1165300 METAL5_1883200_1165300 0.022
R_VDD4_14751 METAL5_1883200_1165300 METAL5_1877600_1165300 0.0224
R_VDD4_14752 METAL5_1877600_1165300 METAL5_1877400_1165300 0.0008
R_VDD4_14753 METAL5_1877400_1165300 METAL5_1876700_1165300 0.0028
R_VDD4_14754 METAL5_1876700_1165300 METAL5_1874700_1165300 0.008
R_VDD4_14755 METAL5_1874700_1165300 METAL5_1871200_1165300 0.014
R_VDD4_14756 METAL5_1871200_1165300 METAL5_1870600_1165300 0.0024
R_VDD4_14757 METAL5_1870600_1165300 METAL5_1865600_1165300 0.02
R_VDD4_14758 METAL5_1865600_1165300 METAL5_1865400_1165300 0.0008
R_VDD4_14759 METAL5_1865400_1165300 METAL5_1864700_1165300 0.0028
R_VDD4_14760 METAL5_1864700_1165300 METAL5_1859200_1165300 0.022
R_VDD4_14761 METAL5_1859200_1165300 METAL5_1858600_1165300 0.0024
R_VDD4_14762 METAL5_1858600_1165300 METAL5_1858400_1165300 0.0008
R_VDD4_14763 METAL5_1858400_1165300 METAL5_1853400_1165300 0.02
R_VDD4_14764 METAL5_1853400_1165300 METAL5_1852700_1165300 0.0028
R_VDD4_14765 METAL5_1852700_1165300 METAL5_1847200_1165300 0.022
R_VDD4_14766 METAL5_1847200_1165300 METAL5_1846800_1165300 0.0016
R_VDD4_14767 METAL5_1846800_1165300 METAL5_1846600_1165300 0.0008
R_VDD4_14768 METAL5_1846600_1165300 METAL5_1846400_1165300 0.0008
R_VDD4_14769 METAL5_1846400_1165300 METAL5_1844800_1165300 0.0064
R_VDD4_14770 METAL5_1844800_1165300 METAL5_1841400_1165300 0.0136
R_VDD4_14771 METAL5_1841400_1165300 METAL5_1834600_1165300 0.0272
R_VDD4_14772 METAL5_1834600_1165300 METAL5_1834400_1165300 0.0008
R_VDD4_14773 METAL5_1834400_1165300 METAL6_1834400_1165300 0.1
R_VDD4_14774 METAL6_1834400_1165300 METAL6_1832800_1165300 0.0032
R_VDD4_14775 METAL6_1832800_1165300 METAL6_1822600_1165300 0.0204
R_VDD4_14776 METAL6_1822600_1165300 METAL6_1822400_1165300 0.0004
R_VDD4_14777 METAL6_1822400_1165300 METAL6_1820800_1165300 0.0032
R_VDD4_14778 METAL6_1820800_1165300 METAL6_1812000_1165300 0.0176
R_VDD4_14779 METAL6_1812000_1165300 METAL6_1810600_1165300 0.0028
R_VDD4_14780 METAL6_1810600_1165300 METAL6_1800000_1165300 0.0212
R_VDD4_14781 METAL6_1800000_1165300 METAL6_1799400_1165300 0.0012
R_VDD4_14782 METAL6_1799400_1165300 METAL6_1798600_1165300 0.0016
R_VDD4_14783 METAL6_1798600_1165300 METAL6_1788000_1165300 0.0212
R_VDD4_14784 METAL6_1788000_1165300 METAL6_1787400_1165300 0.0012
R_VDD4_14785 METAL6_1787400_1165300 METAL6_1775400_1165300 0.024
R_VDD4_14786 METAL6_1775400_1165300 METAL6_1768000_1165300 0.0148
R_VDD4_14787 METAL6_1768000_1165300 METAL6_1767700_1165300 0.0006
R_VDD4_14788 METAL6_1767700_1165300 METAL6_1763800_1165300 0.0078
R_VDD4_14789 METAL6_1763800_1165300 METAL6_1763400_1165300 0.0008
R_VDD4_14790 METAL6_1763400_1165300 METAL6_1756000_1165300 0.0148
R_VDD4_14791 METAL6_1756000_1165300 METAL6_1755700_1165300 0.0006
R_VDD4_14792 METAL6_1755700_1165300 METAL6_1753800_1165300 0.0038
R_VDD4_14793 METAL6_1753800_1165300 METAL6_1751800_1165300 0.004
R_VDD4_14794 METAL6_1751800_1165300 METAL6_1751400_1165300 0.0008
R_VDD4_14795 METAL6_1751400_1165300 METAL6_1744000_1165300 0.0148
R_VDD4_14796 METAL6_1744000_1165300 METAL6_1743700_1165300 0.0006
R_VDD4_14797 METAL6_1743700_1165300 METAL6_1741800_1165300 0.0038
R_VDD4_14798 METAL6_1741800_1165300 METAL6_1739800_1165300 0.004
R_VDD4_14799 METAL6_1739800_1165300 METAL6_1739400_1165300 0.0008
R_VDD4_14800 METAL6_1739400_1165300 METAL6_1732000_1165300 0.0148
R_VDD4_14801 METAL6_1732000_1165300 METAL6_1731700_1165300 0.0006
R_VDD4_14802 METAL6_1731700_1165300 METAL6_1729800_1165300 0.0038
R_VDD4_14803 METAL6_1729800_1165300 METAL6_1727800_1165300 0.004
R_VDD4_14804 METAL6_1727800_1165300 METAL6_1719700_1165300 0.0162
R_VDD4_14805 METAL6_1719700_1165300 METAL6_1717800_1165300 0.0038
R_VDD4_14806 METAL6_1717800_1165300 METAL6_1710800_1165300 0.014
R_VDD4_14807 METAL6_1710800_1165300 METAL6_1707700_1165300 0.0062
R_VDD4_14808 METAL6_1707700_1165300 METAL6_1699000_1165300 0.0174
R_VDD4_14809 METAL6_1699000_1165300 METAL6_1692000_1165300 0.014
R_VDD4_14810 METAL6_1692000_1165300 METAL6_1682800_1165300 0.0184
R_VDD4_14811 METAL6_1682800_1165300 METAL6_1682800_1160600 0.0094
R_VDD4_14812 METAL6_1682800_1160600 METAL6_1680000_1160600 0.0056
R_VDD4_14813 METAL6_1680000_1160600 METAL6_1670800_1160600 0.0184
R_VDD4_14814 METAL6_1670800_1160600 METAL6_1668000_1160600 0.0056
R_VDD4_14815 METAL6_1668000_1160600 METAL6_1660700_1160600 0.0146
R_VDD4_14816 METAL6_1660700_1160600 METAL6_1660700_1158500 0.0042
R_VDD4_14817 METAL6_1660700_1158500 METAL6_1658800_1158500 0.0038
R_VDD4_14818 METAL6_1658800_1158500 METAL6_1648700_1158500 0.0202
R_VDD4_14819 METAL6_1648700_1158500 METAL6_1648700_1157700 0.0016
R_VDD4_14820 METAL6_1648700_1157700 METAL6_1648700_1153300 0.0088
R_VDD4_14821 METAL6_1648700_1153300 METAL6_1648700_1146500 0.0136
R_VDD4_14822 METAL6_1648700_1146500 METAL6_1648000_1146500 0.0014
R_VDD4_14823 METAL6_1648000_1146500 METAL6_1646800_1146500 0.0024
R_VDD4_14824 METAL6_1646800_1146500 METAL6_1636700_1146500 0.0202
R_VDD4_14825 METAL6_1636700_1146500 METAL6_1636000_1146500 0.0014
R_VDD4_14826 METAL6_1636000_1146500 METAL6_1634800_1146500 0.0024
R_VDD4_14827 METAL6_1634800_1146500 METAL6_1632800_1146500 0.004
R_VDD4_14828 METAL6_1632800_1146500 METAL6_1627800_1146500 0.01
R_VDD4_14829 METAL6_1627800_1146500 METAL6_1624700_1146500 0.0062
R_VDD4_14830 METAL6_1624700_1146500 METAL6_1624000_1146500 0.0014
R_VDD4_14831 METAL6_1624000_1146500 METAL6_1615800_1146500 0.0164
R_VDD4_14832 METAL6_1615800_1146500 METAL6_1612700_1146500 0.0062
R_VDD4_14833 METAL6_1612700_1146500 METAL6_1612000_1146500 0.0014
R_VDD4_14834 METAL6_1612000_1146500 METAL6_1607900_1146500 0.0082
R_VDD4_14835 METAL6_1607900_1146500 METAL6_1603800_1146500 0.0082
R_VDD4_14836 METAL6_1603800_1146500 METAL6_1600700_1146500 0.0062
R_VDD4_14837 METAL6_1600700_1146500 METAL6_1600000_1146500 0.0014
R_VDD4_14838 METAL6_1600000_1146500 METAL6_1591800_1146500 0.0164
R_VDD4_14839 METAL6_1591800_1146500 METAL6_1588700_1146500 0.0062
R_VDD4_14840 METAL6_1588700_1146500 METAL6_1588000_1146500 0.0014
R_VDD4_14841 METAL6_1588000_1146500 METAL6_1579800_1146500 0.0164
R_VDD4_14842 METAL6_1579800_1146500 METAL6_1576700_1146500 0.0062
R_VDD4_14843 METAL6_1576700_1146500 METAL6_1576000_1146500 0.0014
R_VDD4_14844 METAL6_1576000_1146500 METAL6_1574700_1146500 0.0026
R_VDD4_14845 METAL6_1574700_1146500 METAL6_1569000_1146500 0.0114
R_VDD4_14846 METAL6_1569000_1146500 METAL6_1567800_1146500 0.0024
R_VDD4_14847 METAL6_1567800_1146500 METAL6_1564000_1146500 0.0076
R_VDD4_14848 METAL6_1564000_1146500 METAL6_1557000_1146500 0.014
R_VDD4_14849 METAL6_1557000_1146500 METAL6_1555800_1146500 0.0024
R_VDD4_14850 METAL6_1555800_1146500 METAL6_1555400_1146500 0.0008
R_VDD4_14851 METAL6_1555400_1146500 METAL6_1552000_1146500 0.0068
R_VDD4_14852 METAL6_1552000_1146500 METAL6_1552000_1146300 0.0004
R_VDD4_14853 METAL6_1552000_1146300 METAL6_1552000_1144800 0.003
R_VDD4_14854 METAL6_1552000_1144800 METAL6_1552000_1141300 0.007
R_VDD4_14855 METAL6_1552000_1141300 METAL6_1551800_1141300 0.0004
R_VDD4_14856 METAL6_1551800_1141300 METAL6_1545000_1141300 0.0136
R_VDD4_14857 METAL6_1545000_1141300 METAL6_1540000_1141300 0.01
R_VDD4_14858 METAL6_1540000_1141300 METAL6_1539800_1141300 0.0004
R_VDD4_14859 METAL6_1539800_1141300 METAL5_1539800_1141300 0.1
R_VDD4_14860 METAL5_1539800_1141300 METAL4_1539800_1141300 0.1
I_VDD4_47 METAL6_995000_275000 gnd 0.006
I_VDD4_48 METAL4_2236700_1042700 gnd 0.0065
I_VDD4_49 METAL4_2014400_1184600 gnd 0.0065
I_VDD4_50 METAL4_1939800_1129300 gnd 0.0065
I_VDD4_51 METAL4_1739800_1129300 gnd 0.0065
I_VDD4_52 METAL4_2153400_709800 gnd 0.0065
I_VDD4_53 METAL4_1539800_1129300 gnd 0.0065

V_VDD5_22 METAL6_1600000_0 gnd 1
R_VDD5_14861 METAL6_1600000_0 METAL6_1600000_9500 0.019
R_VDD5_14862 METAL6_1600000_9500 METAL6_1600000_16600 0.0142
R_VDD5_14863 METAL6_1600000_16600 METAL6_1600000_21500 0.0098
R_VDD5_14864 METAL6_1600000_21500 METAL6_1600000_28600 0.0142
R_VDD5_14865 METAL6_1600000_28600 METAL6_1600000_33500 0.0098
R_VDD5_14866 METAL6_1600000_33500 METAL6_1600000_40600 0.0142
R_VDD5_14867 METAL6_1600000_40600 METAL6_1600000_52600 0.024
R_VDD5_14868 METAL6_1600000_52600 METAL6_1600000_64000 0.0228
R_VDD5_14869 METAL6_1600000_64000 METAL6_1600000_64600 0.0012
R_VDD5_14870 METAL6_1600000_64600 METAL6_1600000_71600 0.014
R_VDD5_14871 METAL6_1600000_71600 METAL6_1600000_76000 0.0088
R_VDD5_14872 METAL6_1600000_76000 METAL6_1600000_76600 0.0012
R_VDD5_14873 METAL6_1600000_76600 METAL6_1600000_83600 0.014
R_VDD5_14874 METAL6_1600000_83600 METAL6_1600000_88000 0.0088
R_VDD5_14875 METAL6_1600000_88000 METAL6_1600000_88600 0.0012
R_VDD5_14876 METAL6_1600000_88600 METAL6_1600000_95600 0.014
R_VDD5_14877 METAL6_1600000_95600 METAL6_1600000_100000 0.0088
R_VDD5_14878 METAL6_1600000_100000 METAL6_1600000_112000 0.024
R_VDD5_14879 METAL6_1600000_112000 METAL6_1600000_159600 0.0952
R_VDD5_14880 METAL6_1600000_159600 METAL6_1600000_166600 0.014
R_VDD5_14881 METAL6_1600000_166600 METAL6_1600000_176000 0.0188
R_VDD5_14882 METAL6_1600000_176000 METAL6_1600000_178600 0.0052
R_VDD5_14883 METAL6_1600000_178600 METAL6_1600000_188000 0.0188
R_VDD5_14884 METAL6_1600000_188000 METAL6_1600000_190600 0.0052
R_VDD5_14885 METAL6_1600000_190600 METAL6_1600000_200000 0.0188
R_VDD5_14886 METAL6_1600000_200000 METAL6_1600000_212000 0.024
R_VDD5_14887 METAL6_1600000_212000 METAL6_1600000_248300 0.0726
R_VDD5_14888 METAL6_1600000_248300 METAL6_1600000_251000 0.0054
R_VDD5_14889 METAL6_1600000_251000 METAL6_1600000_260300 0.0186
R_VDD5_14890 METAL6_1600000_260300 METAL6_1600000_263000 0.0054
R_VDD5_14891 METAL6_1600000_263000 METAL6_1600000_272300 0.0186
R_VDD5_14892 METAL6_1600000_272300 METAL6_1600000_275000 0.0054
R_VDD5_14893 METAL6_1600000_275000 METAL6_1600000_279300 0.0086
R_VDD5_14894 METAL6_1600000_279300 METAL6_1600000_287000 0.0154
R_VDD5_14895 METAL6_1600000_287000 METAL6_1600000_288000 0.002
R_VDD5_14896 METAL6_1600000_288000 METAL6_1600000_299000 0.022
R_VDD5_14897 METAL6_1600000_299000 METAL6_1600000_300000 0.002
R_VDD5_14898 METAL6_1600000_300000 METAL6_1600000_312000 0.024
R_VDD5_14899 METAL6_1600000_312000 METAL6_1600000_355300 0.0866
R_VDD5_14900 METAL6_1600000_355300 METAL6_1600000_362300 0.014
R_VDD5_14901 METAL6_1600000_362300 METAL6_1600000_366800 0.009
R_VDD5_14902 METAL6_1600000_366800 METAL6_1600000_374300 0.015
R_VDD5_14903 METAL6_1600000_374300 METAL6_1600000_378800 0.009
R_VDD5_14904 METAL6_1600000_378800 METAL6_1600000_386300 0.015
R_VDD5_14905 METAL6_1600000_386300 METAL6_1600000_388000 0.0034
R_VDD5_14906 METAL6_1600000_388000 METAL6_1600000_390800 0.0056
R_VDD5_14907 METAL6_1600000_390800 METAL6_1600000_400000 0.0184
R_VDD5_14908 METAL6_1600000_400000 METAL6_1600000_402800 0.0056
R_VDD5_14909 METAL6_1600000_402800 METAL6_1600000_412000 0.0184
R_VDD5_14910 METAL6_1600000_412000 METAL6_1600000_413000 0.002
R_VDD5_14911 METAL6_1600000_413000 METAL6_1600000_414800 0.0036
R_VDD5_14912 METAL6_1600000_414800 METAL6_1600000_425000 0.0204
R_VDD5_14913 METAL6_1600000_425000 METAL6_1600000_437000 0.024
R_VDD5_14914 METAL6_1600000_437000 METAL5_1600000_437000 0.1
R_VDD5_14915 METAL5_1600000_437000 METAL5_1591800_437000 0.0328
R_VDD5_14916 METAL5_1591800_437000 METAL5_1588700_437000 0.0124
R_VDD5_14917 METAL5_1588700_437000 METAL5_1588000_437000 0.0028
R_VDD5_14918 METAL5_1588000_437000 METAL5_1579800_437000 0.0328
R_VDD5_14919 METAL5_1579800_437000 METAL5_1576700_437000 0.0124
R_VDD5_14920 METAL5_1576700_437000 METAL5_1576000_437000 0.0028
R_VDD5_14921 METAL5_1576000_437000 METAL5_1574700_437000 0.0052
R_VDD5_14922 METAL5_1574700_437000 METAL5_1564000_437000 0.0428
R_VDD5_14923 METAL5_1564000_437000 METAL5_1564000_449000 0.048
R_VDD5_14924 METAL5_1564000_449000 METAL5_1564000_453000 0.016
R_VDD5_14925 METAL5_1564000_453000 METAL5_1564000_459000 0.024
R_VDD5_14926 METAL5_1564000_459000 METAL5_1564000_461000 0.008
R_VDD5_14927 METAL5_1564000_461000 METAL6_1564000_461000 0.1
R_VDD5_14928 METAL6_1564000_461000 METAL6_1557000_461000 0.014
R_VDD5_14929 METAL6_1557000_461000 METAL6_1557000_465000 0.008
R_VDD5_14930 METAL6_1557000_465000 METAL6_1557000_468400 0.0068
R_VDD5_14931 METAL6_1557000_468400 METAL6_1555400_468400 0.0032
R_VDD5_14932 METAL6_1555400_468400 METAL6_1551800_468400 0.0072
R_VDD5_14933 METAL6_1551800_468400 METAL6_1539800_468400 0.024
R_VDD5_14934 METAL6_1539800_468400 METAL6_1527800_468400 0.024
R_VDD5_14935 METAL6_1527800_468400 METAL6_1512000_468400 0.0316
R_VDD5_14936 METAL6_1512000_468400 METAL6_1510400_468400 0.0032
R_VDD5_14937 METAL6_1510400_468400 METAL6_1503400_468400 0.014
R_VDD5_14938 METAL6_1503400_468400 METAL6_1500000_468400 0.0068
R_VDD5_14939 METAL6_1500000_468400 METAL6_1498300_468400 0.0034
R_VDD5_14940 METAL6_1498300_468400 METAL6_1491400_468400 0.0138
R_VDD5_14941 METAL6_1491400_468400 METAL6_1488000_468400 0.0068
R_VDD5_14942 METAL6_1488000_468400 METAL6_1479400_468400 0.0172
R_VDD5_14943 METAL6_1479400_468400 METAL6_1444800_468400 0.0692
R_VDD5_14944 METAL6_1444800_468400 METAL6_1443700_468400 0.0022
R_VDD5_14945 METAL6_1443700_468400 METAL6_1432800_468400 0.0218
R_VDD5_14946 METAL6_1432800_468400 METAL6_1431700_468400 0.0022
R_VDD5_14947 METAL6_1431700_468400 METAL6_1424000_468400 0.0154
R_VDD5_14948 METAL6_1424000_468400 METAL6_1420800_468400 0.0064
R_VDD5_14949 METAL6_1420800_468400 METAL6_1420800_471000 0.0052
R_VDD5_14950 METAL6_1420800_471000 METAL6_1420800_473000 0.004
R_VDD5_14951 METAL6_1420800_473000 METAL6_1420800_477000 0.008
R_VDD5_14952 METAL6_1420800_477000 METAL6_1420800_480400 0.0068
R_VDD5_14953 METAL6_1420800_480400 METAL6_1420800_483000 0.0052
R_VDD5_14954 METAL6_1420800_483000 METAL6_1420800_488000 0.01
R_VDD5_14955 METAL6_1420800_488000 METAL6_1420800_492400 0.0088
R_VDD5_14956 METAL6_1420800_492400 METAL6_1420800_495000 0.0052
R_VDD5_14957 METAL6_1420800_495000 METAL6_1419700_495000 0.0022
R_VDD5_14958 METAL6_1419700_495000 METAL6_1412000_495000 0.0154
R_VDD5_14959 METAL6_1412000_495000 METAL6_1400000_495000 0.024
R_VDD5_14960 METAL6_1400000_495000 METAL6_1388000_495000 0.024
R_VDD5_14961 METAL6_1388000_495000 METAL6_1337000_495000 0.102
R_VDD5_14962 METAL6_1337000_495000 METAL6_1336000_495000 0.002
R_VDD5_14963 METAL6_1336000_495000 METAL6_1325000_495000 0.022
R_VDD5_14964 METAL6_1325000_495000 METAL6_1324000_495000 0.002
R_VDD5_14965 METAL6_1324000_495000 METAL6_1323800_495000 0.0004
R_VDD5_14966 METAL6_1323800_495000 METAL6_1313000_495000 0.0216
R_VDD5_14967 METAL6_1313000_495000 METAL6_1312000_495000 0.002
R_VDD5_14968 METAL6_1312000_495000 METAL6_1312000_500000 0.01
R_VDD5_14969 METAL6_1312000_500000 METAL6_1312000_504000 0.008
R_VDD5_14970 METAL6_1312000_504000 METAL6_1312000_507000 0.006
R_VDD5_14971 METAL6_1312000_507000 METAL6_1312000_507800 0.0016
R_VDD5_14972 METAL6_1312000_507800 METAL6_1312000_512000 0.0084
R_VDD5_14973 METAL6_1312000_512000 METAL6_1312000_516000 0.008
R_VDD5_14974 METAL6_1312000_516000 METAL6_1312000_519000 0.006
R_VDD5_14975 METAL6_1312000_519000 METAL6_1312000_520200 0.0024
R_VDD5_14976 METAL6_1312000_520200 METAL6_1312000_528000 0.0156
R_VDD5_14977 METAL6_1312000_528000 METAL6_1312000_532200 0.0084
R_VDD5_14978 METAL6_1312000_532200 METAL6_1312000_535400 0.0064
R_VDD5_14979 METAL6_1312000_535400 METAL6_1312000_544200 0.0176
R_VDD5_14980 METAL6_1312000_544200 METAL6_1312000_547400 0.0064
R_VDD5_14981 METAL6_1312000_547400 METAL6_1312000_550400 0.006
R_VDD5_14982 METAL6_1312000_550400 METAL6_1312000_556200 0.0116
R_VDD5_14983 METAL6_1312000_556200 METAL6_1312000_559400 0.0064
R_VDD5_14984 METAL6_1312000_559400 METAL6_1312000_561000 0.0032
R_VDD5_14985 METAL6_1312000_561000 METAL6_1312000_562400 0.0028
R_VDD5_14986 METAL6_1312000_562400 METAL6_1312000_573000 0.0212
R_VDD5_14987 METAL6_1312000_573000 METAL6_1312000_574400 0.0028
R_VDD5_14988 METAL6_1312000_574400 METAL6_1311800_574400 0.0004
R_VDD5_14989 METAL6_1311800_574400 METAL6_1301000_574400 0.0216
R_VDD5_14990 METAL6_1301000_574400 METAL6_1300000_574400 0.002
R_VDD5_14991 METAL6_1300000_574400 METAL6_1299800_574400 0.0004
R_VDD5_14992 METAL6_1299800_574400 METAL6_1289000_574400 0.0216
R_VDD5_14993 METAL6_1289000_574400 METAL6_1288000_574400 0.002
R_VDD5_14994 METAL6_1288000_574400 METAL6_1287800_574400 0.0004
R_VDD5_14995 METAL6_1287800_574400 METAL6_1286700_574400 0.0022
R_VDD5_14996 METAL6_1286700_574400 METAL6_1276000_574400 0.0214
R_VDD5_14997 METAL6_1276000_574400 METAL6_1274700_574400 0.0026
R_VDD5_14998 METAL6_1274700_574400 METAL6_1270300_574400 0.0088
R_VDD5_14999 METAL6_1270300_574400 METAL6_1266800_574400 0.007
R_VDD5_15000 METAL6_1266800_574400 METAL6_1262700_574400 0.0082
R_VDD5_15001 METAL6_1262700_574400 METAL6_1259800_574400 0.0058
R_VDD5_15002 METAL6_1259800_574400 METAL6_1258300_574400 0.003
R_VDD5_15003 METAL6_1258300_574400 METAL6_1254700_574400 0.0072
R_VDD5_15004 METAL6_1254700_574400 METAL6_1253300_574400 0.0028
R_VDD5_15005 METAL6_1253300_574400 METAL6_1247800_574400 0.011
R_VDD5_15006 METAL6_1247800_574400 METAL6_1246300_574400 0.003
R_VDD5_15007 METAL6_1246300_574400 METAL6_1242700_574400 0.0072
R_VDD5_15008 METAL6_1242700_574400 METAL6_1236000_574400 0.0134
R_VDD5_15009 METAL6_1236000_574400 METAL6_1235800_574400 0.0004
R_VDD5_15010 METAL6_1235800_574400 METAL6_1235800_579800 0.0108
R_VDD5_15011 METAL6_1235800_579800 METAL6_1235800_585000 0.0104
R_VDD5_15012 METAL6_1235800_585000 METAL6_1234300_585000 0.003
R_VDD5_15013 METAL6_1234300_585000 METAL6_1230700_585000 0.0072
R_VDD5_15014 METAL6_1230700_585000 METAL6_1224000_585000 0.0134
R_VDD5_15015 METAL6_1224000_585000 METAL6_1224000_586400 0.0028
R_VDD5_15016 METAL6_1224000_586400 METAL6_1224000_588000 0.0032
R_VDD5_15017 METAL6_1224000_588000 METAL6_1224000_598400 0.0208
R_VDD5_15018 METAL6_1224000_598400 METAL6_1224000_600000 0.0032
R_VDD5_15019 METAL6_1224000_600000 METAL6_1224000_612000 0.024
R_VDD5_15020 METAL6_1224000_612000 METAL6_1224000_629400 0.0348
R_VDD5_15021 METAL6_1224000_629400 METAL6_1223800_629400 0.0004
R_VDD5_15022 METAL6_1223800_629400 METAL6_1223800_637800 0.0168
R_VDD5_15023 METAL6_1223800_637800 METAL6_1223800_641400 0.0072
R_VDD5_15024 METAL6_1223800_641400 METAL6_1223800_649800 0.0168
R_VDD5_15025 METAL6_1223800_649800 METAL6_1223800_653400 0.0072
R_VDD5_15026 METAL6_1223800_653400 METAL6_1223800_661800 0.0168
R_VDD5_15027 METAL6_1223800_661800 METAL6_1223800_665400 0.0072
R_VDD5_15028 METAL6_1223800_665400 METAL6_1223800_688000 0.0452
R_VDD5_15029 METAL6_1223800_688000 METAL6_1223800_697800 0.0196
R_VDD5_15030 METAL6_1223800_697800 METAL6_1223800_700000 0.0044
R_VDD5_15031 METAL6_1223800_700000 METAL6_1223800_702800 0.0056
R_VDD5_15032 METAL6_1223800_702800 METAL6_1223800_709800 0.014
R_VDD5_15033 METAL6_1223800_709800 METAL6_1223800_712000 0.0044
R_VDD5_15034 METAL6_1223800_712000 METAL6_1223800_716800 0.0096
R_VDD5_15035 METAL6_1223800_716800 METAL6_1223800_721800 0.01
R_VDD5_15036 METAL6_1223800_721800 METAL6_1223800_733800 0.024
R_VDD5_15037 METAL6_1223800_733800 METAL6_1222300_733800 0.003
R_VDD5_15038 METAL6_1222300_733800 METAL6_1218700_733800 0.0072
R_VDD5_15039 METAL6_1218700_733800 METAL6_1216400_733800 0.0046
R_VDD5_15040 METAL6_1216400_733800 METAL6_1212000_733800 0.0088
R_VDD5_15041 METAL6_1212000_733800 METAL6_1212000_734400 0.0012
R_VDD5_15042 METAL6_1212000_734400 METAL6_1212000_735400 0.002
R_VDD5_15043 METAL6_1212000_735400 METAL6_1212000_742400 0.014
R_VDD5_15044 METAL6_1212000_742400 METAL6_1212000_745800 0.0068
R_VDD5_15045 METAL6_1212000_745800 METAL6_1212000_746400 0.0012
R_VDD5_15046 METAL6_1212000_746400 METAL6_1212000_754400 0.016
R_VDD5_15047 METAL6_1212000_754400 METAL6_1212000_757800 0.0068
R_VDD5_15048 METAL6_1212000_757800 METAL6_1212000_758400 0.0012
R_VDD5_15049 METAL6_1212000_758400 METAL6_1212000_760000 0.0032
R_VDD5_15050 METAL6_1212000_760000 METAL6_1212000_763000 0.006
R_VDD5_15051 METAL6_1212000_763000 METAL6_1212000_766400 0.0068
R_VDD5_15052 METAL6_1212000_766400 METAL6_1212000_769800 0.0068
R_VDD5_15053 METAL6_1212000_769800 METAL6_1212000_770400 0.0012
R_VDD5_15054 METAL6_1212000_770400 METAL6_1212000_772000 0.0032
R_VDD5_15055 METAL6_1212000_772000 METAL6_1212000_778400 0.0128
R_VDD5_15056 METAL6_1212000_778400 METAL6_1212000_779200 0.0016
R_VDD5_15057 METAL6_1212000_779200 METAL6_1212000_782400 0.0064
R_VDD5_15058 METAL6_1212000_782400 METAL6_1212000_784000 0.0032
R_VDD5_15059 METAL6_1212000_784000 METAL6_1212000_784500 0.001
R_VDD5_15060 METAL6_1212000_784500 METAL6_1212000_788000 0.007
R_VDD5_15061 METAL6_1212000_788000 METAL6_1212000_790400 0.0048
R_VDD5_15062 METAL6_1212000_790400 METAL6_1212000_791200 0.0016
R_VDD5_15063 METAL6_1212000_791200 METAL6_1212000_794400 0.0064
R_VDD5_15064 METAL6_1212000_794400 METAL6_1212000_794800 0.0008
R_VDD5_15065 METAL6_1212000_794800 METAL6_1212000_800000 0.0104
R_VDD5_15066 METAL6_1212000_800000 METAL6_1212000_802400 0.0048
R_VDD5_15067 METAL6_1212000_802400 METAL6_1212000_803200 0.0016
R_VDD5_15068 METAL6_1212000_803200 METAL6_1212000_806400 0.0064
R_VDD5_15069 METAL6_1212000_806400 METAL6_1212000_808000 0.0032
R_VDD5_15070 METAL6_1212000_808000 METAL6_1212000_812000 0.008
R_VDD5_15071 METAL6_1212000_812000 METAL6_1212000_814400 0.0048
R_VDD5_15072 METAL6_1212000_814400 METAL6_1212000_818400 0.008
R_VDD5_15073 METAL6_1212000_818400 METAL6_1212000_820000 0.0032
R_VDD5_15074 METAL6_1212000_820000 METAL6_1212000_828700 0.0174
R_VDD5_15075 METAL6_1212000_828700 METAL6_1212000_830400 0.0034
R_VDD5_15076 METAL6_1212000_830400 METAL6_1212000_832000 0.0032
R_VDD5_15077 METAL6_1212000_832000 METAL6_1212000_839500 0.015
R_VDD5_15078 METAL6_1212000_839500 METAL6_1212000_840700 0.0024
R_VDD5_15079 METAL6_1212000_840700 METAL6_1212000_842400 0.0034
R_VDD5_15080 METAL6_1212000_842400 METAL6_1212000_851500 0.0182
R_VDD5_15081 METAL6_1212000_851500 METAL6_1212000_852700 0.0024
R_VDD5_15082 METAL6_1212000_852700 METAL6_1212000_858200 0.011
R_VDD5_15083 METAL6_1212000_858200 METAL6_1212000_863500 0.0106
R_VDD5_15084 METAL6_1212000_863500 METAL6_1212000_875000 0.023
R_VDD5_15085 METAL6_1212000_875000 METAL6_1212000_887000 0.024
R_VDD5_15086 METAL6_1212000_887000 METAL6_1212000_888000 0.002
R_VDD5_15087 METAL6_1212000_888000 METAL6_1212000_899000 0.022
R_VDD5_15088 METAL6_1212000_899000 METAL6_1212000_900000 0.002
R_VDD5_15089 METAL6_1212000_900000 METAL6_1212000_900400 0.0008
R_VDD5_15090 METAL6_1212000_900400 METAL6_1212000_912000 0.0232
R_VDD5_15091 METAL6_1212000_912000 METAL6_1212000_927300 0.0306
R_VDD5_15092 METAL6_1212000_927300 METAL6_1212000_935000 0.0154
R_VDD5_15093 METAL6_1212000_935000 METAL6_1211800_935000 0.0004
R_VDD5_15094 METAL6_1211800_935000 METAL6_1210300_935000 0.003
R_VDD5_15095 METAL6_1210300_935000 METAL6_1206700_935000 0.0072
R_VDD5_15096 METAL6_1206700_935000 METAL6_1204400_935000 0.0046
R_VDD5_15097 METAL6_1204400_935000 METAL6_1200000_935000 0.0088
R_VDD5_15098 METAL6_1200000_935000 METAL6_1199800_935000 0.0004
R_VDD5_15099 METAL6_1199800_935000 METAL6_1198300_935000 0.003
R_VDD5_15100 METAL6_1198300_935000 METAL6_1194700_935000 0.0072
R_VDD5_15101 METAL6_1194700_935000 METAL6_1192400_935000 0.0046
R_VDD5_15102 METAL6_1192400_935000 METAL6_1188000_935000 0.0088
R_VDD5_15103 METAL6_1188000_935000 METAL6_1186300_935000 0.0034
R_VDD5_15104 METAL6_1186300_935000 METAL6_1180400_935000 0.0118
R_VDD5_15105 METAL6_1180400_935000 METAL6_1174300_935000 0.0122
R_VDD5_15106 METAL6_1174300_935000 METAL6_1173700_935000 0.0012
R_VDD5_15107 METAL6_1173700_935000 METAL6_1166700_935000 0.014
R_VDD5_15108 METAL6_1166700_935000 METAL6_1162300_935000 0.0088
R_VDD5_15109 METAL6_1162300_935000 METAL6_1154700_935000 0.0152
R_VDD5_15110 METAL6_1154700_935000 METAL6_1142700_935000 0.024
R_VDD5_15111 METAL6_1142700_935000 METAL6_1137000_935000 0.0114
R_VDD5_15112 METAL6_1137000_935000 METAL6_1130700_935000 0.0126
R_VDD5_15113 METAL6_1130700_935000 METAL6_1130700_947000 0.024
R_VDD5_15114 METAL6_1130700_947000 METAL6_1130700_959000 0.024
R_VDD5_15115 METAL6_1130700_959000 METAL6_1125000_959000 0.0114
R_VDD5_15116 METAL6_1125000_959000 METAL6_1113000_959000 0.024
R_VDD5_15117 METAL6_1113000_959000 METAL6_1019000_959000 0.188
R_VDD5_15118 METAL6_1019000_959000 METAL6_1007000_959000 0.024
R_VDD5_15119 METAL6_1007000_959000 METAL6_995000_959000 0.024
R_VDD5_15120 METAL6_995000_959000 METAL6_988000_959000 0.014
R_VDD5_15121 METAL6_988000_959000 METAL6_964400_959000 0.0472
R_VDD5_15122 METAL6_964400_959000 METAL6_952400_959000 0.024
R_VDD5_15123 METAL6_952400_959000 METAL6_947400_959000 0.01
R_VDD5_15124 METAL6_947400_959000 METAL6_940400_959000 0.014
R_VDD5_15125 METAL6_940400_959000 METAL6_928400_959000 0.024
R_VDD5_15126 METAL6_928400_959000 METAL6_928400_971000 0.024
R_VDD5_15127 METAL6_928400_971000 METAL6_928400_976000 0.01
R_VDD5_15128 METAL6_928400_976000 METAL6_928400_983000 0.014
R_VDD5_15129 METAL6_928400_983000 METAL6_928400_988000 0.01
R_VDD5_15130 METAL6_928400_988000 METAL6_928400_995000 0.014
R_VDD5_15131 METAL6_928400_995000 METAL5_928400_995000 0.1
R_VDD5_15132 METAL5_928400_995000 METAL5_928400_1000000 0.02
R_VDD5_15133 METAL5_928400_1000000 METAL5_928400_1007000 0.028
R_VDD5_15134 METAL5_928400_1007000 METAL5_928400_1012000 0.02
R_VDD5_15135 METAL5_928400_1012000 METAL5_928400_1014000 0.008
R_VDD5_15136 METAL5_928400_1014000 METAL5_928400_1019000 0.02
R_VDD5_15137 METAL5_928400_1019000 METAL5_928400_1023700 0.0188
R_VDD5_15138 METAL5_928400_1023700 METAL5_928400_1025400 0.0068
R_VDD5_15139 METAL5_928400_1025400 METAL5_928400_1026000 0.0024
R_VDD5_15140 METAL5_928400_1026000 METAL5_928400_1029800 0.0152
R_VDD5_15141 METAL5_928400_1029800 METAL5_928400_1031000 0.0048
R_VDD5_15142 METAL5_928400_1031000 METAL6_928400_1031000 0.1
R_VDD5_15143 METAL6_928400_1031000 METAL6_928400_1035700 0.0094
R_VDD5_15144 METAL6_928400_1035700 METAL6_928400_1037400 0.0034
R_VDD5_15145 METAL6_928400_1037400 METAL6_928400_1038000 0.0012
R_VDD5_15146 METAL6_928400_1038000 METAL6_928400_1041800 0.0076
R_VDD5_15147 METAL6_928400_1041800 METAL6_928400_1042700 0.0018
R_VDD5_15148 METAL6_928400_1042700 METAL6_928400_1047700 0.01
R_VDD5_15149 METAL6_928400_1047700 METAL6_928400_1049400 0.0034
R_VDD5_15150 METAL6_928400_1049400 METAL6_928400_1049800 0.0008
R_VDD5_15151 METAL6_928400_1049800 METAL6_928400_1053800 0.008
R_VDD5_15152 METAL6_928400_1053800 METAL6_928400_1054700 0.0018
R_VDD5_15153 METAL6_928400_1054700 METAL6_928400_1061400 0.0134
R_VDD5_15154 METAL6_928400_1061400 METAL6_928400_1061800 0.0008
R_VDD5_15155 METAL6_928400_1061800 METAL6_928400_1066700 0.0098
R_VDD5_15156 METAL6_928400_1066700 METAL6_928400_1073400 0.0134
R_VDD5_15157 METAL6_928400_1073400 METAL6_928400_1073800 0.0008
R_VDD5_15158 METAL6_928400_1073800 METAL6_928400_1074000 0.0004
R_VDD5_15159 METAL6_928400_1074000 METAL6_928400_1074500 0.001
R_VDD5_15160 METAL6_928400_1074500 METAL6_928400_1085800 0.0226
R_VDD5_15161 METAL6_928400_1085800 METAL6_928400_1086000 0.0004
R_VDD5_15162 METAL6_928400_1086000 METAL6_928400_1086300 0.0006
R_VDD5_15163 METAL6_928400_1086300 METAL6_928400_1086500 0.0004
R_VDD5_15164 METAL6_928400_1086500 METAL6_928400_1088000 0.003
R_VDD5_15165 METAL6_928400_1088000 METAL6_928400_1096800 0.0176
R_VDD5_15166 METAL6_928400_1096800 METAL6_928400_1098000 0.0024
R_VDD5_15167 METAL6_928400_1098000 METAL6_928400_1098300 0.0006
R_VDD5_15168 METAL6_928400_1098300 METAL6_928400_1098500 0.0004
R_VDD5_15169 METAL6_928400_1098500 METAL6_928400_1100000 0.003
R_VDD5_15170 METAL6_928400_1100000 METAL6_928400_1108800 0.0176
R_VDD5_15171 METAL6_928400_1108800 METAL6_928400_1110000 0.0024
R_VDD5_15172 METAL6_928400_1110000 METAL6_928400_1110300 0.0006
R_VDD5_15173 METAL6_928400_1110300 METAL6_928400_1110500 0.0004
R_VDD5_15174 METAL6_928400_1110500 METAL6_928400_1112000 0.003
R_VDD5_15175 METAL6_928400_1112000 METAL6_928400_1120800 0.0176
R_VDD5_15176 METAL6_928400_1120800 METAL6_928400_1122300 0.003
R_VDD5_15177 METAL6_928400_1122300 METAL6_928400_1122500 0.0004
R_VDD5_15178 METAL6_928400_1122500 METAL6_928400_1129300 0.0136
R_VDD5_15179 METAL6_928400_1129300 METAL6_928400_1132800 0.007
R_VDD5_15180 METAL6_928400_1132800 METAL6_928400_1134300 0.003
R_VDD5_15181 METAL6_928400_1134300 METAL6_928400_1134500 0.0004
R_VDD5_15182 METAL6_928400_1134500 METAL6_928400_1141300 0.0136
R_VDD5_15183 METAL6_928400_1141300 METAL6_928400_1146300 0.01
R_VDD5_15184 METAL6_928400_1146300 METAL6_928400_1153300 0.014
R_VDD5_15185 METAL6_928400_1153300 METAL6_928400_1157700 0.0088
R_VDD5_15186 METAL6_928400_1157700 METAL6_928400_1160600 0.0058
R_VDD5_15187 METAL6_928400_1160600 METAL6_928400_1169700 0.0182
R_VDD5_15188 METAL6_928400_1169700 METAL6_928400_1172600 0.0058
R_VDD5_15189 METAL6_928400_1172600 METAL6_928400_1181700 0.0182
R_VDD5_15190 METAL6_928400_1181700 METAL6_928400_1181800 0.0002
R_VDD5_15191 METAL6_928400_1181800 METAL6_928400_1184600 0.0056
R_VDD5_15192 METAL6_928400_1184600 METAL6_928400_1191600 0.014
R_VDD5_15193 METAL6_928400_1191600 METAL6_928400_1193700 0.0042
R_VDD5_15194 METAL6_928400_1193700 METAL6_928400_1193800 0.0002
R_VDD5_15195 METAL6_928400_1193800 METAL6_928400_1205700 0.0238
R_VDD5_15196 METAL6_928400_1205700 METAL6_928400_1205800 0.0002
R_VDD5_15197 METAL6_928400_1205800 METAL6_928400_1217700 0.0238
R_VDD5_15198 METAL6_928400_1217700 METAL6_928400_1223700 0.012
R_VDD5_15199 METAL6_928400_1223700 METAL6_928400_1229700 0.012
R_VDD5_15200 METAL6_928400_1229700 METAL6_928400_1235700 0.012
R_VDD5_15201 METAL6_928400_1235700 METAL6_928400_1238000 0.0046
R_VDD5_15202 METAL6_928400_1238000 METAL6_928400_1247700 0.0194
R_VDD5_15203 METAL6_928400_1247700 METAL6_928400_1250000 0.0046
R_VDD5_15204 METAL6_928400_1250000 METAL6_928400_1259700 0.0194
R_VDD5_15205 METAL6_928400_1259700 METAL6_928400_1261000 0.0026
R_VDD5_15206 METAL6_928400_1261000 METAL6_928400_1262000 0.002
R_VDD5_15207 METAL6_928400_1262000 METAL6_928400_1271700 0.0194
R_VDD5_15208 METAL6_928400_1271700 METAL6_928400_1273000 0.0026
R_VDD5_15209 METAL6_928400_1273000 METAL6_928400_1283700 0.0214
R_VDD5_15210 METAL6_928400_1283700 METAL6_928400_1285000 0.0026
R_VDD5_15211 METAL6_928400_1285000 METAL6_928400_1295700 0.0214
R_VDD5_15212 METAL6_928400_1295700 METAL6_928400_1297000 0.0026
R_VDD5_15213 METAL6_928400_1297000 METAL6_928400_1302000 0.01
R_VDD5_15214 METAL6_928400_1302000 METAL6_928400_1307700 0.0114
R_VDD5_15215 METAL6_928400_1307700 METAL6_928400_1309000 0.0026
R_VDD5_15216 METAL6_928400_1309000 METAL6_928400_1314000 0.01
R_VDD5_15217 METAL6_928400_1314000 METAL6_928400_1319700 0.0114
R_VDD5_15218 METAL6_928400_1319700 METAL6_928400_1326000 0.0126
R_VDD5_15219 METAL6_928400_1326000 METAL5_928400_1326000 0.1
R_VDD5_15220 METAL5_928400_1326000 METAL5_928400_1338000 0.048
R_VDD5_15221 METAL5_928400_1338000 METAL5_928400_1350000 0.048
R_VDD5_15222 METAL5_928400_1350000 METAL5_928400_1357000 0.028
R_VDD5_15223 METAL5_928400_1357000 METAL5_928400_1362000 0.02
R_VDD5_15224 METAL5_928400_1362000 METAL5_928400_1369000 0.028
R_VDD5_15225 METAL5_928400_1369000 METAL5_928400_1374000 0.02
R_VDD5_15226 METAL5_928400_1374000 METAL5_928400_1381000 0.028
R_VDD5_15227 METAL5_928400_1381000 METAL6_928400_1381000 0.1
R_VDD5_15228 METAL6_928400_1381000 METAL6_928400_1386600 0.0112
R_VDD5_15229 METAL6_928400_1386600 METAL6_928400_1393000 0.0128
R_VDD5_15230 METAL6_928400_1393000 METAL6_928400_1405000 0.024
R_VDD5_15231 METAL6_928400_1405000 METAL6_928400_1437700 0.0654
R_VDD5_15232 METAL6_928400_1437700 METAL6_928400_1449700 0.024
R_VDD5_15233 METAL6_928400_1449700 METAL6_928400_1461700 0.024
R_VDD5_15234 METAL6_928400_1461700 METAL6_928400_1492300 0.0612
R_VDD5_15235 METAL6_928400_1492300 METAL6_928400_1504300 0.024
R_VDD5_15236 METAL6_928400_1504300 METAL6_928400_1516300 0.024
R_VDD5_15237 METAL6_928400_1516300 METAL6_928400_1528300 0.024
R_VDD5_15238 METAL6_928400_1528300 METAL6_928400_1540300 0.024
R_VDD5_15239 METAL6_928400_1540300 METAL5_928400_1540300 0.1
R_VDD5_15240 METAL5_928400_1540300 METAL5_928400_1552300 0.048
R_VDD5_15241 METAL5_928400_1552300 METAL5_928400_1554500 0.0088
R_VDD5_15242 METAL5_928400_1554500 METAL5_928400_1564300 0.0392
R_VDD5_15243 METAL5_928400_1564300 METAL6_928400_1564300 0.1
R_VDD5_15244 METAL6_928400_1564300 METAL6_928400_1571300 0.014
R_VDD5_15245 METAL6_928400_1571300 METAL6_928400_1576300 0.01
R_VDD5_15246 METAL6_928400_1576300 METAL6_928400_1714500 0.2764
R_VDD5_15247 METAL6_928400_1714500 METAL6_928400_1720500 0.012
R_VDD5_15248 METAL6_928400_1720500 METAL6_928400_1726500 0.012
R_VDD5_15249 METAL6_940400_1726500 METAL6_928400_1726500 0.024
R_VDD5_15250 METAL6_195000_3275000 METAL6_207000_3275000 0.024
R_VDD5_15251 METAL6_928400_1726500 METAL6_928400_1731700 0.0104
R_VDD5_15252 METAL6_928400_1731700 METAL6_928400_1738500 0.0136
R_VDD5_15253 METAL6_928400_1738500 METAL5_928400_1738500 0.1
R_VDD5_15254 METAL5_928400_1738500 METAL5_916400_1738500 0.048
R_VDD5_15255 METAL5_916400_1738500 METAL5_904400_1738500 0.048
R_VDD5_15256 METAL5_904400_1738500 METAL5_892400_1738500 0.048
R_VDD5_15257 METAL5_892400_1738500 METAL5_880400_1738500 0.048
R_VDD5_15258 METAL5_880400_1738500 METAL6_880400_1738500 0.1
R_VDD5_15259 METAL6_880400_1738500 METAL6_731000_1738500 0.2988
R_VDD5_15260 METAL6_731000_1738500 METAL6_719000_1738500 0.024
R_VDD5_15261 METAL6_719000_1738500 METAL6_719000_1750500 0.024
R_VDD5_15262 METAL6_719000_1750500 METAL6_719000_1762500 0.024
R_VDD5_15263 METAL6_719000_1762500 METAL6_719000_1774500 0.024
R_VDD5_15264 METAL6_719000_1774500 METAL6_719000_1802500 0.056
R_VDD5_15265 METAL6_719000_1802500 METAL6_719000_1814500 0.024
R_VDD5_15266 METAL6_719000_1814500 METAL6_719000_1826500 0.024
R_VDD5_15267 METAL6_719000_1826500 METAL6_719000_1838500 0.024
R_VDD5_15268 METAL6_719000_1838500 METAL6_719000_1852300 0.0276
R_VDD5_15269 METAL6_719000_1852300 METAL6_719000_1866300 0.028
R_VDD5_15270 METAL6_719000_1866300 METAL6_719000_1902500 0.0724
R_VDD5_15271 METAL6_719000_1902500 METAL6_719000_1914500 0.024
R_VDD5_15272 METAL6_719000_1914500 METAL6_719000_1926500 0.024
R_VDD5_15273 METAL6_719000_1926500 METAL6_719000_1938500 0.024
R_VDD5_15274 METAL6_719000_1938500 METAL6_712000_1938500 0.014
R_VDD5_15275 METAL6_712000_1938500 METAL6_707000_1938500 0.01
R_VDD5_15276 METAL6_707000_1938500 METAL6_700000_1938500 0.014
R_VDD5_15277 METAL6_700000_1938500 METAL6_695000_1938500 0.01
R_VDD5_15278 METAL6_695000_1938500 METAL6_688000_1938500 0.014
R_VDD5_15279 METAL6_688000_1938500 METAL6_676000_1938500 0.024
R_VDD5_15280 METAL6_676000_1938500 METAL6_569000_1938500 0.214
R_VDD5_15281 METAL6_569000_1938500 METAL6_569000_1939000 0.001
R_VDD5_15282 METAL6_569000_1939000 METAL6_569000_1940500 0.003
R_VDD5_15283 METAL6_569000_1940500 METAL6_569000_1950500 0.02
R_VDD5_15284 METAL6_569000_1950500 METAL6_569000_1951000 0.001
R_VDD5_15285 METAL6_569000_1951000 METAL6_569000_1952500 0.003
R_VDD5_15286 METAL6_569000_1952500 METAL6_569000_1962500 0.02
R_VDD5_15287 METAL6_569000_1962500 METAL6_569000_1963000 0.001
R_VDD5_15288 METAL6_569000_1963000 METAL6_569000_1964500 0.003
R_VDD5_15289 METAL6_569000_1964500 METAL6_569000_1975000 0.021
R_VDD5_15290 METAL6_569000_1975000 METAL6_569000_1976500 0.003
R_VDD5_15291 METAL6_569000_1976500 METAL6_569000_1987000 0.021
R_VDD5_15292 METAL6_569000_1987000 METAL6_569000_1988500 0.003
R_VDD5_15293 METAL6_569000_1988500 METAL6_569000_2014500 0.052
R_VDD5_15294 METAL6_569000_2014500 METAL6_569000_2026500 0.024
R_VDD5_15295 METAL6_569000_2026500 METAL6_569000_2038500 0.024
R_VDD5_15296 METAL6_569000_2038500 METAL6_569000_2114500 0.152
R_VDD5_15297 METAL6_569000_2114500 METAL6_569000_2126500 0.024
R_VDD5_15298 METAL6_569000_2126500 METAL6_569000_2138500 0.024
R_VDD5_15299 METAL6_569000_2138500 METAL6_569000_2147300 0.0176
R_VDD5_15300 METAL6_569000_2147300 METAL6_569000_2150500 0.0064
R_VDD5_15301 METAL6_569000_2150500 METAL6_569000_2154300 0.0076
R_VDD5_15302 METAL6_569000_2154300 METAL6_569000_2163000 0.0174
R_VDD5_15303 METAL6_569000_2163000 METAL6_569000_2166300 0.0066
R_VDD5_15304 METAL6_569000_2166300 METAL6_569000_2175000 0.0174
R_VDD5_15305 METAL6_569000_2175000 METAL6_569000_2178300 0.0066
R_VDD5_15306 METAL6_569000_2178300 METAL6_569000_2187000 0.0174
R_VDD5_15307 METAL6_569000_2187000 METAL6_557000_2187000 0.024
R_VDD5_15308 METAL6_557000_2187000 METAL6_557000_2190300 0.0066
R_VDD5_15309 METAL6_557000_2190300 METAL6_557000_2199000 0.0174
R_VDD5_15310 METAL6_557000_2199000 METAL6_557000_2202300 0.0066
R_VDD5_15311 METAL6_557000_2202300 METAL6_557000_2222500 0.0404
R_VDD5_15312 METAL6_557000_2222500 METAL6_557000_2234500 0.024
R_VDD5_15313 METAL6_557000_2234500 METAL6_557000_2246500 0.024
R_VDD5_15314 METAL6_557000_2246500 METAL6_557000_2256500 0.02
R_VDD5_15315 METAL6_557000_2256500 METAL6_557000_2258500 0.004
R_VDD5_15316 METAL6_557000_2258500 METAL6_557000_2268500 0.02
R_VDD5_15317 METAL6_557000_2268500 METAL6_557000_2276000 0.015
R_VDD5_15318 METAL6_557000_2276000 METAL6_557000_2280500 0.009
R_VDD5_15319 METAL6_557000_2280500 METAL6_557000_2288000 0.015
R_VDD5_15320 METAL6_557000_2288000 METAL6_557000_2292000 0.008
R_VDD5_15321 METAL6_557000_2292000 METAL6_557000_2300000 0.016
R_VDD5_15322 METAL6_557000_2300000 METAL6_557000_2304000 0.008
R_VDD5_15323 METAL6_557000_2304000 METAL6_557000_2305000 0.002
R_VDD5_15324 METAL6_557000_2305000 METAL6_557000_2312000 0.014
R_VDD5_15325 METAL6_557000_2312000 METAL6_557000_2314000 0.004
R_VDD5_15326 METAL6_557000_2314000 METAL6_557000_2316000 0.004
R_VDD5_15327 METAL6_557000_2316000 METAL6_557000_2317000 0.002
R_VDD5_15328 METAL6_557000_2317000 METAL6_557000_2324000 0.014
R_VDD5_15329 METAL6_557000_2324000 METAL6_557000_2326000 0.004
R_VDD5_15330 METAL6_557000_2326000 METAL6_557000_2328000 0.004
R_VDD5_15331 METAL6_557000_2328000 METAL6_557000_2329000 0.002
R_VDD5_15332 METAL6_557000_2329000 METAL6_557000_2338000 0.018
R_VDD5_15333 METAL6_557000_2338000 METAL6_557000_2340000 0.004
R_VDD5_15334 METAL6_557000_2340000 METAL6_557000_2341000 0.002
R_VDD5_15335 METAL6_557000_2341000 METAL6_557000_2350000 0.018
R_VDD5_15336 METAL6_557000_2350000 METAL6_557000_2352000 0.004
R_VDD5_15337 METAL6_557000_2352000 METAL6_557000_2353000 0.002
R_VDD5_15338 METAL6_557000_2353000 METAL6_557000_2362000 0.018
R_VDD5_15339 METAL6_557000_2362000 METAL6_557000_2364000 0.004
R_VDD5_15340 METAL6_557000_2364000 METAL6_557000_2365000 0.002
R_VDD5_15341 METAL6_557000_2365000 METAL6_557000_2374000 0.018
R_VDD5_15342 METAL6_557000_2374000 METAL6_557000_2376000 0.004
R_VDD5_15343 METAL6_557000_2376000 METAL6_557000_2377000 0.002
R_VDD5_15344 METAL6_557000_2377000 METAL6_557000_2388000 0.022
R_VDD5_15345 METAL6_557000_2388000 METAL6_557000_2389000 0.002
R_VDD5_15346 METAL6_557000_2389000 METAL6_557000_2395000 0.012
R_VDD5_15347 METAL6_557000_2395000 METAL6_557000_2400000 0.01
R_VDD5_15348 METAL6_557000_2400000 METAL6_557000_2401000 0.002
R_VDD5_15349 METAL6_557000_2401000 METAL6_557000_2407000 0.012
R_VDD5_15350 METAL6_557000_2407000 METAL6_545000_2407000 0.024
R_VDD5_15351 METAL6_545000_2407000 METAL6_545000_2412000 0.01
R_VDD5_15352 METAL6_545000_2412000 METAL6_543000_2412000 0.004
R_VDD5_15353 METAL6_543000_2412000 METAL6_538000_2412000 0.01
R_VDD5_15354 METAL6_538000_2412000 METAL6_533000_2412000 0.01
R_VDD5_15355 METAL6_533000_2412000 METAL6_343000_2412000 0.38
R_VDD5_15356 METAL6_343000_2412000 METAL6_231000_2412000 0.224
R_VDD5_15357 METAL6_231000_2412000 METAL6_219000_2412000 0.024
R_VDD5_15358 METAL6_219000_2412000 METAL6_219000_2413000 0.002
R_VDD5_15359 METAL6_219000_2413000 METAL6_219000_2419000 0.012
R_VDD5_15360 METAL6_219000_2419000 METAL6_219000_2424000 0.01
R_VDD5_15361 METAL6_219000_2424000 METAL6_219000_2436000 0.024
R_VDD5_15362 METAL6_219000_2436000 METAL6_219000_2438000 0.004
R_VDD5_15363 METAL6_219000_2438000 METAL6_219000_2444000 0.012
R_VDD5_15364 METAL6_219000_2444000 METAL6_219000_2450000 0.012
R_VDD5_15365 METAL6_219000_2450000 METAL6_219000_2456000 0.012
R_VDD5_15366 METAL6_219000_2456000 METAL6_219000_2462000 0.012
R_VDD5_15367 METAL6_219000_2462000 METAL6_219000_2468000 0.012
R_VDD5_15368 METAL6_219000_2468000 METAL6_219000_2469000 0.002
R_VDD5_15369 METAL6_219000_2469000 METAL6_219000_2481000 0.024
R_VDD5_15370 METAL6_219000_2481000 METAL6_219000_2493000 0.024
R_VDD5_15371 METAL6_219000_2493000 METAL6_219000_2505000 0.024
R_VDD5_15372 METAL6_219000_2505000 METAL6_219000_2512000 0.014
R_VDD5_15373 METAL6_219000_2512000 METAL6_219000_2517700 0.0114
R_VDD5_15374 METAL6_219000_2517700 METAL6_219000_2524000 0.0126
R_VDD5_15375 METAL6_219000_2524000 METAL6_219000_2529700 0.0114
R_VDD5_15376 METAL6_219000_2529700 METAL6_219000_2536000 0.0126
R_VDD5_15377 METAL6_219000_2536000 METAL6_219000_2541700 0.0114
R_VDD5_15378 METAL6_219000_2541700 METAL6_219000_2548000 0.0126
R_VDD5_15379 METAL6_219000_2548000 METAL6_219000_2553700 0.0114
R_VDD5_15380 METAL6_219000_2553700 METAL6_219000_2589000 0.0706
R_VDD5_15381 METAL6_219000_2589000 METAL6_219000_2603000 0.028
R_VDD5_15382 METAL6_219000_2603000 METAL6_219000_2644000 0.082
R_VDD5_15383 METAL6_219000_2644000 METAL6_219000_2656000 0.024
R_VDD5_15384 METAL6_219000_2656000 METAL6_219000_2665700 0.0194
R_VDD5_15385 METAL6_219000_2665700 METAL6_219000_2668000 0.0046
R_VDD5_15386 METAL6_219000_2668000 METAL6_219000_2701000 0.066
R_VDD5_15387 METAL6_219000_2701000 METAL6_219000_2701700 0.0014
R_VDD5_15388 METAL6_219000_2701700 METAL6_219000_2713000 0.0226
R_VDD5_15389 METAL6_219000_2713000 METAL6_219000_2713700 0.0014
R_VDD5_15390 METAL6_219000_2713700 METAL6_219000_2724000 0.0206
R_VDD5_15391 METAL6_219000_2724000 METAL6_219000_2725000 0.002
R_VDD5_15392 METAL6_219000_2725000 METAL6_219000_2725700 0.0014
R_VDD5_15393 METAL6_219000_2725700 METAL6_219000_2736000 0.0206
R_VDD5_15394 METAL6_219000_2736000 METAL6_219000_2737000 0.002
R_VDD5_15395 METAL6_219000_2737000 METAL6_219000_2737700 0.0014
R_VDD5_15396 METAL6_219000_2737700 METAL6_219000_2748000 0.0206
R_VDD5_15397 METAL6_219000_2748000 METAL6_219000_2777000 0.058
R_VDD5_15398 METAL6_219000_2777000 METAL6_219000_2789000 0.024
R_VDD5_15399 METAL6_219000_2789000 METAL6_219000_2801000 0.024
R_VDD5_15400 METAL6_219000_2801000 METAL6_219000_2801700 0.0014
R_VDD5_15401 METAL6_219000_2801700 METAL6_219000_2803000 0.0026
R_VDD5_15402 METAL6_219000_2803000 METAL6_219000_2808000 0.01
R_VDD5_15403 METAL6_219000_2808000 METAL6_219000_2813700 0.0114
R_VDD5_15404 METAL6_219000_2813700 METAL6_219000_2825700 0.024
R_VDD5_15405 METAL6_219000_2825700 METAL6_219000_2901700 0.152
R_VDD5_15406 METAL6_219000_2901700 METAL6_219000_2913000 0.0226
R_VDD5_15407 METAL6_219000_2913000 METAL6_219000_2913700 0.0014
R_VDD5_15408 METAL6_219000_2913700 METAL6_219000_2925000 0.0226
R_VDD5_15409 METAL6_219000_2925000 METAL6_219000_2925700 0.0014
R_VDD5_15410 METAL6_219000_2925700 METAL6_219000_2937000 0.0226
R_VDD5_15411 METAL6_219000_2937000 METAL6_219000_3001700 0.1294
R_VDD5_15412 METAL6_219000_3001700 METAL6_219000_3013700 0.024
R_VDD5_15413 METAL6_219000_3013700 METAL6_219000_3025700 0.024
R_VDD5_15414 METAL6_219000_3025700 METAL6_219000_3063000 0.0746
R_VDD5_15415 METAL6_219000_3063000 METAL6_219000_3073700 0.0214
R_VDD5_15416 METAL6_219000_3073700 METAL6_219000_3075000 0.0026
R_VDD5_15417 METAL6_219000_3075000 METAL6_219000_3085700 0.0214
R_VDD5_15418 METAL6_219000_3085700 METAL6_219000_3087000 0.0026
R_VDD5_15419 METAL6_219000_3087000 METAL6_207000_3087000 0.024
R_VDD5_15420 METAL6_207000_3087000 METAL6_207000_3089700 0.0054
R_VDD5_15421 METAL6_207000_3089700 METAL6_207000_3097700 0.016
R_VDD5_15422 METAL6_207000_3097700 METAL6_207000_3101700 0.008
R_VDD5_15423 METAL6_207000_3101700 METAL6_207000_3109700 0.016
R_VDD5_15424 METAL6_207000_3109700 METAL6_207000_3113700 0.008
R_VDD5_15425 METAL6_207000_3113700 METAL6_207000_3125700 0.024
R_VDD5_15426 METAL6_207000_3125700 METAL6_207000_3179700 0.108
R_VDD5_15427 METAL6_207000_3179700 METAL6_207000_3255700 0.152
R_VDD5_15428 METAL6_207000_3255700 METAL6_207000_3263000 0.0146
R_VDD5_15429 METAL6_207000_3263000 METAL6_207000_3275000 0.024
R_VDD5_15430 METAL6_545000_2725000 METAL6_557000_2725000 0.024
R_VDD5_15431 METAL6_533000_2412000 METAL6_533000_2413000 0.002
R_VDD5_15432 METAL6_533000_2413000 METAL6_533000_2419000 0.012
R_VDD5_15433 METAL6_533000_2419000 METAL6_533000_2424000 0.01
R_VDD5_15434 METAL6_533000_2424000 METAL6_533000_2436000 0.024
R_VDD5_15435 METAL6_533000_2436000 METAL6_538000_2436000 0.01
R_VDD5_15436 METAL6_538000_2436000 METAL6_543000_2436000 0.01
R_VDD5_15437 METAL6_543000_2436000 METAL6_545000_2436000 0.004
R_VDD5_15438 METAL6_545000_2436000 METAL6_557000_2436000 0.024
R_VDD5_15439 METAL6_557000_2436000 METAL6_557000_2438000 0.004
R_VDD5_15440 METAL6_557000_2438000 METAL6_557000_2444000 0.012
R_VDD5_15441 METAL6_557000_2444000 METAL6_557000_2450000 0.012
R_VDD5_15442 METAL6_557000_2450000 METAL6_557000_2456000 0.012
R_VDD5_15443 METAL6_557000_2456000 METAL6_557000_2462000 0.012
R_VDD5_15444 METAL6_557000_2462000 METAL6_557000_2468000 0.012
R_VDD5_15445 METAL6_557000_2468000 METAL6_557000_2469000 0.002
R_VDD5_15446 METAL6_557000_2469000 METAL6_557000_2481000 0.024
R_VDD5_15447 METAL6_557000_2481000 METAL6_557000_2493000 0.024
R_VDD5_15448 METAL6_557000_2493000 METAL6_557000_2505000 0.024
R_VDD5_15449 METAL6_557000_2505000 METAL6_557000_2512000 0.014
R_VDD5_15450 METAL6_557000_2512000 METAL6_557000_2517700 0.0114
R_VDD5_15451 METAL6_557000_2517700 METAL6_557000_2524000 0.0126
R_VDD5_15452 METAL6_557000_2524000 METAL6_557000_2529700 0.0114
R_VDD5_15453 METAL6_557000_2529700 METAL6_557000_2536000 0.0126
R_VDD5_15454 METAL6_557000_2536000 METAL6_557000_2541700 0.0114
R_VDD5_15455 METAL6_557000_2541700 METAL6_557000_2548000 0.0126
R_VDD5_15456 METAL6_557000_2548000 METAL6_557000_2553700 0.0114
R_VDD5_15457 METAL6_557000_2553700 METAL6_557000_2589000 0.0706
R_VDD5_15458 METAL6_557000_2589000 METAL6_557000_2603000 0.028
R_VDD5_15459 METAL6_557000_2603000 METAL6_557000_2644000 0.082
R_VDD5_15460 METAL6_557000_2644000 METAL6_557000_2656000 0.024
R_VDD5_15461 METAL6_557000_2656000 METAL6_557000_2665700 0.0194
R_VDD5_15462 METAL6_557000_2665700 METAL6_557000_2668000 0.0046
R_VDD5_15463 METAL6_557000_2668000 METAL6_557000_2701000 0.066
R_VDD5_15464 METAL6_557000_2701000 METAL6_557000_2701700 0.0014
R_VDD5_15465 METAL6_557000_2701700 METAL6_557000_2713000 0.0226
R_VDD5_15466 METAL6_557000_2713000 METAL6_557000_2713700 0.0014
R_VDD5_15467 METAL6_557000_2713700 METAL6_557000_2724000 0.0206
R_VDD5_15468 METAL6_557000_2724000 METAL6_557000_2725000 0.002
R_VDD5_15469 METAL6_545000_2175000 METAL6_557000_2175000 0.024
R_VDD5_15470 METAL6_557000_2258500 METAL6_569000_2258500 0.024
R_VDD5_15471 METAL6_569000_2258500 METAL6_569000_2256500 0.004
R_VDD5_15472 METAL6_569000_2256500 METAL6_569000_2246500 0.02
R_VDD5_15473 METAL6_569000_2246500 METAL6_569000_2234500 0.024
R_VDD5_15474 METAL6_569000_2234500 METAL6_569000_2222500 0.024
R_VDD5_15475 METAL6_569000_2222500 METAL6_569000_2202300 0.0404
R_VDD5_15476 METAL6_569000_2202300 METAL6_569000_2199000 0.0066
R_VDD5_15477 METAL6_569000_2199000 METAL5_569000_2199000 0.1
R_VDD5_15478 METAL5_569000_2199000 METAL5_557000_2199000 0.048
R_VDD5_15479 METAL5_557000_2199000 METAL5_557000_2190300 0.0348
R_VDD5_15480 METAL5_557000_2190300 METAL5_557000_2187000 0.0132
R_VDD5_15481 METAL5_557000_2187000 METAL5_557000_2178300 0.0348
R_VDD5_15482 METAL5_557000_2178300 METAL5_557000_2175000 0.0132
R_VDD5_15483 METAL5_557000_2175000 METAL6_557000_2175000 0.1
R_VDD5_15484 METAL6_1325000_3305000 METAL6_1325000_3293000 0.024
R_VDD5_15485 METAL6_1600000_248300 METAL6_1600700_248300 0.0014
R_VDD5_15486 METAL6_1600700_248300 METAL6_1603800_248300 0.0062
R_VDD5_15487 METAL6_1603800_248300 METAL6_1607900_248300 0.0082
R_VDD5_15488 METAL6_1607900_248300 METAL6_1612000_248300 0.0082
R_VDD5_15489 METAL6_1612000_248300 METAL6_1612000_251000 0.0054
R_VDD5_15490 METAL6_1612000_251000 METAL6_1612000_260300 0.0186
R_VDD5_15491 METAL6_1612000_260300 METAL6_1612000_263000 0.0054
R_VDD5_15492 METAL6_1612000_263000 METAL6_1612000_272300 0.0186
R_VDD5_15493 METAL6_1612000_272300 METAL6_1612000_275000 0.0054
R_VDD5_15494 METAL6_1612000_275000 METAL6_1612000_279300 0.0086
R_VDD5_15495 METAL6_1612000_279300 METAL6_1612000_287000 0.0154
R_VDD5_15496 METAL6_1612000_287000 METAL6_1612000_288000 0.002
R_VDD5_15497 METAL6_1612000_288000 METAL6_1612000_299000 0.022
R_VDD5_15498 METAL6_1612000_299000 METAL6_1612000_300000 0.002
R_VDD5_15499 METAL6_1612000_300000 METAL6_1612000_312000 0.024
R_VDD5_15500 METAL6_1612000_312000 METAL6_1612000_355300 0.0866
R_VDD5_15501 METAL6_1612000_355300 METAL6_1612000_362300 0.014
R_VDD5_15502 METAL6_1612000_362300 METAL6_1612000_366800 0.009
R_VDD5_15503 METAL6_1612000_366800 METAL6_1612000_374300 0.015
R_VDD5_15504 METAL6_1612000_374300 METAL6_1612000_378800 0.009
R_VDD5_15505 METAL6_1612000_378800 METAL6_1612000_386300 0.015
R_VDD5_15506 METAL6_1612000_386300 METAL6_1612000_388000 0.0034
R_VDD5_15507 METAL6_1612000_388000 METAL6_1612000_390800 0.0056
R_VDD5_15508 METAL6_1612000_390800 METAL6_1612000_400000 0.0184
R_VDD5_15509 METAL6_1612000_400000 METAL6_1612000_402800 0.0056
R_VDD5_15510 METAL6_1612000_402800 METAL6_1612000_412000 0.0184
R_VDD5_15511 METAL6_1612000_412000 METAL6_1612000_413000 0.002
R_VDD5_15512 METAL6_1612000_413000 METAL6_1612000_414800 0.0036
R_VDD5_15513 METAL6_1612000_414800 METAL6_1612000_425000 0.0204
R_VDD5_15514 METAL6_1612000_425000 METAL6_1612700_425000 0.0014
R_VDD5_15515 METAL6_1612700_425000 METAL6_1615800_425000 0.0062
R_VDD5_15516 METAL6_1615800_425000 METAL6_1624000_425000 0.0164
R_VDD5_15517 METAL6_1624000_425000 METAL5_1624000_425000 0.1
R_VDD5_15518 METAL5_1624000_425000 METAL5_1624000_437000 0.048
R_VDD5_15519 METAL5_1624000_437000 METAL5_1624000_449000 0.048
R_VDD5_15520 METAL5_1624000_449000 METAL5_1624000_453000 0.016
R_VDD5_15521 METAL5_1624000_453000 METAL5_1624000_456400 0.0136
R_VDD5_15522 METAL5_1624000_456400 METAL5_1624000_459000 0.0104
R_VDD5_15523 METAL5_1624000_459000 METAL5_1624000_461000 0.008
R_VDD5_15524 METAL5_1624000_461000 METAL6_1624000_461000 0.1
R_VDD5_15525 METAL6_1624000_461000 METAL6_1624000_465000 0.008
R_VDD5_15526 METAL6_1624000_465000 METAL6_1624000_468400 0.0068
R_VDD5_15527 METAL6_1624000_468400 METAL6_1624000_471000 0.0052
R_VDD5_15528 METAL6_1624000_471000 METAL6_1624000_473000 0.004
R_VDD5_15529 METAL6_1624000_473000 METAL6_1624000_477000 0.008
R_VDD5_15530 METAL6_1624000_477000 METAL6_1624000_480400 0.0068
R_VDD5_15531 METAL6_1624000_480400 METAL6_1624000_483000 0.0052
R_VDD5_15532 METAL6_1624000_483000 METAL6_1624000_488000 0.01
R_VDD5_15533 METAL6_1624000_488000 METAL6_1624000_492400 0.0088
R_VDD5_15534 METAL6_1624000_492400 METAL6_1624000_495000 0.0052
R_VDD5_15535 METAL6_1624000_495000 METAL6_1624000_500000 0.01
R_VDD5_15536 METAL6_1624000_500000 METAL6_1624000_504000 0.008
R_VDD5_15537 METAL6_1624000_504000 METAL6_1624000_507000 0.006
R_VDD5_15538 METAL6_1624000_507000 METAL6_1624000_507800 0.0016
R_VDD5_15539 METAL6_1624000_507800 METAL6_1624000_512000 0.0084
R_VDD5_15540 METAL6_1624000_512000 METAL6_1624000_516000 0.008
R_VDD5_15541 METAL6_1624000_516000 METAL6_1624000_519000 0.006
R_VDD5_15542 METAL6_1624000_519000 METAL6_1624000_520200 0.0024
R_VDD5_15543 METAL6_1624000_520200 METAL6_1624000_528000 0.0156
R_VDD5_15544 METAL6_1624000_528000 METAL6_1624000_532200 0.0084
R_VDD5_15545 METAL6_1624000_532200 METAL6_1624000_535400 0.0064
R_VDD5_15546 METAL6_1624000_535400 METAL6_1624000_544200 0.0176
R_VDD5_15547 METAL6_1624000_544200 METAL6_1624000_547400 0.0064
R_VDD5_15548 METAL6_1624000_547400 METAL6_1624000_550400 0.006
R_VDD5_15549 METAL6_1624000_550400 METAL6_1624000_556200 0.0116
R_VDD5_15550 METAL6_1624000_556200 METAL6_1624000_559400 0.0064
R_VDD5_15551 METAL6_1624000_559400 METAL6_1624000_561000 0.0032
R_VDD5_15552 METAL6_1624000_561000 METAL6_1624000_562400 0.0028
R_VDD5_15553 METAL6_1624000_562400 METAL6_1624000_573000 0.0212
R_VDD5_15554 METAL6_1624000_573000 METAL6_1624000_574400 0.0028
R_VDD5_15555 METAL6_1624000_574400 METAL6_1624000_579800 0.0108
R_VDD5_15556 METAL6_1624000_579800 METAL6_1624000_585000 0.0104
R_VDD5_15557 METAL6_1624000_585000 METAL6_1624000_586400 0.0028
R_VDD5_15558 METAL6_1624000_586400 METAL6_1624000_588000 0.0032
R_VDD5_15559 METAL6_1624000_588000 METAL6_1624000_597000 0.018
R_VDD5_15560 METAL6_1624000_597000 METAL6_1624000_598400 0.0028
R_VDD5_15561 METAL6_1624000_598400 METAL6_1624000_600000 0.0032
R_VDD5_15562 METAL6_1624000_600000 METAL6_1624000_612000 0.024
R_VDD5_15563 METAL6_1624000_612000 METAL6_1624000_617400 0.0108
R_VDD5_15564 METAL6_1624000_617400 METAL6_1624000_629400 0.024
R_VDD5_15565 METAL6_1624000_629400 METAL6_1624000_637800 0.0168
R_VDD5_15566 METAL6_1624000_637800 METAL6_1624000_641400 0.0072
R_VDD5_15567 METAL6_1624000_641400 METAL6_1624000_649800 0.0168
R_VDD5_15568 METAL6_1624000_649800 METAL6_1624000_653400 0.0072
R_VDD5_15569 METAL6_1624000_653400 METAL6_1624000_661800 0.0168
R_VDD5_15570 METAL6_1624000_661800 METAL6_1624000_665400 0.0072
R_VDD5_15571 METAL6_1624000_665400 METAL6_1624000_688000 0.0452
R_VDD5_15572 METAL6_1624000_688000 METAL6_1624000_697800 0.0196
R_VDD5_15573 METAL6_1624000_697800 METAL6_1624000_700000 0.0044
R_VDD5_15574 METAL6_1624000_700000 METAL6_1624000_702800 0.0056
R_VDD5_15575 METAL6_1624000_702800 METAL6_1624000_709800 0.014
R_VDD5_15576 METAL6_1624000_709800 METAL6_1624000_712000 0.0044
R_VDD5_15577 METAL6_1624000_712000 METAL6_1624000_716800 0.0096
R_VDD5_15578 METAL6_1624000_716800 METAL6_1624000_721800 0.01
R_VDD5_15579 METAL6_1624000_721800 METAL6_1624000_733800 0.024
R_VDD5_15580 METAL6_1624000_733800 METAL6_1624700_733800 0.0014
R_VDD5_15581 METAL6_1624700_733800 METAL6_1624700_734400 0.0012
R_VDD5_15582 METAL6_1624700_734400 METAL6_1624700_735400 0.002
R_VDD5_15583 METAL6_1624700_735400 METAL6_1624700_742400 0.014
R_VDD5_15584 METAL6_1624700_742400 METAL6_1624700_745800 0.0068
R_VDD5_15585 METAL6_1624700_745800 METAL6_1624700_746400 0.0012
R_VDD5_15586 METAL6_1624700_746400 METAL6_1624700_754400 0.016
R_VDD5_15587 METAL6_1624700_754400 METAL6_1624700_757800 0.0068
R_VDD5_15588 METAL6_1624700_757800 METAL6_1624700_758400 0.0012
R_VDD5_15589 METAL6_1624700_758400 METAL6_1624700_760000 0.0032
R_VDD5_15590 METAL6_1624700_760000 METAL6_1624700_763000 0.006
R_VDD5_15591 METAL6_1624700_763000 METAL6_1624700_766400 0.0068
R_VDD5_15592 METAL6_1624700_766400 METAL6_1624700_769800 0.0068
R_VDD5_15593 METAL6_1624700_769800 METAL6_1624700_770400 0.0012
R_VDD5_15594 METAL6_1624700_770400 METAL5_1624700_770400 0.1
R_VDD5_15595 METAL5_1624700_770400 METAL5_1624700_772000 0.0064
R_VDD5_15596 METAL5_1624700_772000 METAL5_1624700_778400 0.0256
R_VDD5_15597 METAL5_1624700_778400 METAL5_1624700_779200 0.0032
R_VDD5_15598 METAL5_1624700_779200 METAL5_1624700_782400 0.0128
R_VDD5_15599 METAL5_1624700_782400 METAL5_1624700_784000 0.0064
R_VDD5_15600 METAL5_1624700_784000 METAL5_1624700_784500 0.002
R_VDD5_15601 METAL5_1624700_784500 METAL5_1624700_788000 0.014
R_VDD5_15602 METAL5_1624700_788000 METAL5_1624700_790400 0.0096
R_VDD5_15603 METAL5_1624700_790400 METAL5_1624700_791200 0.0032
R_VDD5_15604 METAL5_1624700_791200 METAL5_1624700_794400 0.0128
R_VDD5_15605 METAL5_1624700_794400 METAL5_1624700_794800 0.0016
R_VDD5_15606 METAL5_1624700_794800 METAL5_1624700_800000 0.0208
R_VDD5_15607 METAL5_1624700_800000 METAL5_1624700_802400 0.0096
R_VDD5_15608 METAL5_1624700_802400 METAL5_1624700_803200 0.0032
R_VDD5_15609 METAL5_1624700_803200 METAL5_1624700_806400 0.0128
R_VDD5_15610 METAL5_1624700_806400 METAL5_1624700_808000 0.0064
R_VDD5_15611 METAL5_1624700_808000 METAL5_1624700_812000 0.016
R_VDD5_15612 METAL5_1624700_812000 METAL5_1624700_814400 0.0096
R_VDD5_15613 METAL5_1624700_814400 METAL5_1624700_818400 0.016
R_VDD5_15614 METAL5_1624700_818400 METAL5_1624700_820000 0.0064
R_VDD5_15615 METAL5_1624700_820000 METAL5_1624700_828700 0.0348
R_VDD5_15616 METAL5_1624700_828700 METAL5_1624700_830400 0.0068
R_VDD5_15617 METAL5_1624700_830400 METAL5_1624700_832000 0.0064
R_VDD5_15618 METAL5_1624700_832000 METAL5_1624700_839500 0.03
R_VDD5_15619 METAL5_1624700_839500 METAL5_1624700_840700 0.0048
R_VDD5_15620 METAL5_1624700_840700 METAL5_1624700_842400 0.0068
R_VDD5_15621 METAL5_1624700_842400 METAL6_1624700_842400 0.1
R_VDD5_15622 METAL6_1624700_842400 METAL6_1624700_851500 0.0182
R_VDD5_15623 METAL6_1624700_851500 METAL6_1624700_852700 0.0024
R_VDD5_15624 METAL6_1624700_852700 METAL6_1624700_858200 0.011
R_VDD5_15625 METAL6_1624700_858200 METAL6_1624700_863500 0.0106
R_VDD5_15626 METAL6_1624700_863500 METAL6_1624700_875000 0.023
R_VDD5_15627 METAL6_1624700_875000 METAL6_1624700_887000 0.024
R_VDD5_15628 METAL6_1624700_887000 METAL6_1624700_888000 0.002
R_VDD5_15629 METAL6_1624700_888000 METAL6_1624700_899000 0.022
R_VDD5_15630 METAL6_1624700_899000 METAL6_1624700_900000 0.002
R_VDD5_15631 METAL6_1624700_900000 METAL6_1624700_900400 0.0008
R_VDD5_15632 METAL6_1624700_900400 METAL6_1624700_912000 0.0232
R_VDD5_15633 METAL6_1624700_912000 METAL6_1624700_923000 0.022
R_VDD5_15634 METAL6_1624700_923000 METAL6_1624700_927300 0.0086
R_VDD5_15635 METAL6_1624700_927300 METAL6_1624700_935000 0.0154
R_VDD5_15636 METAL6_1624700_935000 METAL6_1624700_947000 0.024
R_VDD5_15637 METAL6_1624700_947000 METAL6_1624700_959000 0.024
R_VDD5_15638 METAL6_1624700_959000 METAL6_1624700_971000 0.024
R_VDD5_15639 METAL6_1624700_971000 METAL6_1624700_976000 0.01
R_VDD5_15640 METAL6_1624700_976000 METAL6_1624700_983000 0.014
R_VDD5_15641 METAL6_1624700_983000 METAL6_1624700_988000 0.01
R_VDD5_15642 METAL6_1624700_988000 METAL6_1624700_995000 0.014
R_VDD5_15643 METAL6_1624700_995000 METAL6_1624700_1000000 0.01
R_VDD5_15644 METAL6_1624700_1000000 METAL6_1624700_1007000 0.014
R_VDD5_15645 METAL6_1624700_1007000 METAL6_1624700_1012000 0.01
R_VDD5_15646 METAL6_1624700_1012000 METAL6_1624700_1014000 0.004
R_VDD5_15647 METAL6_1624700_1014000 METAL6_1624700_1019000 0.01
R_VDD5_15648 METAL6_1624700_1019000 METAL6_1624700_1023700 0.0094
R_VDD5_15649 METAL6_1624700_1023700 METAL6_1624700_1025400 0.0034
R_VDD5_15650 METAL6_1624700_1025400 METAL6_1624700_1026000 0.0012
R_VDD5_15651 METAL6_1624700_1026000 METAL6_1624700_1029800 0.0076
R_VDD5_15652 METAL6_1624700_1029800 METAL6_1624700_1031000 0.0024
R_VDD5_15653 METAL6_1624700_1031000 METAL6_1624700_1035700 0.0094
R_VDD5_15654 METAL6_1624700_1035700 METAL6_1624700_1037400 0.0034
R_VDD5_15655 METAL6_1624700_1037400 METAL6_1624700_1038000 0.0012
R_VDD5_15656 METAL6_1624700_1038000 METAL6_1624700_1041800 0.0076
R_VDD5_15657 METAL6_1624700_1041800 METAL6_1624700_1042700 0.0018
R_VDD5_15658 METAL6_1624700_1042700 METAL6_1624700_1043000 0.0006
R_VDD5_15659 METAL6_1624700_1043000 METAL6_1624700_1047700 0.0094
R_VDD5_15660 METAL6_1624700_1047700 METAL6_1624700_1049400 0.0034
R_VDD5_15661 METAL6_1624700_1049400 METAL6_1624700_1049800 0.0008
R_VDD5_15662 METAL6_1624700_1049800 METAL6_1624700_1053800 0.008
R_VDD5_15663 METAL6_1624700_1053800 METAL6_1624700_1054700 0.0018
R_VDD5_15664 METAL6_1624700_1054700 METAL6_1624700_1061400 0.0134
R_VDD5_15665 METAL6_1624700_1061400 METAL6_1624700_1061800 0.0008
R_VDD5_15666 METAL6_1624700_1061800 METAL6_1624700_1066700 0.0098
R_VDD5_15667 METAL6_1624700_1066700 METAL6_1624700_1073400 0.0134
R_VDD5_15668 METAL6_1624700_1073400 METAL6_1624000_1073400 0.0014
R_VDD5_15669 METAL6_1624000_1073400 METAL6_1615800_1073400 0.0164
R_VDD5_15670 METAL6_1615800_1073400 METAL6_1612700_1073400 0.0062
R_VDD5_15671 METAL6_1612700_1073400 METAL6_1612000_1073400 0.0014
R_VDD5_15672 METAL6_1612000_1073400 METAL6_1607900_1073400 0.0082
R_VDD5_15673 METAL6_1607900_1073400 METAL6_1603800_1073400 0.0082
R_VDD5_15674 METAL6_1603800_1073400 METAL6_1600700_1073400 0.0062
R_VDD5_15675 METAL6_1600700_1073400 METAL6_1600000_1073400 0.0014
R_VDD5_15676 METAL6_1600000_1073400 METAL6_1591800_1073400 0.0164
R_VDD5_15677 METAL6_1591800_1073400 METAL6_1588700_1073400 0.0062
R_VDD5_15678 METAL6_1588700_1073400 METAL6_1588000_1073400 0.0014
R_VDD5_15679 METAL6_1588000_1073400 METAL6_1579800_1073400 0.0164
R_VDD5_15680 METAL6_1579800_1073400 METAL6_1576700_1073400 0.0062
R_VDD5_15681 METAL6_1576700_1073400 METAL6_1576000_1073400 0.0014
R_VDD5_15682 METAL6_1576000_1073400 METAL6_1574700_1073400 0.0026
R_VDD5_15683 METAL6_1574700_1073400 METAL6_1569000_1073400 0.0114
R_VDD5_15684 METAL6_1569000_1073400 METAL6_1564000_1073400 0.01
R_VDD5_15685 METAL6_1564000_1073400 METAL6_1557000_1073400 0.014
R_VDD5_15686 METAL6_1557000_1073400 METAL6_1555400_1073400 0.0032
R_VDD5_15687 METAL6_1555400_1073400 METAL6_1552000_1073400 0.0068
R_VDD5_15688 METAL6_1552000_1073400 METAL6_1552000_1073800 0.0008
R_VDD5_15689 METAL6_1552000_1073800 METAL6_1551800_1073800 0.0004
R_VDD5_15690 METAL6_1551800_1073800 METAL6_1545000_1073800 0.0136
R_VDD5_15691 METAL6_1545000_1073800 METAL6_1539800_1073800 0.0104
R_VDD5_15692 METAL6_1539800_1073800 METAL6_1527800_1073800 0.024
R_VDD5_15693 METAL6_1527800_1073800 METAL6_1512000_1073800 0.0316
R_VDD5_15694 METAL6_1512000_1073800 METAL6_1510400_1073800 0.0032
R_VDD5_15695 METAL6_1510400_1073800 METAL6_1503400_1073800 0.014
R_VDD5_15696 METAL6_1503400_1073800 METAL6_1500000_1073800 0.0068
R_VDD5_15697 METAL6_1500000_1073800 METAL6_1498300_1073800 0.0034
R_VDD5_15698 METAL6_1498300_1073800 METAL6_1491400_1073800 0.0138
R_VDD5_15699 METAL6_1491400_1073800 METAL6_1488000_1073800 0.0068
R_VDD5_15700 METAL6_1488000_1073800 METAL6_1479400_1073800 0.0172
R_VDD5_15701 METAL6_1479400_1073800 METAL6_1444800_1073800 0.0692
R_VDD5_15702 METAL6_1444800_1073800 METAL6_1443700_1073800 0.0022
R_VDD5_15703 METAL6_1443700_1073800 METAL6_1432800_1073800 0.0218
R_VDD5_15704 METAL6_1432800_1073800 METAL6_1431700_1073800 0.0022
R_VDD5_15705 METAL6_1431700_1073800 METAL6_1424000_1073800 0.0154
R_VDD5_15706 METAL6_1424000_1073800 METAL6_1420800_1073800 0.0064
R_VDD5_15707 METAL6_1420800_1073800 METAL6_1419700_1073800 0.0022
R_VDD5_15708 METAL6_1419700_1073800 METAL6_1412000_1073800 0.0154
R_VDD5_15709 METAL6_1412000_1073800 METAL6_1408800_1073800 0.0064
R_VDD5_15710 METAL6_1408800_1073800 METAL6_1400000_1073800 0.0176
R_VDD5_15711 METAL6_1400000_1073800 METAL6_1388000_1073800 0.024
R_VDD5_15712 METAL6_1388000_1073800 METAL6_1337000_1073800 0.102
R_VDD5_15713 METAL6_1337000_1073800 METAL6_1336000_1073800 0.002
R_VDD5_15714 METAL6_1336000_1073800 METAL6_1336000_1074000 0.0004
R_VDD5_15715 METAL6_1336000_1074000 METAL6_1336000_1074500 0.001
R_VDD5_15716 METAL6_1336000_1074500 METAL6_1336000_1085800 0.0226
R_VDD5_15717 METAL6_1336000_1085800 METAL6_1336000_1086000 0.0004
R_VDD5_15718 METAL6_1336000_1086000 METAL6_1336000_1086300 0.0006
R_VDD5_15719 METAL6_1336000_1086300 METAL6_1336000_1086500 0.0004
R_VDD5_15720 METAL6_1336000_1086500 METAL6_1336000_1088000 0.003
R_VDD5_15721 METAL6_1336000_1088000 METAL6_1336000_1096800 0.0176
R_VDD5_15722 METAL6_1336000_1096800 METAL6_1336000_1098000 0.0024
R_VDD5_15723 METAL6_1336000_1098000 METAL6_1336000_1098300 0.0006
R_VDD5_15724 METAL6_1336000_1098300 METAL6_1336000_1098500 0.0004
R_VDD5_15725 METAL6_1336000_1098500 METAL6_1336000_1100000 0.003
R_VDD5_15726 METAL6_1336000_1100000 METAL6_1336000_1108800 0.0176
R_VDD5_15727 METAL6_1336000_1108800 METAL6_1336000_1110000 0.0024
R_VDD5_15728 METAL6_1336000_1110000 METAL6_1336000_1110300 0.0006
R_VDD5_15729 METAL6_1336000_1110300 METAL6_1336000_1110500 0.0004
R_VDD5_15730 METAL6_1336000_1110500 METAL6_1336000_1112000 0.003
R_VDD5_15731 METAL6_1336000_1112000 METAL6_1336000_1120800 0.0176
R_VDD5_15732 METAL6_1336000_1120800 METAL6_1336000_1122300 0.003
R_VDD5_15733 METAL6_1336000_1122300 METAL6_1325000_1122300 0.022
R_VDD5_15734 METAL6_1325000_1122300 METAL6_1324000_1122300 0.002
R_VDD5_15735 METAL6_1324000_1122300 METAL6_1323800_1122300 0.0004
R_VDD5_15736 METAL6_1323800_1122300 METAL6_1313000_1122300 0.0216
R_VDD5_15737 METAL6_1313000_1122300 METAL6_1312000_1122300 0.002
R_VDD5_15738 METAL6_1312000_1122300 METAL6_1311800_1122300 0.0004
R_VDD5_15739 METAL6_1311800_1122300 METAL6_1301000_1122300 0.0216
R_VDD5_15740 METAL6_1301000_1122300 METAL6_1300000_1122300 0.002
R_VDD5_15741 METAL6_1300000_1122300 METAL6_1300000_1122500 0.0004
R_VDD5_15742 METAL6_1300000_1122500 METAL6_1300000_1129300 0.0136
R_VDD5_15743 METAL6_1300000_1129300 METAL6_1300000_1132800 0.007
R_VDD5_15744 METAL6_1300000_1132800 METAL6_1300000_1134300 0.003
R_VDD5_15745 METAL6_1300000_1134300 METAL6_1300000_1134500 0.0004
R_VDD5_15746 METAL6_1300000_1134500 METAL6_1300000_1141300 0.0136
R_VDD5_15747 METAL6_1300000_1141300 METAL6_1300000_1146300 0.01
R_VDD5_15748 METAL6_1300000_1146300 METAL6_1300000_1153300 0.014
R_VDD5_15749 METAL6_1300000_1153300 METAL6_1300000_1157700 0.0088
R_VDD5_15750 METAL6_1300000_1157700 METAL6_1300000_1160600 0.0058
R_VDD5_15751 METAL6_1300000_1160600 METAL6_1300000_1169700 0.0182
R_VDD5_15752 METAL6_1300000_1169700 METAL5_1300000_1169700 0.1
R_VDD5_15753 METAL5_1300000_1169700 METAL5_1300000_1172600 0.0116
R_VDD5_15754 METAL5_1300000_1172600 METAL5_1300000_1181700 0.0364
R_VDD5_15755 METAL5_1300000_1181700 METAL5_1300000_1181800 0.0004
R_VDD5_15756 METAL5_1300000_1181800 METAL5_1300000_1184600 0.0112
R_VDD5_15757 METAL5_1300000_1184600 METAL5_1300000_1191600 0.028
R_VDD5_15758 METAL5_1300000_1191600 METAL5_1300000_1193700 0.0084
R_VDD5_15759 METAL5_1300000_1193700 METAL5_1300000_1193800 0.0004
R_VDD5_15760 METAL5_1300000_1193800 METAL5_1300000_1205700 0.0476
R_VDD5_15761 METAL5_1300000_1205700 METAL6_1300000_1205700 0.1
R_VDD5_15762 METAL6_1300000_1205700 METAL6_1299800_1205700 0.0004
R_VDD5_15763 METAL6_1299800_1205700 METAL6_1289000_1205700 0.0216
R_VDD5_15764 METAL6_1289000_1205700 METAL6_1288000_1205700 0.002
R_VDD5_15765 METAL6_1288000_1205700 METAL6_1287800_1205700 0.0004
R_VDD5_15766 METAL6_1287800_1205700 METAL6_1286700_1205700 0.0022
R_VDD5_15767 METAL6_1286700_1205700 METAL6_1276000_1205700 0.0214
R_VDD5_15768 METAL6_1276000_1205700 METAL6_1274700_1205700 0.0026
R_VDD5_15769 METAL6_1274700_1205700 METAL6_1270300_1205700 0.0088
R_VDD5_15770 METAL6_1270300_1205700 METAL6_1270300_1205800 0.0002
R_VDD5_15771 METAL6_1270300_1205800 METAL6_1270300_1217700 0.0238
R_VDD5_15772 METAL6_1270300_1217700 METAL6_1270300_1223700 0.012
R_VDD5_15773 METAL6_1270300_1223700 METAL6_1270300_1229700 0.012
R_VDD5_15774 METAL6_1270300_1229700 METAL6_1270300_1235700 0.012
R_VDD5_15775 METAL6_1270300_1235700 METAL6_1270300_1238000 0.0046
R_VDD5_15776 METAL6_1270300_1238000 METAL6_1270300_1247700 0.0194
R_VDD5_15777 METAL6_1270300_1247700 METAL6_1270300_1250000 0.0046
R_VDD5_15778 METAL6_1270300_1250000 METAL6_1270300_1259700 0.0194
R_VDD5_15779 METAL6_1270300_1259700 METAL6_1270300_1261000 0.0026
R_VDD5_15780 METAL6_1270300_1261000 METAL6_1270300_1262000 0.002
R_VDD5_15781 METAL6_1270300_1262000 METAL6_1270300_1271700 0.0194
R_VDD5_15782 METAL6_1270300_1271700 METAL6_1270300_1273000 0.0026
R_VDD5_15783 METAL6_1270300_1273000 METAL6_1270300_1283700 0.0214
R_VDD5_15784 METAL6_1270300_1283700 METAL6_1270300_1285000 0.0026
R_VDD5_15785 METAL6_1270300_1285000 METAL6_1270300_1295700 0.0214
R_VDD5_15786 METAL6_1270300_1295700 METAL6_1270300_1297000 0.0026
R_VDD5_15787 METAL6_1270300_1297000 METAL6_1270300_1302000 0.01
R_VDD5_15788 METAL6_1270300_1302000 METAL6_1270300_1307700 0.0114
R_VDD5_15789 METAL6_1270300_1307700 METAL6_1270300_1309000 0.0026
R_VDD5_15790 METAL6_1270300_1309000 METAL6_1270300_1314000 0.01
R_VDD5_15791 METAL6_1270300_1314000 METAL5_1270300_1314000 0.1
R_VDD5_15792 METAL5_1270300_1314000 METAL5_1270300_1319700 0.0228
R_VDD5_15793 METAL5_1270300_1319700 METAL5_1270300_1326000 0.0252
R_VDD5_15794 METAL5_1270300_1326000 METAL5_1270300_1338000 0.048
R_VDD5_15795 METAL5_1270300_1338000 METAL5_1270300_1350000 0.048
R_VDD5_15796 METAL5_1270300_1350000 METAL5_1270300_1357000 0.028
R_VDD5_15797 METAL5_1270300_1357000 METAL5_1270300_1362000 0.02
R_VDD5_15798 METAL5_1270300_1362000 METAL6_1270300_1362000 0.1
R_VDD5_15799 METAL6_1270300_1362000 METAL6_1270300_1369000 0.014
R_VDD5_15800 METAL6_1270300_1369000 METAL6_1270300_1374000 0.01
R_VDD5_15801 METAL6_1270300_1374000 METAL6_1270300_1381000 0.014
R_VDD5_15802 METAL6_1270300_1381000 METAL6_1270300_1386600 0.0112
R_VDD5_15803 METAL6_1270300_1386600 METAL6_1270300_1393000 0.0128
R_VDD5_15804 METAL6_1270300_1393000 METAL6_1270300_1405000 0.024
R_VDD5_15805 METAL6_1270300_1405000 METAL6_1270300_1437700 0.0654
R_VDD5_15806 METAL6_1270300_1437700 METAL6_1270300_1449700 0.024
R_VDD5_15807 METAL6_1270300_1449700 METAL6_1270300_1461700 0.024
R_VDD5_15808 METAL6_1270300_1461700 METAL6_1270300_1492300 0.0612
R_VDD5_15809 METAL6_1270300_1492300 METAL6_1270300_1504300 0.024
R_VDD5_15810 METAL6_1270300_1504300 METAL6_1270300_1516300 0.024
R_VDD5_15811 METAL6_1270300_1516300 METAL6_1270300_1528300 0.024
R_VDD5_15812 METAL6_1270300_1528300 METAL6_1270300_1540300 0.024
R_VDD5_15813 METAL6_1270300_1540300 METAL5_1270300_1540300 0.1
R_VDD5_15814 METAL5_1270300_1540300 METAL5_1270300_1552300 0.048
R_VDD5_15815 METAL5_1270300_1552300 METAL5_1266800_1552300 0.014
R_VDD5_15816 METAL5_1266800_1552300 METAL5_1262700_1552300 0.0164
R_VDD5_15817 METAL5_1262700_1552300 METAL5_1259800_1552300 0.0116
R_VDD5_15818 METAL5_1259800_1552300 METAL5_1258300_1552300 0.006
R_VDD5_15819 METAL5_1258300_1552300 METAL5_1254700_1552300 0.0144
R_VDD5_15820 METAL5_1254700_1552300 METAL5_1253300_1552300 0.0056
R_VDD5_15821 METAL5_1253300_1552300 METAL5_1247800_1552300 0.022
R_VDD5_15822 METAL5_1247800_1552300 METAL5_1246300_1552300 0.006
R_VDD5_15823 METAL5_1246300_1552300 METAL6_1246300_1552300 0.1
R_VDD5_15824 METAL6_1246300_1552300 METAL6_1246300_1554500 0.0044
R_VDD5_15825 METAL6_1246300_1554500 METAL6_1246300_1564300 0.0196
R_VDD5_15826 METAL6_1246300_1564300 METAL6_1246300_1571300 0.014
R_VDD5_15827 METAL6_1246300_1571300 METAL6_1246300_1576300 0.01
R_VDD5_15828 METAL6_1246300_1576300 METAL6_1246300_1714500 0.2764
R_VDD5_15829 METAL6_1246300_1714500 METAL6_1246300_1720500 0.012
R_VDD5_15830 METAL6_1246300_1720500 METAL6_1246300_1726500 0.012
R_VDD5_15831 METAL6_1246300_1726500 METAL6_1246300_1731700 0.0104
R_VDD5_15832 METAL6_1246300_1731700 METAL6_1246300_1738500 0.0136
R_VDD5_15833 METAL6_1246300_1738500 METAL6_1246300_1750500 0.024
R_VDD5_15834 METAL6_1246300_1750500 METAL6_1246300_1762500 0.024
R_VDD5_15835 METAL6_1246300_1762500 METAL6_1246300_1774500 0.024
R_VDD5_15836 METAL6_1246300_1774500 METAL6_1246300_1802500 0.056
R_VDD5_15837 METAL6_1246300_1802500 METAL6_1246300_1814500 0.024
R_VDD5_15838 METAL6_1246300_1814500 METAL6_1246300_1826500 0.024
R_VDD5_15839 METAL6_1246300_1826500 METAL6_1246300_1838500 0.024
R_VDD5_15840 METAL6_1246300_1838500 METAL6_1246300_1852300 0.0276
R_VDD5_15841 METAL6_1246300_1852300 METAL6_1246300_1866300 0.028
R_VDD5_15842 METAL6_1246300_1866300 METAL6_1246300_1902500 0.0724
R_VDD5_15843 METAL6_1246300_1902500 METAL6_1246300_1914500 0.024
R_VDD5_15844 METAL6_1246300_1914500 METAL6_1246300_1926500 0.024
R_VDD5_15845 METAL6_1246300_1926500 METAL6_1246300_1938500 0.024
R_VDD5_15846 METAL6_1246300_1938500 METAL6_1246300_1939000 0.001
R_VDD5_15847 METAL6_1246300_1939000 METAL6_1246300_1940500 0.003
R_VDD5_15848 METAL6_1246300_1940500 METAL6_1246300_1950500 0.02
R_VDD5_15849 METAL6_1246300_1950500 METAL6_1246300_1951000 0.001
R_VDD5_15850 METAL6_1246300_1951000 METAL5_1246300_1951000 0.1
R_VDD5_15851 METAL5_1246300_1951000 METAL5_1242700_1951000 0.0144
R_VDD5_15852 METAL5_1242700_1951000 METAL5_1236000_1951000 0.0268
R_VDD5_15853 METAL5_1236000_1951000 METAL5_1236000_1952500 0.006
R_VDD5_15854 METAL5_1236000_1952500 METAL5_1236000_1962500 0.04
R_VDD5_15855 METAL5_1236000_1962500 METAL5_1235800_1962500 0.0008
R_VDD5_15856 METAL5_1235800_1962500 METAL5_1234300_1962500 0.006
R_VDD5_15857 METAL5_1234300_1962500 METAL5_1230700_1962500 0.0144
R_VDD5_15858 METAL5_1230700_1962500 METAL5_1224000_1962500 0.0268
R_VDD5_15859 METAL5_1224000_1962500 METAL5_1223800_1962500 0.0008
R_VDD5_15860 METAL5_1223800_1962500 METAL5_1222300_1962500 0.006
R_VDD5_15861 METAL5_1222300_1962500 METAL6_1222300_1962500 0.1
R_VDD5_15862 METAL6_1222300_1962500 METAL6_1222300_1963000 0.001
R_VDD5_15863 METAL6_1222300_1963000 METAL6_1222300_1964500 0.003
R_VDD5_15864 METAL6_1222300_1964500 METAL6_1222300_1975000 0.021
R_VDD5_15865 METAL6_1222300_1975000 METAL6_1222300_1976500 0.003
R_VDD5_15866 METAL6_1222300_1976500 METAL6_1222300_1987000 0.021
R_VDD5_15867 METAL6_1222300_1987000 METAL6_1222300_1988500 0.003
R_VDD5_15868 METAL6_1222300_1988500 METAL6_1222300_2014500 0.052
R_VDD5_15869 METAL6_1222300_2014500 METAL6_1222300_2026500 0.024
R_VDD5_15870 METAL6_1222300_2026500 METAL6_1222300_2038500 0.024
R_VDD5_15871 METAL6_1222300_2038500 METAL6_1222300_2114500 0.152
R_VDD5_15872 METAL6_1222300_2114500 METAL6_1222300_2126500 0.024
R_VDD5_15873 METAL6_1222300_2126500 METAL6_1222300_2138500 0.024
R_VDD5_15874 METAL6_1222300_2138500 METAL6_1222300_2147300 0.0176
R_VDD5_15875 METAL6_1222300_2147300 METAL6_1222300_2150500 0.0064
R_VDD5_15876 METAL6_1222300_2150500 METAL6_1222300_2154300 0.0076
R_VDD5_15877 METAL6_1222300_2154300 METAL6_1222300_2163000 0.0174
R_VDD5_15878 METAL6_1222300_2163000 METAL6_1222300_2166300 0.0066
R_VDD5_15879 METAL6_1222300_2166300 METAL6_1222300_2175000 0.0174
R_VDD5_15880 METAL6_1222300_2175000 METAL6_1222300_2178300 0.0066
R_VDD5_15881 METAL6_1222300_2178300 METAL6_1222300_2187000 0.0174
R_VDD5_15882 METAL6_1222300_2187000 METAL6_1222300_2190300 0.0066
R_VDD5_15883 METAL6_1222300_2190300 METAL6_1222300_2199000 0.0174
R_VDD5_15884 METAL6_1222300_2199000 METAL6_1222300_2202300 0.0066
R_VDD5_15885 METAL6_1222300_2202300 METAL6_1222300_2211000 0.0174
R_VDD5_15886 METAL6_1222300_2211000 METAL6_1222300_2222500 0.023
R_VDD5_15887 METAL6_1222300_2222500 METAL6_1222300_2234500 0.024
R_VDD5_15888 METAL6_1222300_2234500 METAL6_1222300_2246500 0.024
R_VDD5_15889 METAL6_1222300_2246500 METAL6_1222300_2256500 0.02
R_VDD5_15890 METAL6_1222300_2256500 METAL6_1222300_2258500 0.004
R_VDD5_15891 METAL6_1222300_2258500 METAL6_1222300_2268500 0.02
R_VDD5_15892 METAL6_1222300_2268500 METAL6_1222300_2270500 0.004
R_VDD5_15893 METAL6_1222300_2270500 METAL6_1222300_2276000 0.011
R_VDD5_15894 METAL6_1222300_2276000 METAL6_1222300_2280500 0.009
R_VDD5_15895 METAL6_1222300_2280500 METAL6_1222300_2288000 0.015
R_VDD5_15896 METAL6_1222300_2288000 METAL6_1222300_2292000 0.008
R_VDD5_15897 METAL6_1222300_2292000 METAL6_1222300_2300000 0.016
R_VDD5_15898 METAL6_1222300_2300000 METAL6_1222300_2304000 0.008
R_VDD5_15899 METAL6_1222300_2304000 METAL6_1222300_2305000 0.002
R_VDD5_15900 METAL6_1222300_2305000 METAL6_1222300_2312000 0.014
R_VDD5_15901 METAL6_1222300_2312000 METAL6_1222300_2314000 0.004
R_VDD5_15902 METAL6_1222300_2314000 METAL6_1222300_2316000 0.004
R_VDD5_15903 METAL6_1222300_2316000 METAL6_1222300_2317000 0.002
R_VDD5_15904 METAL6_1222300_2317000 METAL6_1222300_2324000 0.014
R_VDD5_15905 METAL6_1222300_2324000 METAL5_1222300_2324000 0.1
R_VDD5_15906 METAL5_1222300_2324000 METAL5_1218700_2324000 0.0144
R_VDD5_15907 METAL5_1218700_2324000 METAL5_1216400_2324000 0.0092
R_VDD5_15908 METAL5_1216400_2324000 METAL5_1212000_2324000 0.0176
R_VDD5_15909 METAL5_1212000_2324000 METAL5_1211800_2324000 0.0008
R_VDD5_15910 METAL5_1211800_2324000 METAL5_1210300_2324000 0.006
R_VDD5_15911 METAL5_1210300_2324000 METAL5_1206700_2324000 0.0144
R_VDD5_15912 METAL5_1206700_2324000 METAL5_1204400_2324000 0.0092
R_VDD5_15913 METAL5_1204400_2324000 METAL5_1200000_2324000 0.0176
R_VDD5_15914 METAL5_1200000_2324000 METAL5_1199800_2324000 0.0008
R_VDD5_15915 METAL5_1199800_2324000 METAL5_1198300_2324000 0.006
R_VDD5_15916 METAL5_1198300_2324000 METAL5_1194700_2324000 0.0144
R_VDD5_15917 METAL5_1194700_2324000 METAL5_1192400_2324000 0.0092
R_VDD5_15918 METAL5_1192400_2324000 METAL5_1188000_2324000 0.0176
R_VDD5_15919 METAL5_1188000_2324000 METAL5_1186300_2324000 0.0068
R_VDD5_15920 METAL5_1186300_2324000 METAL5_1180400_2324000 0.0236
R_VDD5_15921 METAL5_1180400_2324000 METAL5_1174300_2324000 0.0244
R_VDD5_15922 METAL5_1174300_2324000 METAL5_1173700_2324000 0.0024
R_VDD5_15923 METAL5_1173700_2324000 METAL5_1166700_2324000 0.028
R_VDD5_15924 METAL5_1166700_2324000 METAL5_1162300_2324000 0.0176
R_VDD5_15925 METAL5_1162300_2324000 METAL6_1162300_2324000 0.1
R_VDD5_15926 METAL6_1162300_2324000 METAL6_1162300_2326000 0.004
R_VDD5_15927 METAL6_1162300_2326000 METAL6_1162300_2328000 0.004
R_VDD5_15928 METAL6_1162300_2328000 METAL6_1162300_2329000 0.002
R_VDD5_15929 METAL6_1162300_2329000 METAL6_1162300_2338000 0.018
R_VDD5_15930 METAL6_1162300_2338000 METAL6_1162300_2340000 0.004
R_VDD5_15931 METAL6_1162300_2340000 METAL6_1162300_2341000 0.002
R_VDD5_15932 METAL6_1162300_2341000 METAL6_1162300_2350000 0.018
R_VDD5_15933 METAL6_1162300_2350000 METAL6_1162300_2352000 0.004
R_VDD5_15934 METAL6_1162300_2352000 METAL6_1162300_2353000 0.002
R_VDD5_15935 METAL6_1162300_2353000 METAL6_1162300_2362000 0.018
R_VDD5_15936 METAL6_1162300_2362000 METAL6_1162300_2364000 0.004
R_VDD5_15937 METAL6_1162300_2364000 METAL6_1162300_2365000 0.002
R_VDD5_15938 METAL6_1162300_2365000 METAL6_1162300_2374000 0.018
R_VDD5_15939 METAL6_1162300_2374000 METAL6_1162300_2376000 0.004
R_VDD5_15940 METAL6_1162300_2376000 METAL6_1162300_2377000 0.002
R_VDD5_15941 METAL6_1162300_2377000 METAL6_1162300_2388000 0.022
R_VDD5_15942 METAL6_1162300_2388000 METAL6_1162300_2389000 0.002
R_VDD5_15943 METAL6_1162300_2389000 METAL6_1162300_2395000 0.012
R_VDD5_15944 METAL6_1162300_2395000 METAL6_1162300_2400000 0.01
R_VDD5_15945 METAL6_1162300_2400000 METAL6_1162300_2401000 0.002
R_VDD5_15946 METAL6_1162300_2401000 METAL6_1162300_2407000 0.012
R_VDD5_15947 METAL6_1162300_2407000 METAL6_1162300_2412000 0.01
R_VDD5_15948 METAL6_1162300_2412000 METAL6_1162300_2413000 0.002
R_VDD5_15949 METAL6_1162300_2413000 METAL6_1162300_2419000 0.012
R_VDD5_15950 METAL6_1162300_2419000 METAL6_1162300_2424000 0.01
R_VDD5_15951 METAL6_1162300_2424000 METAL6_1162300_2436000 0.024
R_VDD5_15952 METAL6_1162300_2436000 METAL6_1162300_2438000 0.004
R_VDD5_15953 METAL6_1162300_2438000 METAL6_1162300_2444000 0.012
R_VDD5_15954 METAL6_1162300_2444000 METAL6_1162300_2448000 0.008
R_VDD5_15955 METAL6_1162300_2448000 METAL6_1162300_2450000 0.004
R_VDD5_15956 METAL6_1162300_2450000 METAL6_1162300_2456000 0.012
R_VDD5_15957 METAL6_1162300_2456000 METAL6_1162300_2462000 0.012
R_VDD5_15958 METAL6_1162300_2462000 METAL6_1162300_2468000 0.012
R_VDD5_15959 METAL6_1162300_2468000 METAL6_1162300_2469000 0.002
R_VDD5_15960 METAL6_1162300_2469000 METAL6_1162300_2481000 0.024
R_VDD5_15961 METAL6_1162300_2481000 METAL6_1162300_2493000 0.024
R_VDD5_15962 METAL6_1162300_2493000 METAL6_1162300_2505000 0.024
R_VDD5_15963 METAL6_1162300_2505000 METAL6_1162300_2512000 0.014
R_VDD5_15964 METAL6_1162300_2512000 METAL6_1162300_2517700 0.0114
R_VDD5_15965 METAL6_1162300_2517700 METAL6_1162300_2524000 0.0126
R_VDD5_15966 METAL6_1162300_2524000 METAL6_1162300_2529700 0.0114
R_VDD5_15967 METAL6_1162300_2529700 METAL6_1162300_2536000 0.0126
R_VDD5_15968 METAL6_1162300_2536000 METAL6_1162300_2541700 0.0114
R_VDD5_15969 METAL6_1162300_2541700 METAL6_1162300_2548000 0.0126
R_VDD5_15970 METAL6_1162300_2548000 METAL6_1162300_2553700 0.0114
R_VDD5_15971 METAL6_1162300_2553700 METAL6_1162300_2589000 0.0706
R_VDD5_15972 METAL6_1162300_2589000 METAL6_1162300_2603000 0.028
R_VDD5_15973 METAL6_1162300_2603000 METAL6_1162300_2644000 0.082
R_VDD5_15974 METAL6_1162300_2644000 METAL6_1162300_2656000 0.024
R_VDD5_15975 METAL6_1162300_2656000 METAL6_1162300_2665700 0.0194
R_VDD5_15976 METAL6_1162300_2665700 METAL6_1162300_2668000 0.0046
R_VDD5_15977 METAL6_1162300_2668000 METAL6_1162300_2701000 0.066
R_VDD5_15978 METAL6_1162300_2701000 METAL6_1162300_2701700 0.0014
R_VDD5_15979 METAL6_1162300_2701700 METAL6_1162300_2713000 0.0226
R_VDD5_15980 METAL6_1162300_2713000 METAL6_1162300_2713700 0.0014
R_VDD5_15981 METAL6_1162300_2713700 METAL6_1162300_2724000 0.0206
R_VDD5_15982 METAL6_1162300_2724000 METAL6_1162300_2725000 0.002
R_VDD5_15983 METAL6_1162300_2725000 METAL6_1162300_2725700 0.0014
R_VDD5_15984 METAL6_1162300_2725700 METAL6_1162300_2736000 0.0206
R_VDD5_15985 METAL6_1162300_2736000 METAL6_1162300_2737000 0.002
R_VDD5_15986 METAL6_1162300_2737000 METAL6_1162300_2737700 0.0014
R_VDD5_15987 METAL6_1162300_2737700 METAL5_1162300_2737700 0.1
R_VDD5_15988 METAL5_1162300_2737700 METAL5_1166700_2737700 0.0176
R_VDD5_15989 METAL5_1166700_2737700 METAL5_1173700_2737700 0.028
R_VDD5_15990 METAL5_1173700_2737700 METAL5_1174300_2737700 0.0024
R_VDD5_15991 METAL5_1174300_2737700 METAL5_1180400_2737700 0.0244
R_VDD5_15992 METAL5_1180400_2737700 METAL5_1186300_2737700 0.0236
R_VDD5_15993 METAL5_1186300_2737700 METAL6_1186300_2737700 0.1
R_VDD5_15994 METAL6_1186300_2737700 METAL6_1186300_2748000 0.0206
R_VDD5_15995 METAL6_1186300_2748000 METAL6_1186300_2777000 0.058
R_VDD5_15996 METAL6_1186300_2777000 METAL6_1186300_2789000 0.024
R_VDD5_15997 METAL6_1186300_2789000 METAL6_1186300_2801000 0.024
R_VDD5_15998 METAL6_1186300_2801000 METAL6_1186300_2801700 0.0014
R_VDD5_15999 METAL6_1186300_2801700 METAL6_1186300_2803000 0.0026
R_VDD5_16000 METAL6_1186300_2803000 METAL6_1186300_2808000 0.01
R_VDD5_16001 METAL6_1186300_2808000 METAL6_1186300_2813700 0.0114
R_VDD5_16002 METAL6_1186300_2813700 METAL6_1186300_2825700 0.024
R_VDD5_16003 METAL6_1186300_2825700 METAL6_1186300_2901700 0.152
R_VDD5_16004 METAL6_1186300_2901700 METAL6_1186300_2913000 0.0226
R_VDD5_16005 METAL6_1186300_2913000 METAL6_1186300_2913700 0.0014
R_VDD5_16006 METAL6_1186300_2913700 METAL6_1186300_2925000 0.0226
R_VDD5_16007 METAL6_1186300_2925000 METAL6_1186300_2925700 0.0014
R_VDD5_16008 METAL6_1186300_2925700 METAL6_1186300_2937000 0.0226
R_VDD5_16009 METAL6_1186300_2937000 METAL6_1186300_3001700 0.1294
R_VDD5_16010 METAL6_1186300_3001700 METAL6_1186300_3013700 0.024
R_VDD5_16011 METAL6_1186300_3013700 METAL6_1186300_3025700 0.024
R_VDD5_16012 METAL6_1186300_3025700 METAL6_1186300_3063000 0.0746
R_VDD5_16013 METAL6_1186300_3063000 METAL6_1186300_3073700 0.0214
R_VDD5_16014 METAL6_1186300_3073700 METAL6_1186300_3075000 0.0026
R_VDD5_16015 METAL6_1186300_3075000 METAL6_1186300_3085700 0.0214
R_VDD5_16016 METAL6_1186300_3085700 METAL6_1186300_3087000 0.0026
R_VDD5_16017 METAL6_1186300_3087000 METAL6_1186300_3089700 0.0054
R_VDD5_16018 METAL6_1186300_3089700 METAL6_1186300_3097700 0.016
R_VDD5_16019 METAL6_1186300_3097700 METAL6_1188000_3097700 0.0034
R_VDD5_16020 METAL6_1188000_3097700 METAL6_1192400_3097700 0.0088
R_VDD5_16021 METAL6_1192400_3097700 METAL6_1194700_3097700 0.0046
R_VDD5_16022 METAL6_1194700_3097700 METAL6_1198300_3097700 0.0072
R_VDD5_16023 METAL6_1198300_3097700 METAL6_1199800_3097700 0.003
R_VDD5_16024 METAL6_1199800_3097700 METAL6_1199800_3099000 0.0026
R_VDD5_16025 METAL6_1199800_3099000 METAL6_1199800_3101700 0.0054
R_VDD5_16026 METAL6_1199800_3101700 METAL6_1199800_3109700 0.016
R_VDD5_16027 METAL6_1199800_3109700 METAL6_1199800_3113700 0.008
R_VDD5_16028 METAL6_1199800_3113700 METAL6_1199800_3125700 0.024
R_VDD5_16029 METAL6_1199800_3125700 METAL6_1199800_3179700 0.108
R_VDD5_16030 METAL6_1199800_3179700 METAL6_1199800_3255700 0.152
R_VDD5_16031 METAL6_1199800_3255700 METAL6_1199800_3263000 0.0146
R_VDD5_16032 METAL6_1199800_3263000 METAL6_1199800_3275000 0.024
R_VDD5_16033 METAL6_1199800_3275000 METAL6_1199800_3281000 0.012
R_VDD5_16034 METAL6_1199800_3281000 METAL6_1199800_3287000 0.012
R_VDD5_16035 METAL6_1199800_3287000 METAL6_1199800_3293000 0.012
R_VDD5_16036 METAL6_1199800_3293000 METAL6_1200000_3293000 0.0004
R_VDD5_16037 METAL6_1200000_3293000 METAL6_1204400_3293000 0.0088
R_VDD5_16038 METAL6_1204400_3293000 METAL6_1206700_3293000 0.0046
R_VDD5_16039 METAL6_1206700_3293000 METAL6_1210300_3293000 0.0072
R_VDD5_16040 METAL6_1210300_3293000 METAL6_1211800_3293000 0.003
R_VDD5_16041 METAL6_1211800_3293000 METAL6_1212000_3293000 0.0004
R_VDD5_16042 METAL6_1212000_3293000 METAL6_1216400_3293000 0.0088
R_VDD5_16043 METAL6_1216400_3293000 METAL6_1218700_3293000 0.0046
R_VDD5_16044 METAL6_1218700_3293000 METAL6_1222300_3293000 0.0072
R_VDD5_16045 METAL6_1222300_3293000 METAL6_1223800_3293000 0.003
R_VDD5_16046 METAL6_1223800_3293000 METAL6_1224000_3293000 0.0004
R_VDD5_16047 METAL6_1224000_3293000 METAL6_1230700_3293000 0.0134
R_VDD5_16048 METAL6_1230700_3293000 METAL6_1234300_3293000 0.0072
R_VDD5_16049 METAL6_1234300_3293000 METAL6_1235800_3293000 0.003
R_VDD5_16050 METAL6_1235800_3293000 METAL6_1236000_3293000 0.0004
R_VDD5_16051 METAL6_1236000_3293000 METAL6_1242700_3293000 0.0134
R_VDD5_16052 METAL6_1242700_3293000 METAL6_1246300_3293000 0.0072
R_VDD5_16053 METAL6_1246300_3293000 METAL6_1247800_3293000 0.003
R_VDD5_16054 METAL6_1247800_3293000 METAL6_1253300_3293000 0.011
R_VDD5_16055 METAL6_1253300_3293000 METAL6_1254700_3293000 0.0028
R_VDD5_16056 METAL6_1254700_3293000 METAL6_1258300_3293000 0.0072
R_VDD5_16057 METAL6_1258300_3293000 METAL6_1259800_3293000 0.003
R_VDD5_16058 METAL6_1259800_3293000 METAL6_1262700_3293000 0.0058
R_VDD5_16059 METAL6_1262700_3293000 METAL6_1266800_3293000 0.0082
R_VDD5_16060 METAL6_1266800_3293000 METAL6_1270300_3293000 0.007
R_VDD5_16061 METAL6_1270300_3293000 METAL6_1274700_3293000 0.0088
R_VDD5_16062 METAL6_1274700_3293000 METAL6_1276000_3293000 0.0026
R_VDD5_16063 METAL6_1276000_3293000 METAL6_1286700_3293000 0.0214
R_VDD5_16064 METAL6_1286700_3293000 METAL6_1287800_3293000 0.0022
R_VDD5_16065 METAL6_1287800_3293000 METAL6_1288000_3293000 0.0004
R_VDD5_16066 METAL6_1288000_3293000 METAL6_1289000_3293000 0.002
R_VDD5_16067 METAL6_1289000_3293000 METAL6_1299800_3293000 0.0216
R_VDD5_16068 METAL6_1299800_3293000 METAL6_1300000_3293000 0.0004
R_VDD5_16069 METAL6_1300000_3293000 METAL6_1301000_3293000 0.002
R_VDD5_16070 METAL6_1301000_3293000 METAL6_1311800_3293000 0.0216
R_VDD5_16071 METAL6_1311800_3293000 METAL6_1312000_3293000 0.0004
R_VDD5_16072 METAL6_1312000_3293000 METAL6_1313000_3293000 0.002
R_VDD5_16073 METAL6_1313000_3293000 METAL6_1323800_3293000 0.0216
R_VDD5_16074 METAL6_1323800_3293000 METAL6_1324000_3293000 0.0004
R_VDD5_16075 METAL6_1324000_3293000 METAL6_1325000_3293000 0.002
R_VDD5_16076 METAL6_195000_2175000 METAL6_207000_2175000 0.024
R_VDD5_16077 METAL6_1600000_9500 METAL6_1591800_9500 0.0164
R_VDD5_16078 METAL6_1591800_9500 METAL6_1588700_9500 0.0062
R_VDD5_16079 METAL6_1588700_9500 METAL6_1588000_9500 0.0014
R_VDD5_16080 METAL6_1588000_9500 METAL6_1579800_9500 0.0164
R_VDD5_16081 METAL6_1579800_9500 METAL6_1579800_16600 0.0142
R_VDD5_16082 METAL6_1579800_16600 METAL6_1579800_21500 0.0098
R_VDD5_16083 METAL6_1579800_21500 METAL6_1579800_28600 0.0142
R_VDD5_16084 METAL6_1579800_28600 METAL6_1579800_33500 0.0098
R_VDD5_16085 METAL6_1579800_33500 METAL6_1579800_40600 0.0142
R_VDD5_16086 METAL6_1579800_40600 METAL6_1579800_52600 0.024
R_VDD5_16087 METAL6_1579800_52600 METAL6_1579800_64000 0.0228
R_VDD5_16088 METAL6_1579800_64000 METAL6_1576700_64000 0.0062
R_VDD5_16089 METAL6_1576700_64000 METAL6_1576000_64000 0.0014
R_VDD5_16090 METAL6_1576000_64000 METAL6_1574700_64000 0.0026
R_VDD5_16091 METAL6_1574700_64000 METAL6_1569000_64000 0.0114
R_VDD5_16092 METAL6_1569000_64000 METAL6_1564000_64000 0.01
R_VDD5_16093 METAL6_1564000_64000 METAL6_1557000_64000 0.014
R_VDD5_16094 METAL6_1557000_64000 METAL6_1555400_64000 0.0032
R_VDD5_16095 METAL6_1555400_64000 METAL6_1552000_64000 0.0068
R_VDD5_16096 METAL6_1552000_64000 METAL6_1552000_64600 0.0012
R_VDD5_16097 METAL6_1552000_64600 METAL6_1552000_71600 0.014
R_VDD5_16098 METAL6_1552000_71600 METAL6_1552000_76000 0.0088
R_VDD5_16099 METAL6_1552000_76000 METAL6_1552000_76600 0.0012
R_VDD5_16100 METAL6_1552000_76600 METAL6_1552000_83600 0.014
R_VDD5_16101 METAL6_1552000_83600 METAL6_1552000_88000 0.0088
R_VDD5_16102 METAL6_1552000_88000 METAL6_1552000_88600 0.0012
R_VDD5_16103 METAL6_1552000_88600 METAL6_1552000_95600 0.014
R_VDD5_16104 METAL6_1552000_95600 METAL6_1552000_100000 0.0088
R_VDD5_16105 METAL6_1552000_100000 METAL6_1552000_112000 0.024
R_VDD5_16106 METAL6_1552000_112000 METAL6_1552000_159600 0.0952
R_VDD5_16107 METAL6_1552000_159600 METAL6_1552000_166600 0.014
R_VDD5_16108 METAL6_1552000_166600 METAL6_1552000_176000 0.0188
R_VDD5_16109 METAL6_1552000_176000 METAL6_1552000_178600 0.0052
R_VDD5_16110 METAL6_1552000_178600 METAL6_1552000_188000 0.0188
R_VDD5_16111 METAL6_1552000_188000 METAL6_1552000_190600 0.0052
R_VDD5_16112 METAL6_1552000_190600 METAL6_1552000_200000 0.0188
R_VDD5_16113 METAL6_1552000_200000 METAL6_1552000_212000 0.024
R_VDD5_16114 METAL6_1552000_212000 METAL6_1552000_236300 0.0486
R_VDD5_16115 METAL6_1552000_236300 METAL6_1552000_248300 0.024
R_VDD5_16116 METAL6_1552000_248300 METAL6_1552000_251000 0.0054
R_VDD5_16117 METAL6_1552000_251000 METAL6_1552000_260300 0.0186
R_VDD5_16118 METAL6_1552000_260300 METAL6_1552000_263000 0.0054
R_VDD5_16119 METAL6_1552000_263000 METAL6_1552000_272300 0.0186
R_VDD5_16120 METAL6_1552000_272300 METAL6_1552000_275000 0.0054
R_VDD5_16121 METAL6_1552000_275000 METAL5_1552000_275000 0.1
R_VDD5_16122 METAL5_1552000_275000 METAL5_1552000_279300 0.0172
R_VDD5_16123 METAL5_1552000_279300 METAL5_1552000_287000 0.0308
R_VDD5_16124 METAL5_1552000_287000 METAL5_1552000_288000 0.004
R_VDD5_16125 METAL5_1552000_288000 METAL5_1552000_299000 0.044
R_VDD5_16126 METAL5_1552000_299000 METAL6_1552000_299000 0.1
R_VDD5_16127 METAL6_1552000_299000 METAL6_1552000_300000 0.002
R_VDD5_16128 METAL6_1552000_300000 METAL6_1552000_312000 0.024
R_VDD5_16129 METAL6_1552000_312000 METAL6_1552000_355300 0.0866
R_VDD5_16130 METAL6_1552000_355300 METAL6_1552000_362300 0.014
R_VDD5_16131 METAL6_1552000_362300 METAL6_1552000_366800 0.009
R_VDD5_16132 METAL6_1552000_366800 METAL6_1552000_374300 0.015
R_VDD5_16133 METAL6_1552000_374300 METAL6_1552000_378800 0.009
R_VDD5_16134 METAL6_1552000_378800 METAL6_1552000_386300 0.015
R_VDD5_16135 METAL6_1552000_386300 METAL6_1552000_388000 0.0034
R_VDD5_16136 METAL6_1552000_388000 METAL6_1552000_390800 0.0056
R_VDD5_16137 METAL6_1552000_390800 METAL6_1552000_400000 0.0184
R_VDD5_16138 METAL6_1552000_400000 METAL6_1552000_402800 0.0056
R_VDD5_16139 METAL6_1552000_402800 METAL6_1552000_412000 0.0184
R_VDD5_16140 METAL6_1552000_412000 METAL6_1552000_413000 0.002
R_VDD5_16141 METAL6_1552000_413000 METAL6_1552000_414800 0.0036
R_VDD5_16142 METAL6_1552000_414800 METAL6_1552000_425000 0.0204
R_VDD5_16143 METAL6_1552000_425000 METAL6_1552000_437000 0.024
R_VDD5_16144 METAL6_1552000_437000 METAL6_1551800_437000 0.0004
R_VDD5_16145 METAL6_1551800_437000 METAL6_1545000_437000 0.0136
R_VDD5_16146 METAL6_1545000_437000 METAL6_1540000_437000 0.01
R_VDD5_16147 METAL6_1540000_437000 METAL6_1539800_437000 0.0004
R_VDD5_16148 METAL6_1539800_437000 METAL6_1527800_437000 0.024
R_VDD5_16149 METAL6_1527800_437000 METAL6_1512000_437000 0.0316
R_VDD5_16150 METAL6_1512000_437000 METAL6_1510400_437000 0.0032
R_VDD5_16151 METAL6_1510400_437000 METAL6_1503400_437000 0.014
R_VDD5_16152 METAL6_1503400_437000 METAL6_1500000_437000 0.0068
R_VDD5_16153 METAL6_1500000_437000 METAL6_1498300_437000 0.0034
R_VDD5_16154 METAL6_1498300_437000 METAL6_1491400_437000 0.0138
R_VDD5_16155 METAL6_1491400_437000 METAL6_1488000_437000 0.0068
R_VDD5_16156 METAL6_1488000_437000 METAL6_1479400_437000 0.0172
R_VDD5_16157 METAL6_1479400_437000 METAL6_1444800_437000 0.0692
R_VDD5_16158 METAL6_1444800_437000 METAL6_1443700_437000 0.0022
R_VDD5_16159 METAL6_1443700_437000 METAL6_1432800_437000 0.0218
R_VDD5_16160 METAL6_1432800_437000 METAL6_1431700_437000 0.0022
R_VDD5_16161 METAL6_1431700_437000 METAL6_1424000_437000 0.0154
R_VDD5_16162 METAL6_1424000_437000 METAL6_1420800_437000 0.0064
R_VDD5_16163 METAL6_1420800_437000 METAL6_1419700_437000 0.0022
R_VDD5_16164 METAL6_1419700_437000 METAL6_1412000_437000 0.0154
R_VDD5_16165 METAL6_1412000_437000 METAL6_1408800_437000 0.0064
R_VDD5_16166 METAL6_1408800_437000 METAL5_1408800_437000 0.1
R_VDD5_16167 METAL5_1408800_437000 METAL5_1408800_449000 0.048
R_VDD5_16168 METAL5_1408800_449000 METAL5_1408800_453000 0.016
R_VDD5_16169 METAL5_1408800_453000 METAL5_1408800_456400 0.0136
R_VDD5_16170 METAL5_1408800_456400 METAL5_1408800_459000 0.0104
R_VDD5_16171 METAL5_1408800_459000 METAL5_1408800_461000 0.008
R_VDD5_16172 METAL5_1408800_461000 METAL6_1408800_461000 0.1
R_VDD5_16173 METAL6_1408800_461000 METAL6_1400000_461000 0.0176
R_VDD5_16174 METAL6_1400000_461000 METAL6_1388000_461000 0.024
R_VDD5_16175 METAL6_1388000_461000 METAL6_1348000_461000 0.08
R_VDD5_16176 METAL6_1348000_461000 METAL6_1337000_461000 0.022
R_VDD5_16177 METAL6_1337000_461000 METAL6_1337000_465000 0.008
R_VDD5_16178 METAL6_1337000_465000 METAL6_1337000_468400 0.0068
R_VDD5_16179 METAL6_1337000_468400 METAL6_1337000_471000 0.0052
R_VDD5_16180 METAL6_1337000_471000 METAL6_1337000_473000 0.004
R_VDD5_16181 METAL6_1337000_473000 METAL6_1337000_477000 0.008
R_VDD5_16182 METAL6_1337000_477000 METAL6_1337000_480400 0.0068
R_VDD5_16183 METAL6_1337000_480400 METAL6_1337000_483000 0.0052
R_VDD5_16184 METAL6_1337000_483000 METAL6_1336000_483000 0.002
R_VDD5_16185 METAL6_1336000_483000 METAL6_1325000_483000 0.022
R_VDD5_16186 METAL6_1325000_483000 METAL6_1324000_483000 0.002
R_VDD5_16187 METAL6_1324000_483000 METAL6_1323800_483000 0.0004
R_VDD5_16188 METAL6_1323800_483000 METAL6_1313000_483000 0.0216
R_VDD5_16189 METAL6_1313000_483000 METAL6_1312000_483000 0.002
R_VDD5_16190 METAL6_1312000_483000 METAL6_1311800_483000 0.0004
R_VDD5_16191 METAL6_1311800_483000 METAL6_1301000_483000 0.0216
R_VDD5_16192 METAL6_1301000_483000 METAL6_1300000_483000 0.002
R_VDD5_16193 METAL6_1300000_483000 METAL6_1300000_488000 0.01
R_VDD5_16194 METAL6_1300000_488000 METAL6_1300000_492400 0.0088
R_VDD5_16195 METAL6_1300000_492400 METAL6_1300000_495000 0.0052
R_VDD5_16196 METAL6_1300000_495000 METAL6_1300000_500000 0.01
R_VDD5_16197 METAL6_1300000_500000 METAL6_1300000_504000 0.008
R_VDD5_16198 METAL6_1300000_504000 METAL6_1300000_507000 0.006
R_VDD5_16199 METAL6_1300000_507000 METAL6_1300000_507800 0.0016
R_VDD5_16200 METAL6_1300000_507800 METAL6_1300000_512000 0.0084
R_VDD5_16201 METAL6_1300000_512000 METAL6_1300000_516000 0.008
R_VDD5_16202 METAL6_1300000_516000 METAL6_1300000_519000 0.006
R_VDD5_16203 METAL6_1300000_519000 METAL6_1300000_520200 0.0024
R_VDD5_16204 METAL6_1300000_520200 METAL6_1300000_528000 0.0156
R_VDD5_16205 METAL6_1300000_528000 METAL6_1300000_532200 0.0084
R_VDD5_16206 METAL6_1300000_532200 METAL6_1300000_535400 0.0064
R_VDD5_16207 METAL6_1300000_535400 METAL6_1300000_544200 0.0176
R_VDD5_16208 METAL6_1300000_544200 METAL6_1300000_547400 0.0064
R_VDD5_16209 METAL6_1300000_547400 METAL6_1300000_550400 0.006
R_VDD5_16210 METAL6_1300000_550400 METAL6_1300000_556200 0.0116
R_VDD5_16211 METAL6_1300000_556200 METAL6_1300000_559400 0.0064
R_VDD5_16212 METAL6_1300000_559400 METAL6_1300000_561000 0.0032
R_VDD5_16213 METAL6_1300000_561000 METAL6_1300000_562400 0.0028
R_VDD5_16214 METAL6_1300000_562400 METAL6_1299800_562400 0.0004
R_VDD5_16215 METAL6_1299800_562400 METAL6_1289000_562400 0.0216
R_VDD5_16216 METAL6_1289000_562400 METAL6_1288000_562400 0.002
R_VDD5_16217 METAL6_1288000_562400 METAL6_1287800_562400 0.0004
R_VDD5_16218 METAL6_1287800_562400 METAL6_1286700_562400 0.0022
R_VDD5_16219 METAL6_1286700_562400 METAL6_1282300_562400 0.0088
R_VDD5_16220 METAL6_1282300_562400 METAL6_1276000_562400 0.0126
R_VDD5_16221 METAL6_1276000_562400 METAL6_1274700_562400 0.0026
R_VDD5_16222 METAL6_1274700_562400 METAL6_1270300_562400 0.0088
R_VDD5_16223 METAL6_1270300_562400 METAL6_1266800_562400 0.007
R_VDD5_16224 METAL6_1266800_562400 METAL6_1262700_562400 0.0082
R_VDD5_16225 METAL6_1262700_562400 METAL6_1259800_562400 0.0058
R_VDD5_16226 METAL6_1259800_562400 METAL6_1258300_562400 0.003
R_VDD5_16227 METAL6_1258300_562400 METAL6_1254700_562400 0.0072
R_VDD5_16228 METAL6_1254700_562400 METAL6_1253300_562400 0.0028
R_VDD5_16229 METAL6_1253300_562400 METAL6_1248000_562400 0.0106
R_VDD5_16230 METAL6_1248000_562400 METAL6_1247800_562400 0.0004
R_VDD5_16231 METAL6_1247800_562400 METAL6_1246300_562400 0.003
R_VDD5_16232 METAL6_1246300_562400 METAL6_1242700_562400 0.0072
R_VDD5_16233 METAL6_1242700_562400 METAL6_1236000_562400 0.0134
R_VDD5_16234 METAL6_1236000_562400 METAL6_1235800_562400 0.0004
R_VDD5_16235 METAL6_1235800_562400 METAL6_1234300_562400 0.003
R_VDD5_16236 METAL6_1234300_562400 METAL6_1230700_562400 0.0072
R_VDD5_16237 METAL6_1230700_562400 METAL6_1224000_562400 0.0134
R_VDD5_16238 METAL6_1224000_562400 METAL6_1223800_562400 0.0004
R_VDD5_16239 METAL6_1223800_562400 METAL6_1223800_573000 0.0212
R_VDD5_16240 METAL6_1223800_573000 METAL6_1222300_573000 0.003
R_VDD5_16241 METAL6_1222300_573000 METAL6_1218700_573000 0.0072
R_VDD5_16242 METAL6_1218700_573000 METAL6_1216400_573000 0.0046
R_VDD5_16243 METAL6_1216400_573000 METAL6_1212000_573000 0.0088
R_VDD5_16244 METAL6_1212000_573000 METAL6_1212000_574400 0.0028
R_VDD5_16245 METAL6_1212000_574400 METAL6_1212000_579800 0.0108
R_VDD5_16246 METAL6_1212000_579800 METAL6_1212000_585000 0.0104
R_VDD5_16247 METAL6_1212000_585000 METAL6_1212000_586400 0.0028
R_VDD5_16248 METAL6_1212000_586400 METAL6_1212000_588000 0.0032
R_VDD5_16249 METAL6_1212000_588000 METAL6_1212000_597000 0.018
R_VDD5_16250 METAL6_1212000_597000 METAL6_1212000_598400 0.0028
R_VDD5_16251 METAL6_1212000_598400 METAL6_1212000_600000 0.0032
R_VDD5_16252 METAL6_1212000_600000 METAL6_1212000_612000 0.024
R_VDD5_16253 METAL6_1212000_612000 METAL6_1212000_617400 0.0108
R_VDD5_16254 METAL6_1212000_617400 METAL6_1211800_617400 0.0004
R_VDD5_16255 METAL6_1211800_617400 METAL6_1211800_629400 0.024
R_VDD5_16256 METAL6_1211800_629400 METAL6_1211800_637800 0.0168
R_VDD5_16257 METAL6_1211800_637800 METAL6_1211800_641400 0.0072
R_VDD5_16258 METAL6_1211800_641400 METAL6_1211800_649800 0.0168
R_VDD5_16259 METAL6_1211800_649800 METAL6_1211800_653400 0.0072
R_VDD5_16260 METAL6_1211800_653400 METAL6_1211800_661800 0.0168
R_VDD5_16261 METAL6_1211800_661800 METAL6_1211800_665400 0.0072
R_VDD5_16262 METAL6_1211800_665400 METAL6_1211800_688000 0.0452
R_VDD5_16263 METAL6_1211800_688000 METAL6_1211800_697800 0.0196
R_VDD5_16264 METAL6_1211800_697800 METAL6_1211800_700000 0.0044
R_VDD5_16265 METAL6_1211800_700000 METAL6_1211800_702800 0.0056
R_VDD5_16266 METAL6_1211800_702800 METAL6_1211800_709800 0.014
R_VDD5_16267 METAL6_1211800_709800 METAL6_1211800_712000 0.0044
R_VDD5_16268 METAL6_1211800_712000 METAL6_1211800_716800 0.0096
R_VDD5_16269 METAL6_1211800_716800 METAL6_1211800_721800 0.01
R_VDD5_16270 METAL6_1211800_721800 METAL6_1210300_721800 0.003
R_VDD5_16271 METAL6_1210300_721800 METAL6_1206700_721800 0.0072
R_VDD5_16272 METAL6_1206700_721800 METAL6_1204400_721800 0.0046
R_VDD5_16273 METAL6_1204400_721800 METAL6_1200000_721800 0.0088
R_VDD5_16274 METAL6_1200000_721800 METAL6_1200000_733800 0.024
R_VDD5_16275 METAL6_1200000_733800 METAL6_1200000_734400 0.0012
R_VDD5_16276 METAL6_1200000_734400 METAL6_1200000_735400 0.002
R_VDD5_16277 METAL6_1200000_735400 METAL6_1200000_742400 0.014
R_VDD5_16278 METAL6_1200000_742400 METAL6_1200000_745800 0.0068
R_VDD5_16279 METAL6_1200000_745800 METAL6_1200000_746400 0.0012
R_VDD5_16280 METAL6_1200000_746400 METAL6_1200000_754400 0.016
R_VDD5_16281 METAL6_1200000_754400 METAL6_1200000_757800 0.0068
R_VDD5_16282 METAL6_1200000_757800 METAL6_1200000_758400 0.0012
R_VDD5_16283 METAL6_1200000_758400 METAL6_1200000_760000 0.0032
R_VDD5_16284 METAL6_1200000_760000 METAL6_1200000_763000 0.006
R_VDD5_16285 METAL6_1200000_763000 METAL6_1200000_766400 0.0068
R_VDD5_16286 METAL6_1200000_766400 METAL6_1200000_769800 0.0068
R_VDD5_16287 METAL6_1200000_769800 METAL6_1200000_770400 0.0012
R_VDD5_16288 METAL6_1200000_770400 METAL6_1200000_772000 0.0032
R_VDD5_16289 METAL6_1200000_772000 METAL6_1200000_778400 0.0128
R_VDD5_16290 METAL6_1200000_778400 METAL6_1200000_779200 0.0016
R_VDD5_16291 METAL6_1200000_779200 METAL6_1200000_782400 0.0064
R_VDD5_16292 METAL6_1200000_782400 METAL6_1200000_784000 0.0032
R_VDD5_16293 METAL6_1200000_784000 METAL6_1200000_784500 0.001
R_VDD5_16294 METAL6_1200000_784500 METAL6_1200000_788000 0.007
R_VDD5_16295 METAL6_1200000_788000 METAL6_1200000_790400 0.0048
R_VDD5_16296 METAL6_1200000_790400 METAL6_1200000_791200 0.0016
R_VDD5_16297 METAL6_1200000_791200 METAL6_1200000_794400 0.0064
R_VDD5_16298 METAL6_1200000_794400 METAL6_1200000_794800 0.0008
R_VDD5_16299 METAL6_1200000_794800 METAL6_1200000_800000 0.0104
R_VDD5_16300 METAL6_1200000_800000 METAL6_1200000_802400 0.0048
R_VDD5_16301 METAL6_1200000_802400 METAL6_1200000_803200 0.0016
R_VDD5_16302 METAL6_1200000_803200 METAL6_1200000_806400 0.0064
R_VDD5_16303 METAL6_1200000_806400 METAL6_1200000_808000 0.0032
R_VDD5_16304 METAL6_1200000_808000 METAL6_1200000_812000 0.008
R_VDD5_16305 METAL6_1200000_812000 METAL6_1200000_814400 0.0048
R_VDD5_16306 METAL6_1200000_814400 METAL6_1200000_818400 0.008
R_VDD5_16307 METAL6_1200000_818400 METAL6_1200000_820000 0.0032
R_VDD5_16308 METAL6_1200000_820000 METAL6_1200000_828700 0.0174
R_VDD5_16309 METAL6_1200000_828700 METAL6_1200000_830400 0.0034
R_VDD5_16310 METAL6_1200000_830400 METAL6_1200000_832000 0.0032
R_VDD5_16311 METAL6_1200000_832000 METAL6_1200000_839500 0.015
R_VDD5_16312 METAL6_1200000_839500 METAL6_1200000_840700 0.0024
R_VDD5_16313 METAL6_1200000_840700 METAL6_1200000_842400 0.0034
R_VDD5_16314 METAL6_1200000_842400 METAL6_1200000_851500 0.0182
R_VDD5_16315 METAL6_1200000_851500 METAL6_1200000_852700 0.0024
R_VDD5_16316 METAL6_1200000_852700 METAL6_1200000_854400 0.0034
R_VDD5_16317 METAL6_1200000_854400 METAL6_1200000_858200 0.0076
R_VDD5_16318 METAL6_1200000_858200 METAL6_1200000_863500 0.0106
R_VDD5_16319 METAL6_1200000_863500 METAL6_1200000_875000 0.023
R_VDD5_16320 METAL6_1200000_875000 METAL6_1200000_887000 0.024
R_VDD5_16321 METAL6_1200000_887000 METAL6_1200000_888000 0.002
R_VDD5_16322 METAL6_1200000_888000 METAL6_1200000_899000 0.022
R_VDD5_16323 METAL6_1200000_899000 METAL6_1200000_900000 0.002
R_VDD5_16324 METAL6_1200000_900000 METAL6_1200000_900400 0.0008
R_VDD5_16325 METAL6_1200000_900400 METAL6_1200000_912000 0.0232
R_VDD5_16326 METAL6_1200000_912000 METAL6_1200000_923000 0.022
R_VDD5_16327 METAL6_1200000_923000 METAL6_1199800_923000 0.0004
R_VDD5_16328 METAL6_1199800_923000 METAL6_1198300_923000 0.003
R_VDD5_16329 METAL6_1198300_923000 METAL6_1194700_923000 0.0072
R_VDD5_16330 METAL6_1194700_923000 METAL6_1192400_923000 0.0046
R_VDD5_16331 METAL6_1192400_923000 METAL6_1188000_923000 0.0088
R_VDD5_16332 METAL6_1188000_923000 METAL6_1187800_923000 0.0004
R_VDD5_16333 METAL6_1187800_923000 METAL6_1186300_923000 0.003
R_VDD5_16334 METAL6_1186300_923000 METAL6_1180400_923000 0.0118
R_VDD5_16335 METAL6_1180400_923000 METAL6_1174300_923000 0.0122
R_VDD5_16336 METAL6_1174300_923000 METAL6_1173700_923000 0.0012
R_VDD5_16337 METAL6_1173700_923000 METAL6_1166700_923000 0.014
R_VDD5_16338 METAL6_1166700_923000 METAL6_1162300_923000 0.0088
R_VDD5_16339 METAL6_1162300_923000 METAL6_1154700_923000 0.0152
R_VDD5_16340 METAL6_1154700_923000 METAL6_1150300_923000 0.0088
R_VDD5_16341 METAL6_1150300_923000 METAL6_1142700_923000 0.0152
R_VDD5_16342 METAL6_1142700_923000 METAL6_1137000_923000 0.0114
R_VDD5_16343 METAL6_1137000_923000 METAL6_1130700_923000 0.0126
R_VDD5_16344 METAL6_1130700_923000 METAL6_1125000_923000 0.0114
R_VDD5_16345 METAL6_1125000_923000 METAL6_1118700_923000 0.0126
R_VDD5_16346 METAL6_1118700_923000 METAL6_1113000_923000 0.0114
R_VDD5_16347 METAL6_1113000_923000 METAL6_1019000_923000 0.188
R_VDD5_16348 METAL6_1019000_923000 METAL6_1007000_923000 0.024
R_VDD5_16349 METAL6_1007000_923000 METAL6_995000_923000 0.024
R_VDD5_16350 METAL6_995000_923000 METAL6_988000_923000 0.014
R_VDD5_16351 METAL6_988000_923000 METAL6_964400_923000 0.0472
R_VDD5_16352 METAL6_964400_923000 METAL6_952400_923000 0.024
R_VDD5_16353 METAL6_952400_923000 METAL6_947400_923000 0.01
R_VDD5_16354 METAL6_947400_923000 METAL6_940400_923000 0.014
R_VDD5_16355 METAL6_940400_923000 METAL6_928400_923000 0.024
R_VDD5_16356 METAL6_928400_923000 METAL6_916400_923000 0.024
R_VDD5_16357 METAL6_916400_923000 METAL6_904400_923000 0.024
R_VDD5_16358 METAL6_904400_923000 METAL6_892400_923000 0.024
R_VDD5_16359 METAL6_892400_923000 METAL6_880400_923000 0.024
R_VDD5_16360 METAL6_880400_923000 METAL6_868400_923000 0.024
R_VDD5_16361 METAL6_868400_923000 METAL6_731000_923000 0.2748
R_VDD5_16362 METAL6_731000_923000 METAL6_731000_927300 0.0086
R_VDD5_16363 METAL6_731000_927300 METAL6_731000_935000 0.0154
R_VDD5_16364 METAL6_731000_935000 METAL6_731000_947000 0.024
R_VDD5_16365 METAL6_731000_947000 METAL6_731000_959000 0.024
R_VDD5_16366 METAL6_731000_959000 METAL6_731000_971000 0.024
R_VDD5_16367 METAL6_731000_971000 METAL6_731000_976000 0.01
R_VDD5_16368 METAL6_731000_976000 METAL6_731000_983000 0.014
R_VDD5_16369 METAL6_731000_983000 METAL6_731000_988000 0.01
R_VDD5_16370 METAL6_731000_988000 METAL6_731000_995000 0.014
R_VDD5_16371 METAL6_731000_995000 METAL5_731000_995000 0.1
R_VDD5_16372 METAL5_731000_995000 METAL5_731000_1000000 0.02
R_VDD5_16373 METAL5_731000_1000000 METAL5_731000_1007000 0.028
R_VDD5_16374 METAL5_731000_1007000 METAL5_731000_1012000 0.02
R_VDD5_16375 METAL5_731000_1012000 METAL5_731000_1014000 0.008
R_VDD5_16376 METAL5_731000_1014000 METAL5_731000_1019000 0.02
R_VDD5_16377 METAL5_731000_1019000 METAL5_731000_1023700 0.0188
R_VDD5_16378 METAL5_731000_1023700 METAL5_731000_1025400 0.0068
R_VDD5_16379 METAL5_731000_1025400 METAL5_731000_1026000 0.0024
R_VDD5_16380 METAL5_731000_1026000 METAL5_731000_1029800 0.0152
R_VDD5_16381 METAL5_731000_1029800 METAL5_731000_1031000 0.0048
R_VDD5_16382 METAL5_731000_1031000 METAL6_731000_1031000 0.1
R_VDD5_16383 METAL6_731000_1031000 METAL6_731000_1035700 0.0094
R_VDD5_16384 METAL6_731000_1035700 METAL6_731000_1037400 0.0034
R_VDD5_16385 METAL6_731000_1037400 METAL6_731000_1038000 0.0012
R_VDD5_16386 METAL6_731000_1038000 METAL6_731000_1041800 0.0076
R_VDD5_16387 METAL6_731000_1041800 METAL6_731000_1042700 0.0018
R_VDD5_16388 METAL6_731000_1042700 METAL6_731000_1043000 0.0006
R_VDD5_16389 METAL6_731000_1043000 METAL6_731000_1047700 0.0094
R_VDD5_16390 METAL6_731000_1047700 METAL6_731000_1049400 0.0034
R_VDD5_16391 METAL6_731000_1049400 METAL6_731000_1049800 0.0008
R_VDD5_16392 METAL6_731000_1049800 METAL6_731000_1053800 0.008
R_VDD5_16393 METAL6_731000_1053800 METAL6_731000_1054700 0.0018
R_VDD5_16394 METAL6_731000_1054700 METAL6_731000_1061400 0.0134
R_VDD5_16395 METAL6_731000_1061400 METAL6_731000_1061800 0.0008
R_VDD5_16396 METAL6_731000_1061800 METAL6_731000_1066700 0.0098
R_VDD5_16397 METAL6_731000_1066700 METAL6_731000_1073400 0.0134
R_VDD5_16398 METAL6_731000_1073400 METAL6_731000_1073800 0.0008
R_VDD5_16399 METAL6_731000_1073800 METAL6_731000_1074000 0.0004
R_VDD5_16400 METAL6_731000_1074000 METAL6_731000_1074500 0.001
R_VDD5_16401 METAL6_731000_1074500 METAL6_731000_1085400 0.0218
R_VDD5_16402 METAL6_731000_1085400 METAL6_731000_1085800 0.0008
R_VDD5_16403 METAL6_731000_1085800 METAL6_719000_1085800 0.024
R_VDD5_16404 METAL6_719000_1085800 METAL6_719000_1086000 0.0004
R_VDD5_16405 METAL6_719000_1086000 METAL6_719000_1086300 0.0006
R_VDD5_16406 METAL6_719000_1086300 METAL6_719000_1086500 0.0004
R_VDD5_16407 METAL6_719000_1086500 METAL6_719000_1088000 0.003
R_VDD5_16408 METAL6_719000_1088000 METAL6_719000_1096800 0.0176
R_VDD5_16409 METAL6_719000_1096800 METAL6_719000_1098000 0.0024
R_VDD5_16410 METAL6_719000_1098000 METAL6_719000_1098300 0.0006
R_VDD5_16411 METAL6_719000_1098300 METAL6_719000_1098500 0.0004
R_VDD5_16412 METAL6_719000_1098500 METAL6_719000_1100000 0.003
R_VDD5_16413 METAL6_719000_1100000 METAL6_719000_1108800 0.0176
R_VDD5_16414 METAL6_719000_1108800 METAL6_719000_1110000 0.0024
R_VDD5_16415 METAL6_719000_1110000 METAL6_719000_1110300 0.0006
R_VDD5_16416 METAL6_719000_1110300 METAL6_719000_1110500 0.0004
R_VDD5_16417 METAL6_719000_1110500 METAL6_719000_1112000 0.003
R_VDD5_16418 METAL6_719000_1112000 METAL6_719000_1120800 0.0176
R_VDD5_16419 METAL6_719000_1120800 METAL6_719000_1122300 0.003
R_VDD5_16420 METAL6_719000_1122300 METAL6_719000_1122500 0.0004
R_VDD5_16421 METAL6_719000_1122500 METAL6_719000_1129300 0.0136
R_VDD5_16422 METAL6_719000_1129300 METAL6_719000_1132800 0.007
R_VDD5_16423 METAL6_719000_1132800 METAL6_719000_1134300 0.003
R_VDD5_16424 METAL6_719000_1134300 METAL6_719000_1134500 0.0004
R_VDD5_16425 METAL6_719000_1134500 METAL6_719000_1141300 0.0136
R_VDD5_16426 METAL6_719000_1141300 METAL6_719000_1146300 0.01
R_VDD5_16427 METAL6_719000_1146300 METAL6_719000_1153300 0.014
R_VDD5_16428 METAL6_719000_1153300 METAL6_719000_1157700 0.0088
R_VDD5_16429 METAL6_719000_1157700 METAL6_719000_1160600 0.0058
R_VDD5_16430 METAL6_719000_1160600 METAL6_719000_1169700 0.0182
R_VDD5_16431 METAL6_719000_1169700 METAL6_719000_1172600 0.0058
R_VDD5_16432 METAL6_719000_1172600 METAL6_719000_1181700 0.0182
R_VDD5_16433 METAL6_719000_1181700 METAL6_719000_1181800 0.0002
R_VDD5_16434 METAL6_719000_1181800 METAL6_719000_1184600 0.0056
R_VDD5_16435 METAL6_719000_1184600 METAL6_719000_1191600 0.014
R_VDD5_16436 METAL6_719000_1191600 METAL6_719000_1193700 0.0042
R_VDD5_16437 METAL6_719000_1193700 METAL6_719000_1193800 0.0002
R_VDD5_16438 METAL6_719000_1193800 METAL6_719000_1205700 0.0238
R_VDD5_16439 METAL6_719000_1205700 METAL6_719000_1205800 0.0002
R_VDD5_16440 METAL6_719000_1205800 METAL6_719000_1217700 0.0238
R_VDD5_16441 METAL6_719000_1217700 METAL6_712000_1217700 0.014
R_VDD5_16442 METAL6_712000_1217700 METAL5_712000_1217700 0.1
R_VDD5_16443 METAL5_712000_1217700 METAL5_707000_1217700 0.02
R_VDD5_16444 METAL5_707000_1217700 METAL5_700000_1217700 0.028
R_VDD5_16445 METAL5_700000_1217700 METAL5_695000_1217700 0.02
R_VDD5_16446 METAL5_695000_1217700 METAL5_688000_1217700 0.028
R_VDD5_16447 METAL5_688000_1217700 METAL6_688000_1217700 0.1
R_VDD5_16448 METAL6_688000_1217700 METAL6_676000_1217700 0.024
R_VDD5_16449 METAL6_676000_1217700 METAL6_581000_1217700 0.19
R_VDD5_16450 METAL6_581000_1217700 METAL6_569000_1217700 0.024
R_VDD5_16451 METAL6_569000_1217700 METAL6_557000_1217700 0.024
R_VDD5_16452 METAL6_557000_1217700 METAL6_545000_1217700 0.024
R_VDD5_16453 METAL6_545000_1217700 METAL6_545000_1223700 0.012
R_VDD5_16454 METAL6_545000_1223700 METAL6_545000_1229700 0.012
R_VDD5_16455 METAL6_545000_1229700 METAL6_545000_1235700 0.012
R_VDD5_16456 METAL6_545000_1235700 METAL6_545000_1238000 0.0046
R_VDD5_16457 METAL6_545000_1238000 METAL6_545000_1247700 0.0194
R_VDD5_16458 METAL6_545000_1247700 METAL6_545000_1250000 0.0046
R_VDD5_16459 METAL6_545000_1250000 METAL6_545000_1259700 0.0194
R_VDD5_16460 METAL6_545000_1259700 METAL6_543000_1259700 0.004
R_VDD5_16461 METAL6_543000_1259700 METAL6_538000_1259700 0.01
R_VDD5_16462 METAL6_538000_1259700 METAL6_533000_1259700 0.01
R_VDD5_16463 METAL6_533000_1259700 METAL6_521000_1259700 0.024
R_VDD5_16464 METAL6_521000_1259700 METAL6_343000_1259700 0.356
R_VDD5_16465 METAL6_343000_1259700 METAL6_231000_1259700 0.224
R_VDD5_16466 METAL6_231000_1259700 METAL6_231000_1261000 0.0026
R_VDD5_16467 METAL6_231000_1261000 METAL6_231000_1262000 0.002
R_VDD5_16468 METAL6_231000_1262000 METAL6_231000_1271700 0.0194
R_VDD5_16469 METAL6_231000_1271700 METAL6_231000_1273000 0.0026
R_VDD5_16470 METAL6_231000_1273000 METAL6_231000_1283700 0.0214
R_VDD5_16471 METAL6_231000_1283700 METAL6_231000_1285000 0.0026
R_VDD5_16472 METAL6_231000_1285000 METAL6_231000_1295700 0.0214
R_VDD5_16473 METAL6_231000_1295700 METAL6_231000_1297000 0.0026
R_VDD5_16474 METAL6_231000_1297000 METAL6_231000_1302000 0.01
R_VDD5_16475 METAL6_231000_1302000 METAL6_231000_1307700 0.0114
R_VDD5_16476 METAL6_231000_1307700 METAL6_231000_1309000 0.0026
R_VDD5_16477 METAL6_231000_1309000 METAL6_231000_1314000 0.01
R_VDD5_16478 METAL6_231000_1314000 METAL6_231000_1319700 0.0114
R_VDD5_16479 METAL6_231000_1319700 METAL6_231000_1326000 0.0126
R_VDD5_16480 METAL6_231000_1326000 METAL5_231000_1326000 0.1
R_VDD5_16481 METAL5_231000_1326000 METAL5_231000_1338000 0.048
R_VDD5_16482 METAL5_231000_1338000 METAL5_231000_1350000 0.048
R_VDD5_16483 METAL5_231000_1350000 METAL5_231000_1357000 0.028
R_VDD5_16484 METAL5_231000_1357000 METAL5_231000_1362000 0.02
R_VDD5_16485 METAL5_231000_1362000 METAL5_231000_1369000 0.028
R_VDD5_16486 METAL5_231000_1369000 METAL5_231000_1374000 0.02
R_VDD5_16487 METAL5_231000_1374000 METAL5_231000_1381000 0.028
R_VDD5_16488 METAL5_231000_1381000 METAL5_231000_1386600 0.0224
R_VDD5_16489 METAL5_231000_1386600 METAL5_231000_1393000 0.0256
R_VDD5_16490 METAL5_231000_1393000 METAL5_231000_1405000 0.048
R_VDD5_16491 METAL5_231000_1405000 METAL6_231000_1405000 0.1
R_VDD5_16492 METAL6_231000_1405000 METAL6_231000_1437700 0.0654
R_VDD5_16493 METAL6_231000_1437700 METAL6_231000_1449700 0.024
R_VDD5_16494 METAL6_231000_1449700 METAL6_231000_1461700 0.024
R_VDD5_16495 METAL6_231000_1461700 METAL6_231000_1492300 0.0612
R_VDD5_16496 METAL6_231000_1492300 METAL6_231000_1504300 0.024
R_VDD5_16497 METAL6_231000_1504300 METAL6_231000_1516300 0.024
R_VDD5_16498 METAL6_231000_1516300 METAL6_231000_1528300 0.024
R_VDD5_16499 METAL6_231000_1528300 METAL6_231000_1540300 0.024
R_VDD5_16500 METAL6_231000_1540300 METAL6_231000_1552300 0.024
R_VDD5_16501 METAL6_231000_1552300 METAL6_231000_1554500 0.0044
R_VDD5_16502 METAL6_231000_1554500 METAL6_231000_1564300 0.0196
R_VDD5_16503 METAL6_231000_1564300 METAL6_231000_1571300 0.014
R_VDD5_16504 METAL6_231000_1571300 METAL6_231000_1576300 0.01
R_VDD5_16505 METAL6_231000_1576300 METAL6_231000_1714500 0.2764
R_VDD5_16506 METAL6_231000_1714500 METAL6_231000_1720500 0.012
R_VDD5_16507 METAL6_231000_1720500 METAL6_231000_1726500 0.012
R_VDD5_16508 METAL6_231000_1726500 METAL6_231000_1731700 0.0104
R_VDD5_16509 METAL6_231000_1731700 METAL6_231000_1738500 0.0136
R_VDD5_16510 METAL6_231000_1738500 METAL6_231000_1750500 0.024
R_VDD5_16511 METAL6_231000_1750500 METAL6_231000_1762500 0.024
R_VDD5_16512 METAL6_231000_1762500 METAL6_231000_1774500 0.024
R_VDD5_16513 METAL6_231000_1774500 METAL6_231000_1802500 0.056
R_VDD5_16514 METAL6_231000_1802500 METAL6_231000_1814500 0.024
R_VDD5_16515 METAL6_231000_1814500 METAL6_231000_1826500 0.024
R_VDD5_16516 METAL6_231000_1826500 METAL6_231000_1838500 0.024
R_VDD5_16517 METAL6_231000_1838500 METAL6_231000_1852300 0.0276
R_VDD5_16518 METAL6_231000_1852300 METAL6_231000_1866300 0.028
R_VDD5_16519 METAL6_231000_1866300 METAL6_231000_1902500 0.0724
R_VDD5_16520 METAL6_231000_1902500 METAL6_231000_1914500 0.024
R_VDD5_16521 METAL6_231000_1914500 METAL6_231000_1926500 0.024
R_VDD5_16522 METAL6_231000_1926500 METAL6_231000_1938500 0.024
R_VDD5_16523 METAL6_231000_1938500 METAL6_231000_1939000 0.001
R_VDD5_16524 METAL6_231000_1939000 METAL6_231000_1940500 0.003
R_VDD5_16525 METAL6_231000_1940500 METAL6_231000_1950500 0.02
R_VDD5_16526 METAL6_231000_1950500 METAL6_231000_1951000 0.001
R_VDD5_16527 METAL6_231000_1951000 METAL6_231000_1952500 0.003
R_VDD5_16528 METAL6_231000_1952500 METAL6_231000_1962500 0.02
R_VDD5_16529 METAL6_231000_1962500 METAL6_231000_1963000 0.001
R_VDD5_16530 METAL6_231000_1963000 METAL6_231000_1964500 0.003
R_VDD5_16531 METAL6_231000_1964500 METAL6_231000_1974500 0.02
R_VDD5_16532 METAL6_231000_1974500 METAL6_231000_1975000 0.001
R_VDD5_16533 METAL6_231000_1975000 METAL6_231000_1976500 0.003
R_VDD5_16534 METAL6_231000_1976500 METAL6_231000_1987000 0.021
R_VDD5_16535 METAL6_231000_1987000 METAL5_231000_1987000 0.1
R_VDD5_16536 METAL5_231000_1987000 METAL5_219000_1987000 0.048
R_VDD5_16537 METAL5_219000_1987000 METAL5_207000_1987000 0.048
R_VDD5_16538 METAL5_207000_1987000 METAL6_207000_1987000 0.1
R_VDD5_16539 METAL6_207000_1987000 METAL6_207000_1988500 0.003
R_VDD5_16540 METAL6_207000_1988500 METAL6_207000_2014500 0.052
R_VDD5_16541 METAL6_207000_2014500 METAL6_207000_2026500 0.024
R_VDD5_16542 METAL6_207000_2026500 METAL6_207000_2038500 0.024
R_VDD5_16543 METAL6_207000_2038500 METAL6_207000_2114500 0.152
R_VDD5_16544 METAL6_207000_2114500 METAL6_207000_2126500 0.024
R_VDD5_16545 METAL6_207000_2126500 METAL6_207000_2138500 0.024
R_VDD5_16546 METAL6_207000_2138500 METAL6_207000_2147300 0.0176
R_VDD5_16547 METAL6_207000_2147300 METAL6_207000_2150500 0.0064
R_VDD5_16548 METAL6_207000_2150500 METAL6_207000_2154300 0.0076
R_VDD5_16549 METAL6_207000_2154300 METAL6_207000_2163000 0.0174
R_VDD5_16550 METAL6_207000_2163000 METAL6_207000_2166300 0.0066
R_VDD5_16551 METAL6_207000_2166300 METAL6_207000_2175000 0.0174
I_VDD5_54 METAL6_940400_1726500 gnd 0.0016
I_VDD5_55 METAL6_195000_3275000 gnd 0.002
I_VDD5_56 METAL6_545000_2725000 gnd 0.002
I_VDD5_57 METAL6_545000_2175000 gnd 0.002
I_VDD5_58 METAL6_1325000_3305000 gnd 0.004
I_VDD5_59 METAL6_195000_2175000 gnd 0.004

V_VDD6_23 METAL6_1800000_0 gnd 1
R_VDD6_16552 METAL6_1800000_0 METAL6_1800000_9500 0.019
R_VDD6_16553 METAL6_1800000_9500 METAL6_1788000_9500 0.024
R_VDD6_16554 METAL6_1788000_9500 METAL6_1763400_9500 0.0492
R_VDD6_16555 METAL6_1763400_9500 METAL6_1763400_21500 0.024
R_VDD6_16556 METAL6_1763400_21500 METAL6_1755700_21500 0.0154
R_VDD6_16557 METAL6_1755700_21500 METAL6_1755700_28600 0.0142
R_VDD6_16558 METAL6_1755700_28600 METAL6_1755700_40600 0.024
R_VDD6_16559 METAL6_1755700_40600 METAL6_1755700_52600 0.024
R_VDD6_16560 METAL6_1755700_52600 METAL6_1755700_64600 0.024
R_VDD6_16561 METAL6_1755700_64600 METAL6_1755700_71600 0.014
R_VDD6_16562 METAL6_1755700_71600 METAL6_1755700_76000 0.0088
R_VDD6_16563 METAL6_1755700_76000 METAL6_1753800_76000 0.0038
R_VDD6_16564 METAL6_1753800_76000 METAL6_1751800_76000 0.004
R_VDD6_16565 METAL6_1751800_76000 METAL6_1751800_76600 0.0012
R_VDD6_16566 METAL6_1751800_76600 METAL6_1751800_83600 0.014
R_VDD6_16567 METAL6_1751800_83600 METAL6_1751800_88000 0.0088
R_VDD6_16568 METAL6_1751800_88000 METAL6_1751800_88600 0.0012
R_VDD6_16569 METAL6_1751800_88600 METAL6_1751800_95600 0.014
R_VDD6_16570 METAL6_1751800_95600 METAL6_1751800_100000 0.0088
R_VDD6_16571 METAL6_1751800_100000 METAL6_1751800_112000 0.024
R_VDD6_16572 METAL6_1751800_112000 METAL6_1751800_159600 0.0952
R_VDD6_16573 METAL6_1751800_159600 METAL6_1751800_166600 0.014
R_VDD6_16574 METAL6_1751800_166600 METAL6_1751800_176000 0.0188
R_VDD6_16575 METAL6_1751800_176000 METAL6_1751800_178600 0.0052
R_VDD6_16576 METAL6_1751800_178600 METAL6_1751800_188000 0.0188
R_VDD6_16577 METAL6_1751800_188000 METAL6_1751800_190600 0.0052
R_VDD6_16578 METAL6_1751800_190600 METAL6_1751800_200000 0.0188
R_VDD6_16579 METAL6_1751800_200000 METAL6_1751800_212000 0.024
R_VDD6_16580 METAL6_1751800_212000 METAL6_1751800_248300 0.0726
R_VDD6_16581 METAL6_1751800_248300 METAL6_1751800_251000 0.0054
R_VDD6_16582 METAL6_1751800_251000 METAL6_1751800_260300 0.0186
R_VDD6_16583 METAL6_1751800_260300 METAL6_1751800_263000 0.0054
R_VDD6_16584 METAL6_1751800_263000 METAL6_1751800_272300 0.0186
R_VDD6_16585 METAL6_1751800_272300 METAL6_1751800_275000 0.0054
R_VDD6_16586 METAL6_1751800_275000 METAL6_1751800_279300 0.0086
R_VDD6_16587 METAL6_1751800_279300 METAL6_1751800_287000 0.0154
R_VDD6_16588 METAL6_1751800_287000 METAL6_1751800_288000 0.002
R_VDD6_16589 METAL6_1751800_288000 METAL6_1751800_299000 0.022
R_VDD6_16590 METAL6_1751800_299000 METAL6_1751800_300000 0.002
R_VDD6_16591 METAL6_1751800_300000 METAL6_1751800_312000 0.024
R_VDD6_16592 METAL6_1751800_312000 METAL6_1751800_355300 0.0866
R_VDD6_16593 METAL6_1751800_355300 METAL6_1751800_362300 0.014
R_VDD6_16594 METAL6_1751800_362300 METAL6_1751800_366800 0.009
R_VDD6_16595 METAL6_1751800_366800 METAL6_1751800_374300 0.015
R_VDD6_16596 METAL6_1751800_374300 METAL6_1751800_378800 0.009
R_VDD6_16597 METAL6_1751800_378800 METAL6_1751800_386300 0.015
R_VDD6_16598 METAL6_1751800_386300 METAL6_1751800_388000 0.0034
R_VDD6_16599 METAL6_1751800_388000 METAL6_1751800_390800 0.0056
R_VDD6_16600 METAL6_1751800_390800 METAL6_1751800_400000 0.0184
R_VDD6_16601 METAL6_1751800_400000 METAL6_1751800_402800 0.0056
R_VDD6_16602 METAL6_1751800_402800 METAL6_1751800_412000 0.0184
R_VDD6_16603 METAL6_1751800_412000 METAL6_1751800_413000 0.002
R_VDD6_16604 METAL6_1751800_413000 METAL6_1751800_414800 0.0036
R_VDD6_16605 METAL6_1751800_414800 METAL6_1751800_425000 0.0204
R_VDD6_16606 METAL6_1751800_425000 METAL6_1751800_437000 0.024
R_VDD6_16607 METAL6_1751800_437000 METAL6_1751400_437000 0.0008
R_VDD6_16608 METAL6_1751400_437000 METAL6_1744000_437000 0.0148
R_VDD6_16609 METAL6_1744000_437000 METAL6_1743700_437000 0.0006
R_VDD6_16610 METAL6_1743700_437000 METAL6_1741800_437000 0.0038
R_VDD6_16611 METAL6_1741800_437000 METAL6_1739800_437000 0.004
R_VDD6_16612 METAL6_1739800_437000 METAL6_1739400_437000 0.0008
R_VDD6_16613 METAL6_1739400_437000 METAL6_1731700_437000 0.0154
R_VDD6_16614 METAL6_1731700_437000 METAL6_1729800_437000 0.0038
R_VDD6_16615 METAL6_1729800_437000 METAL6_1727800_437000 0.004
R_VDD6_16616 METAL6_1727800_437000 METAL6_1719700_437000 0.0162
R_VDD6_16617 METAL6_1719700_437000 METAL6_1717800_437000 0.0038
R_VDD6_16618 METAL6_1717800_437000 METAL6_1710800_437000 0.014
R_VDD6_16619 METAL6_1710800_437000 METAL6_1707700_437000 0.0062
R_VDD6_16620 METAL6_1707700_437000 METAL6_1699000_437000 0.0174
R_VDD6_16621 METAL6_1699000_437000 METAL6_1692000_437000 0.014
R_VDD6_16622 METAL6_1692000_437000 METAL6_1680000_437000 0.024
R_VDD6_16623 METAL6_1680000_437000 METAL6_1670800_437000 0.0184
R_VDD6_16624 METAL6_1670800_437000 METAL6_1668000_437000 0.0056
R_VDD6_16625 METAL6_1668000_437000 METAL6_1658800_437000 0.0184
R_VDD6_16626 METAL6_1658800_437000 METAL6_1646800_437000 0.024
R_VDD6_16627 METAL6_1646800_437000 METAL6_1634800_437000 0.024
R_VDD6_16628 METAL6_1634800_437000 METAL6_1632800_437000 0.004
R_VDD6_16629 METAL6_1632800_437000 METAL6_1627800_437000 0.01
R_VDD6_16630 METAL6_1627800_437000 METAL6_1615800_437000 0.024
R_VDD6_16631 METAL6_1615800_437000 METAL6_1612700_437000 0.0062
R_VDD6_16632 METAL6_1612700_437000 METAL6_1612000_437000 0.0014
R_VDD6_16633 METAL6_1612000_437000 METAL5_1612000_437000 0.1
R_VDD6_16634 METAL5_1612000_437000 METAL5_1612000_449000 0.048
R_VDD6_16635 METAL5_1612000_449000 METAL5_1612000_453000 0.016
R_VDD6_16636 METAL5_1612000_453000 METAL5_1612000_459000 0.024
R_VDD6_16637 METAL5_1612000_459000 METAL5_1612000_461000 0.008
R_VDD6_16638 METAL5_1612000_461000 METAL5_1607900_461000 0.0164
R_VDD6_16639 METAL5_1607900_461000 METAL5_1603800_461000 0.0164
R_VDD6_16640 METAL5_1603800_461000 METAL5_1600700_461000 0.0124
R_VDD6_16641 METAL5_1600700_461000 METAL5_1600000_461000 0.0028
R_VDD6_16642 METAL5_1600000_461000 METAL5_1591800_461000 0.0328
R_VDD6_16643 METAL5_1591800_461000 METAL5_1588700_461000 0.0124
R_VDD6_16644 METAL5_1588700_461000 METAL5_1588000_461000 0.0028
R_VDD6_16645 METAL5_1588000_461000 METAL5_1579800_461000 0.0328
R_VDD6_16646 METAL5_1579800_461000 METAL5_1576700_461000 0.0124
R_VDD6_16647 METAL5_1576700_461000 METAL5_1576000_461000 0.0028
R_VDD6_16648 METAL5_1576000_461000 METAL6_1576000_461000 0.1
R_VDD6_16649 METAL6_1576000_461000 METAL6_1576000_465000 0.008
R_VDD6_16650 METAL6_1576000_465000 METAL6_1576000_468400 0.0068
R_VDD6_16651 METAL6_1576000_468400 METAL6_1576000_471000 0.0052
R_VDD6_16652 METAL6_1576000_471000 METAL6_1576000_477000 0.012
R_VDD6_16653 METAL6_1576000_477000 METAL6_1576000_480400 0.0068
R_VDD6_16654 METAL6_1576000_480400 METAL6_1574700_480400 0.0026
R_VDD6_16655 METAL6_1574700_480400 METAL6_1564000_480400 0.0214
R_VDD6_16656 METAL6_1564000_480400 METAL6_1557000_480400 0.014
R_VDD6_16657 METAL6_1557000_480400 METAL6_1555400_480400 0.0032
R_VDD6_16658 METAL6_1555400_480400 METAL6_1551800_480400 0.0072
R_VDD6_16659 METAL6_1551800_480400 METAL6_1539800_480400 0.024
R_VDD6_16660 METAL6_1539800_480400 METAL6_1527800_480400 0.024
R_VDD6_16661 METAL6_1527800_480400 METAL6_1512000_480400 0.0316
R_VDD6_16662 METAL6_1512000_480400 METAL6_1510400_480400 0.0032
R_VDD6_16663 METAL6_1510400_480400 METAL6_1503400_480400 0.014
R_VDD6_16664 METAL6_1503400_480400 METAL6_1500000_480400 0.0068
R_VDD6_16665 METAL6_1500000_480400 METAL6_1498300_480400 0.0034
R_VDD6_16666 METAL6_1498300_480400 METAL6_1491400_480400 0.0138
R_VDD6_16667 METAL6_1491400_480400 METAL6_1488000_480400 0.0068
R_VDD6_16668 METAL6_1488000_480400 METAL6_1479400_480400 0.0172
R_VDD6_16669 METAL6_1479400_480400 METAL6_1443700_480400 0.0714
R_VDD6_16670 METAL6_1443700_480400 METAL6_1432800_480400 0.0218
R_VDD6_16671 METAL6_1432800_480400 METAL6_1432800_483000 0.0052
R_VDD6_16672 METAL6_1432800_483000 METAL6_1432800_488000 0.01
R_VDD6_16673 METAL6_1432800_488000 METAL6_1432800_492400 0.0088
R_VDD6_16674 METAL6_1432800_492400 METAL6_1432800_495000 0.0052
R_VDD6_16675 METAL6_1432800_495000 METAL6_1432800_500000 0.01
R_VDD6_16676 METAL6_1432800_500000 METAL6_1432800_504000 0.008
R_VDD6_16677 METAL6_1432800_504000 METAL6_1432800_507000 0.006
R_VDD6_16678 METAL6_1432800_507000 METAL6_1431700_507000 0.0022
R_VDD6_16679 METAL6_1431700_507000 METAL6_1424000_507000 0.0154
R_VDD6_16680 METAL6_1424000_507000 METAL6_1419700_507000 0.0086
R_VDD6_16681 METAL6_1419700_507000 METAL6_1412000_507000 0.0154
R_VDD6_16682 METAL6_1412000_507000 METAL6_1400000_507000 0.024
R_VDD6_16683 METAL6_1400000_507000 METAL6_1388000_507000 0.024
R_VDD6_16684 METAL6_1388000_507000 METAL6_1337000_507000 0.102
R_VDD6_16685 METAL6_1337000_507000 METAL6_1325000_507000 0.024
R_VDD6_16686 METAL6_1325000_507000 METAL6_1324000_507000 0.002
R_VDD6_16687 METAL6_1324000_507000 METAL6_1324000_507800 0.0016
R_VDD6_16688 METAL6_1324000_507800 METAL6_1324000_512000 0.0084
R_VDD6_16689 METAL6_1324000_512000 METAL6_1324000_516000 0.008
R_VDD6_16690 METAL6_1324000_516000 METAL6_1324000_519000 0.006
R_VDD6_16691 METAL6_1324000_519000 METAL6_1324000_520200 0.0024
R_VDD6_16692 METAL6_1324000_520200 METAL6_1324000_528000 0.0156
R_VDD6_16693 METAL6_1324000_528000 METAL6_1324000_532200 0.0084
R_VDD6_16694 METAL6_1324000_532200 METAL6_1324000_535400 0.0064
R_VDD6_16695 METAL6_1324000_535400 METAL6_1324000_544200 0.0176
R_VDD6_16696 METAL6_1324000_544200 METAL6_1324000_547400 0.0064
R_VDD6_16697 METAL6_1324000_547400 METAL6_1324000_550400 0.006
R_VDD6_16698 METAL6_1324000_550400 METAL6_1324000_556200 0.0116
R_VDD6_16699 METAL6_1324000_556200 METAL6_1324000_559400 0.0064
R_VDD6_16700 METAL6_1324000_559400 METAL6_1324000_561000 0.0032
R_VDD6_16701 METAL6_1324000_561000 METAL6_1324000_562400 0.0028
R_VDD6_16702 METAL6_1324000_562400 METAL6_1324000_573000 0.0212
R_VDD6_16703 METAL6_1324000_573000 METAL6_1324000_574400 0.0028
R_VDD6_16704 METAL6_1324000_574400 METAL6_1324000_579800 0.0108
R_VDD6_16705 METAL6_1324000_579800 METAL6_1324000_585000 0.0104
R_VDD6_16706 METAL6_1324000_585000 METAL6_1324000_586400 0.0028
R_VDD6_16707 METAL6_1324000_586400 METAL6_1323800_586400 0.0004
R_VDD6_16708 METAL6_1323800_586400 METAL6_1313000_586400 0.0216
R_VDD6_16709 METAL6_1313000_586400 METAL6_1312000_586400 0.002
R_VDD6_16710 METAL6_1312000_586400 METAL6_1311800_586400 0.0004
R_VDD6_16711 METAL6_1311800_586400 METAL6_1301000_586400 0.0216
R_VDD6_16712 METAL6_1301000_586400 METAL6_1300000_586400 0.002
R_VDD6_16713 METAL6_1300000_586400 METAL6_1299800_586400 0.0004
R_VDD6_16714 METAL6_1299800_586400 METAL6_1289000_586400 0.0216
R_VDD6_16715 METAL6_1289000_586400 METAL6_1288000_586400 0.002
R_VDD6_16716 METAL6_1288000_586400 METAL6_1287800_586400 0.0004
R_VDD6_16717 METAL6_1287800_586400 METAL6_1286700_586400 0.0022
R_VDD6_16718 METAL6_1286700_586400 METAL6_1274700_586400 0.024
R_VDD6_16719 METAL6_1274700_586400 METAL6_1266800_586400 0.0158
R_VDD6_16720 METAL6_1266800_586400 METAL6_1262700_586400 0.0082
R_VDD6_16721 METAL6_1262700_586400 METAL6_1259800_586400 0.0058
R_VDD6_16722 METAL6_1259800_586400 METAL6_1258300_586400 0.003
R_VDD6_16723 METAL6_1258300_586400 METAL6_1254700_586400 0.0072
R_VDD6_16724 METAL6_1254700_586400 METAL6_1253300_586400 0.0028
R_VDD6_16725 METAL6_1253300_586400 METAL6_1247800_586400 0.011
R_VDD6_16726 METAL6_1247800_586400 METAL6_1247800_588000 0.0032
R_VDD6_16727 METAL6_1247800_588000 METAL6_1247800_598400 0.0208
R_VDD6_16728 METAL6_1247800_598400 METAL6_1247800_600000 0.0032
R_VDD6_16729 METAL6_1247800_600000 METAL6_1247800_612000 0.024
R_VDD6_16730 METAL6_1247800_612000 METAL6_1247800_637800 0.0516
R_VDD6_16731 METAL6_1247800_637800 METAL6_1247800_641400 0.0072
R_VDD6_16732 METAL6_1247800_641400 METAL6_1246300_641400 0.003
R_VDD6_16733 METAL6_1246300_641400 METAL6_1242700_641400 0.0072
R_VDD6_16734 METAL6_1242700_641400 METAL6_1235800_641400 0.0138
R_VDD6_16735 METAL6_1235800_641400 METAL6_1235800_649800 0.0168
R_VDD6_16736 METAL6_1235800_649800 METAL6_1235800_653400 0.0072
R_VDD6_16737 METAL6_1235800_653400 METAL6_1235800_661800 0.0168
R_VDD6_16738 METAL6_1235800_661800 METAL6_1235800_665400 0.0072
R_VDD6_16739 METAL6_1235800_665400 METAL6_1235800_688000 0.0452
R_VDD6_16740 METAL6_1235800_688000 METAL6_1235800_697800 0.0196
R_VDD6_16741 METAL6_1235800_697800 METAL6_1235800_700000 0.0044
R_VDD6_16742 METAL6_1235800_700000 METAL6_1235800_702800 0.0056
R_VDD6_16743 METAL6_1235800_702800 METAL6_1235800_709800 0.014
R_VDD6_16744 METAL6_1235800_709800 METAL6_1235800_712000 0.0044
R_VDD6_16745 METAL6_1235800_712000 METAL6_1235800_716800 0.0096
R_VDD6_16746 METAL6_1235800_716800 METAL6_1235800_721800 0.01
R_VDD6_16747 METAL6_1235800_721800 METAL6_1235800_733800 0.024
R_VDD6_16748 METAL6_1235800_733800 METAL6_1235800_735400 0.0032
R_VDD6_16749 METAL6_1235800_735400 METAL6_1235800_742400 0.014
R_VDD6_16750 METAL6_1235800_742400 METAL6_1235800_745800 0.0068
R_VDD6_16751 METAL6_1235800_745800 METAL6_1234300_745800 0.003
R_VDD6_16752 METAL6_1234300_745800 METAL6_1230700_745800 0.0072
R_VDD6_16753 METAL6_1230700_745800 METAL6_1224000_745800 0.0134
R_VDD6_16754 METAL6_1224000_745800 METAL6_1224000_746400 0.0012
R_VDD6_16755 METAL6_1224000_746400 METAL6_1224000_754400 0.016
R_VDD6_16756 METAL6_1224000_754400 METAL6_1224000_758400 0.008
R_VDD6_16757 METAL6_1224000_758400 METAL6_1224000_760000 0.0032
R_VDD6_16758 METAL6_1224000_760000 METAL6_1224000_763000 0.006
R_VDD6_16759 METAL6_1224000_763000 METAL6_1224000_766400 0.0068
R_VDD6_16760 METAL6_1224000_766400 METAL6_1224000_770400 0.008
R_VDD6_16761 METAL6_1224000_770400 METAL6_1224000_772000 0.0032
R_VDD6_16762 METAL6_1224000_772000 METAL6_1224000_778400 0.0128
R_VDD6_16763 METAL6_1224000_778400 METAL6_1224000_779200 0.0016
R_VDD6_16764 METAL6_1224000_779200 METAL6_1224000_782400 0.0064
R_VDD6_16765 METAL6_1224000_782400 METAL6_1224000_784000 0.0032
R_VDD6_16766 METAL6_1224000_784000 METAL6_1224000_784500 0.001
R_VDD6_16767 METAL6_1224000_784500 METAL6_1224000_788000 0.007
R_VDD6_16768 METAL6_1224000_788000 METAL6_1224000_790400 0.0048
R_VDD6_16769 METAL6_1224000_790400 METAL6_1224000_791200 0.0016
R_VDD6_16770 METAL6_1224000_791200 METAL6_1224000_794400 0.0064
R_VDD6_16771 METAL6_1224000_794400 METAL6_1224000_794800 0.0008
R_VDD6_16772 METAL6_1224000_794800 METAL6_1224000_800000 0.0104
R_VDD6_16773 METAL6_1224000_800000 METAL6_1224000_802400 0.0048
R_VDD6_16774 METAL6_1224000_802400 METAL6_1224000_803200 0.0016
R_VDD6_16775 METAL6_1224000_803200 METAL6_1224000_806400 0.0064
R_VDD6_16776 METAL6_1224000_806400 METAL6_1224000_808000 0.0032
R_VDD6_16777 METAL6_1224000_808000 METAL6_1224000_812000 0.008
R_VDD6_16778 METAL6_1224000_812000 METAL6_1224000_814400 0.0048
R_VDD6_16779 METAL6_1224000_814400 METAL6_1224000_818400 0.008
R_VDD6_16780 METAL6_1224000_818400 METAL6_1224000_820000 0.0032
R_VDD6_16781 METAL6_1224000_820000 METAL6_1224000_828700 0.0174
R_VDD6_16782 METAL6_1224000_828700 METAL6_1224000_830400 0.0034
R_VDD6_16783 METAL6_1224000_830400 METAL6_1224000_832000 0.0032
R_VDD6_16784 METAL6_1224000_832000 METAL6_1224000_839500 0.015
R_VDD6_16785 METAL6_1224000_839500 METAL6_1224000_840700 0.0024
R_VDD6_16786 METAL6_1224000_840700 METAL6_1224000_851500 0.0216
R_VDD6_16787 METAL6_1224000_851500 METAL6_1224000_852700 0.0024
R_VDD6_16788 METAL6_1224000_852700 METAL6_1224000_858200 0.011
R_VDD6_16789 METAL6_1224000_858200 METAL6_1224000_863500 0.0106
R_VDD6_16790 METAL6_1224000_863500 METAL6_1224000_875000 0.023
R_VDD6_16791 METAL6_1224000_875000 METAL6_1224000_887000 0.024
R_VDD6_16792 METAL6_1224000_887000 METAL6_1224000_888000 0.002
R_VDD6_16793 METAL6_1224000_888000 METAL6_1224000_899000 0.022
R_VDD6_16794 METAL6_1224000_899000 METAL6_1224000_900000 0.002
R_VDD6_16795 METAL6_1224000_900000 METAL6_1224000_900400 0.0008
R_VDD6_16796 METAL6_1224000_900400 METAL6_1224000_912000 0.0232
R_VDD6_16797 METAL6_1224000_912000 METAL6_1224000_927300 0.0306
R_VDD6_16798 METAL6_1224000_927300 METAL6_1224000_947000 0.0394
R_VDD6_16799 METAL6_1224000_947000 METAL6_1223800_947000 0.0004
R_VDD6_16800 METAL6_1223800_947000 METAL6_1222300_947000 0.003
R_VDD6_16801 METAL6_1222300_947000 METAL6_1218700_947000 0.0072
R_VDD6_16802 METAL6_1218700_947000 METAL6_1216400_947000 0.0046
R_VDD6_16803 METAL6_1216400_947000 METAL6_1212000_947000 0.0088
R_VDD6_16804 METAL6_1212000_947000 METAL6_1211800_947000 0.0004
R_VDD6_16805 METAL6_1211800_947000 METAL6_1210300_947000 0.003
R_VDD6_16806 METAL6_1210300_947000 METAL6_1206700_947000 0.0072
R_VDD6_16807 METAL6_1206700_947000 METAL6_1204400_947000 0.0046
R_VDD6_16808 METAL6_1204400_947000 METAL6_1200000_947000 0.0088
R_VDD6_16809 METAL6_1200000_947000 METAL6_1199800_947000 0.0004
R_VDD6_16810 METAL6_1199800_947000 METAL6_1198300_947000 0.003
R_VDD6_16811 METAL6_1198300_947000 METAL6_1194700_947000 0.0072
R_VDD6_16812 METAL6_1194700_947000 METAL6_1192400_947000 0.0046
R_VDD6_16813 METAL6_1192400_947000 METAL6_1188000_947000 0.0088
R_VDD6_16814 METAL6_1188000_947000 METAL6_1186300_947000 0.0034
R_VDD6_16815 METAL6_1186300_947000 METAL6_1180400_947000 0.0118
R_VDD6_16816 METAL6_1180400_947000 METAL6_1174300_947000 0.0122
R_VDD6_16817 METAL6_1174300_947000 METAL6_1173700_947000 0.0012
R_VDD6_16818 METAL6_1173700_947000 METAL6_1166700_947000 0.014
R_VDD6_16819 METAL6_1166700_947000 METAL6_1154700_947000 0.024
R_VDD6_16820 METAL6_1154700_947000 METAL6_1142700_947000 0.024
R_VDD6_16821 METAL6_1142700_947000 METAL6_1142700_959000 0.024
R_VDD6_16822 METAL6_1142700_959000 METAL6_1142700_971000 0.024
R_VDD6_16823 METAL6_1142700_971000 METAL6_1137000_971000 0.0114
R_VDD6_16824 METAL6_1137000_971000 METAL6_1130700_971000 0.0126
R_VDD6_16825 METAL6_1130700_971000 METAL6_1125000_971000 0.0114
R_VDD6_16826 METAL6_1125000_971000 METAL6_1113000_971000 0.024
R_VDD6_16827 METAL6_1113000_971000 METAL6_1019000_971000 0.188
R_VDD6_16828 METAL6_1019000_971000 METAL6_1007000_971000 0.024
R_VDD6_16829 METAL6_1007000_971000 METAL6_995000_971000 0.024
R_VDD6_16830 METAL6_995000_971000 METAL6_988000_971000 0.014
R_VDD6_16831 METAL6_988000_971000 METAL6_952400_971000 0.0712
R_VDD6_16832 METAL6_952400_971000 METAL6_952400_976000 0.01
R_VDD6_16833 METAL6_952400_976000 METAL6_952400_988000 0.024
R_VDD6_16834 METAL6_952400_988000 METAL6_952400_995000 0.014
R_VDD6_16835 METAL6_952400_995000 METAL5_952400_995000 0.1
R_VDD6_16836 METAL5_952400_995000 METAL5_952400_1000000 0.02
R_VDD6_16837 METAL5_952400_1000000 METAL5_952400_1007000 0.028
R_VDD6_16838 METAL5_952400_1007000 METAL5_952400_1012000 0.02
R_VDD6_16839 METAL5_952400_1012000 METAL5_952400_1014000 0.008
R_VDD6_16840 METAL5_952400_1014000 METAL5_952400_1019000 0.02
R_VDD6_16841 METAL5_952400_1019000 METAL6_952400_1019000 0.1
R_VDD6_16842 METAL6_952400_1019000 METAL6_947400_1019000 0.01
R_VDD6_16843 METAL6_947400_1019000 METAL6_940400_1019000 0.014
R_VDD6_16844 METAL6_940400_1019000 METAL6_928400_1019000 0.024
R_VDD6_16845 METAL6_928400_1019000 METAL6_916400_1019000 0.024
R_VDD6_16846 METAL6_916400_1019000 METAL6_904400_1019000 0.024
R_VDD6_16847 METAL6_904400_1019000 METAL6_892400_1019000 0.024
R_VDD6_16848 METAL6_892400_1019000 METAL6_880400_1019000 0.024
R_VDD6_16849 METAL6_880400_1019000 METAL6_719000_1019000 0.3228
R_VDD6_16850 METAL6_719000_1019000 METAL6_719000_1023700 0.0094
R_VDD6_16851 METAL6_719000_1023700 METAL6_719000_1025400 0.0034
R_VDD6_16852 METAL6_719000_1025400 METAL6_719000_1026000 0.0012
R_VDD6_16853 METAL6_719000_1026000 METAL6_719000_1029800 0.0076
R_VDD6_16854 METAL6_719000_1029800 METAL6_719000_1031000 0.0024
R_VDD6_16855 METAL6_719000_1031000 METAL6_719000_1035700 0.0094
R_VDD6_16856 METAL6_719000_1035700 METAL6_719000_1037400 0.0034
R_VDD6_16857 METAL6_719000_1037400 METAL6_719000_1038000 0.0012
R_VDD6_16858 METAL6_719000_1038000 METAL6_719000_1041800 0.0076
R_VDD6_16859 METAL6_719000_1041800 METAL6_719000_1042700 0.0018
R_VDD6_16860 METAL6_719000_1042700 METAL6_719000_1047700 0.01
R_VDD6_16861 METAL6_719000_1047700 METAL6_719000_1049400 0.0034
R_VDD6_16862 METAL6_719000_1049400 METAL6_719000_1049800 0.0008
R_VDD6_16863 METAL6_719000_1049800 METAL6_719000_1053800 0.008
R_VDD6_16864 METAL6_719000_1053800 METAL6_719000_1054700 0.0018
R_VDD6_16865 METAL6_719000_1054700 METAL6_719000_1061400 0.0134
R_VDD6_16866 METAL6_719000_1061400 METAL6_719000_1061800 0.0008
R_VDD6_16867 METAL6_719000_1061800 METAL6_719000_1066700 0.0098
R_VDD6_16868 METAL6_719000_1066700 METAL6_719000_1073800 0.0142
R_VDD6_16869 METAL6_719000_1073800 METAL6_707000_1073800 0.024
R_VDD6_16870 METAL6_707000_1073800 METAL6_707000_1074000 0.0004
R_VDD6_16871 METAL6_707000_1074000 METAL6_707000_1074500 0.001
R_VDD6_16872 METAL6_707000_1074500 METAL6_707000_1086000 0.023
R_VDD6_16873 METAL6_707000_1086000 METAL6_707000_1086300 0.0006
R_VDD6_16874 METAL6_707000_1086300 METAL6_707000_1086500 0.0004
R_VDD6_16875 METAL6_707000_1086500 METAL6_707000_1088000 0.003
R_VDD6_16876 METAL6_707000_1088000 METAL6_707000_1096800 0.0176
R_VDD6_16877 METAL6_707000_1096800 METAL6_707000_1098000 0.0024
R_VDD6_16878 METAL6_707000_1098000 METAL6_707000_1098300 0.0006
R_VDD6_16879 METAL6_707000_1098300 METAL6_707000_1098500 0.0004
R_VDD6_16880 METAL6_707000_1098500 METAL6_707000_1100000 0.003
R_VDD6_16881 METAL6_707000_1100000 METAL6_707000_1108800 0.0176
R_VDD6_16882 METAL6_707000_1108800 METAL6_707000_1110000 0.0024
R_VDD6_16883 METAL6_707000_1110000 METAL6_707000_1110300 0.0006
R_VDD6_16884 METAL6_707000_1110300 METAL6_707000_1110500 0.0004
R_VDD6_16885 METAL6_707000_1110500 METAL6_707000_1112000 0.003
R_VDD6_16886 METAL6_707000_1112000 METAL6_707000_1120800 0.0176
R_VDD6_16887 METAL6_707000_1120800 METAL6_707000_1122300 0.003
R_VDD6_16888 METAL6_707000_1122300 METAL6_707000_1122500 0.0004
R_VDD6_16889 METAL6_707000_1122500 METAL6_707000_1129300 0.0136
R_VDD6_16890 METAL6_707000_1129300 METAL6_707000_1132800 0.007
R_VDD6_16891 METAL6_707000_1132800 METAL6_707000_1134300 0.003
R_VDD6_16892 METAL6_707000_1134300 METAL6_707000_1134500 0.0004
R_VDD6_16893 METAL6_707000_1134500 METAL6_707000_1141300 0.0136
R_VDD6_16894 METAL6_707000_1141300 METAL6_707000_1146300 0.01
R_VDD6_16895 METAL6_707000_1146300 METAL6_707000_1153300 0.014
R_VDD6_16896 METAL6_707000_1153300 METAL6_707000_1157700 0.0088
R_VDD6_16897 METAL6_707000_1157700 METAL6_707000_1160600 0.0058
R_VDD6_16898 METAL6_707000_1160600 METAL6_707000_1169700 0.0182
R_VDD6_16899 METAL6_707000_1169700 METAL6_707000_1172600 0.0058
R_VDD6_16900 METAL6_707000_1172600 METAL6_707000_1181700 0.0182
R_VDD6_16901 METAL6_707000_1181700 METAL6_707000_1181800 0.0002
R_VDD6_16902 METAL6_707000_1181800 METAL6_707000_1184600 0.0056
R_VDD6_16903 METAL6_707000_1184600 METAL6_707000_1191600 0.014
R_VDD6_16904 METAL6_707000_1191600 METAL6_707000_1193700 0.0042
R_VDD6_16905 METAL6_707000_1193700 METAL6_707000_1193800 0.0002
R_VDD6_16906 METAL6_707000_1193800 METAL6_707000_1205700 0.0238
R_VDD6_16907 METAL6_707000_1205700 METAL6_700000_1205700 0.014
R_VDD6_16908 METAL6_700000_1205700 METAL6_700000_1205800 0.0002
R_VDD6_16909 METAL6_700000_1205800 METAL6_700000_1217700 0.0238
R_VDD6_16910 METAL6_700000_1217700 METAL6_700000_1223700 0.012
R_VDD6_16911 METAL6_700000_1223700 METAL6_700000_1229700 0.012
R_VDD6_16912 METAL6_700000_1229700 METAL6_700000_1235700 0.012
R_VDD6_16913 METAL6_700000_1235700 METAL6_700000_1238000 0.0046
R_VDD6_16914 METAL6_700000_1238000 METAL6_700000_1247700 0.0194
R_VDD6_16915 METAL6_700000_1247700 METAL6_700000_1250000 0.0046
R_VDD6_16916 METAL6_700000_1250000 METAL6_700000_1259700 0.0194
R_VDD6_16917 METAL6_700000_1259700 METAL6_700000_1261000 0.0026
R_VDD6_16918 METAL6_700000_1261000 METAL6_700000_1262000 0.002
R_VDD6_16919 METAL6_700000_1262000 METAL6_700000_1271700 0.0194
R_VDD6_16920 METAL6_700000_1271700 METAL6_700000_1273000 0.0026
R_VDD6_16921 METAL6_700000_1273000 METAL6_700000_1283700 0.0214
R_VDD6_16922 METAL6_700000_1283700 METAL6_700000_1285000 0.0026
R_VDD6_16923 METAL6_700000_1285000 METAL6_700000_1295700 0.0214
R_VDD6_16924 METAL6_700000_1295700 METAL6_700000_1297000 0.0026
R_VDD6_16925 METAL6_700000_1297000 METAL6_700000_1302000 0.01
R_VDD6_16926 METAL6_700000_1302000 METAL6_700000_1307700 0.0114
R_VDD6_16927 METAL6_700000_1307700 METAL6_700000_1309000 0.0026
R_VDD6_16928 METAL6_700000_1309000 METAL6_700000_1314000 0.01
R_VDD6_16929 METAL6_700000_1314000 METAL6_700000_1319700 0.0114
R_VDD6_16930 METAL6_700000_1319700 METAL6_700000_1326000 0.0126
R_VDD6_16931 METAL6_700000_1326000 METAL6_700000_1338000 0.024
R_VDD6_16932 METAL6_700000_1338000 METAL5_700000_1338000 0.1
R_VDD6_16933 METAL5_700000_1338000 METAL5_700000_1350000 0.048
R_VDD6_16934 METAL5_700000_1350000 METAL5_700000_1357000 0.028
R_VDD6_16935 METAL5_700000_1357000 METAL5_700000_1362000 0.02
R_VDD6_16936 METAL5_700000_1362000 METAL6_700000_1362000 0.1
R_VDD6_16937 METAL6_700000_1362000 METAL6_700000_1369000 0.014
R_VDD6_16938 METAL6_700000_1369000 METAL6_695000_1369000 0.01
R_VDD6_16939 METAL6_695000_1369000 METAL6_688000_1369000 0.014
R_VDD6_16940 METAL6_688000_1369000 METAL6_676000_1369000 0.024
R_VDD6_16941 METAL6_676000_1369000 METAL6_569000_1369000 0.214
R_VDD6_16942 METAL6_569000_1369000 METAL6_557000_1369000 0.024
R_VDD6_16943 METAL6_557000_1369000 METAL6_545000_1369000 0.024
R_VDD6_16944 METAL6_545000_1369000 METAL6_545000_1374000 0.01
R_VDD6_16945 METAL6_545000_1374000 METAL6_545000_1381000 0.014
R_VDD6_16946 METAL6_545000_1381000 METAL6_545000_1386600 0.0112
R_VDD6_16947 METAL6_545000_1386600 METAL6_545000_1393000 0.0128
R_VDD6_16948 METAL6_545000_1393000 METAL6_543000_1393000 0.004
R_VDD6_16949 METAL6_543000_1393000 METAL6_538000_1393000 0.01
R_VDD6_16950 METAL6_538000_1393000 METAL6_343000_1393000 0.39
R_VDD6_16951 METAL6_343000_1393000 METAL6_219000_1393000 0.248
R_VDD6_16952 METAL6_219000_1393000 METAL6_219000_1405000 0.024
R_VDD6_16953 METAL6_219000_1405000 METAL6_219000_1437700 0.0654
R_VDD6_16954 METAL6_219000_1437700 METAL6_219000_1449700 0.024
R_VDD6_16955 METAL6_219000_1449700 METAL6_219000_1461700 0.024
R_VDD6_16956 METAL6_219000_1461700 METAL6_219000_1492300 0.0612
R_VDD6_16957 METAL6_219000_1492300 METAL6_219000_1504300 0.024
R_VDD6_16958 METAL6_219000_1504300 METAL6_219000_1516300 0.024
R_VDD6_16959 METAL6_219000_1516300 METAL6_219000_1528300 0.024
R_VDD6_16960 METAL6_219000_1528300 METAL6_219000_1540300 0.024
R_VDD6_16961 METAL6_219000_1540300 METAL6_219000_1552300 0.024
R_VDD6_16962 METAL6_219000_1552300 METAL6_219000_1554500 0.0044
R_VDD6_16963 METAL6_219000_1554500 METAL6_219000_1564300 0.0196
R_VDD6_16964 METAL6_219000_1564300 METAL6_219000_1571300 0.014
R_VDD6_16965 METAL6_219000_1571300 METAL6_219000_1576300 0.01
R_VDD6_16966 METAL6_219000_1576300 METAL6_219000_1714500 0.2764
R_VDD6_16967 METAL6_219000_1714500 METAL6_219000_1720500 0.012
R_VDD6_16968 METAL6_219000_1720500 METAL6_219000_1726500 0.012
R_VDD6_16969 METAL6_219000_1726500 METAL6_219000_1731700 0.0104
R_VDD6_16970 METAL6_219000_1731700 METAL6_219000_1738500 0.0136
R_VDD6_16971 METAL6_219000_1738500 METAL6_219000_1750500 0.024
R_VDD6_16972 METAL6_219000_1750500 METAL6_219000_1762500 0.024
R_VDD6_16973 METAL6_219000_1762500 METAL6_219000_1774500 0.024
R_VDD6_16974 METAL6_219000_1774500 METAL6_219000_1802500 0.056
R_VDD6_16975 METAL6_219000_1802500 METAL6_219000_1814500 0.024
R_VDD6_16976 METAL6_219000_1814500 METAL6_219000_1826500 0.024
R_VDD6_16977 METAL6_219000_1826500 METAL6_219000_1838500 0.024
R_VDD6_16978 METAL6_219000_1838500 METAL6_219000_1852300 0.0276
R_VDD6_16979 METAL6_219000_1852300 METAL6_219000_1866300 0.028
R_VDD6_16980 METAL6_219000_1866300 METAL6_219000_1902500 0.0724
R_VDD6_16981 METAL6_219000_1902500 METAL6_219000_1914500 0.024
R_VDD6_16982 METAL6_219000_1914500 METAL6_219000_1926500 0.024
R_VDD6_16983 METAL6_219000_1926500 METAL6_219000_1938500 0.024
R_VDD6_16984 METAL6_219000_1938500 METAL6_219000_1939000 0.001
R_VDD6_16985 METAL6_219000_1939000 METAL6_219000_1940500 0.003
R_VDD6_16986 METAL6_219000_1940500 METAL6_219000_1950500 0.02
R_VDD6_16987 METAL6_219000_1950500 METAL6_219000_1951000 0.001
R_VDD6_16988 METAL6_219000_1951000 METAL6_219000_1952500 0.003
R_VDD6_16989 METAL6_219000_1952500 METAL6_219000_1962500 0.02
R_VDD6_16990 METAL6_219000_1962500 METAL6_219000_1963000 0.001
R_VDD6_16991 METAL6_219000_1963000 METAL6_219000_1964500 0.003
R_VDD6_16992 METAL6_219000_1964500 METAL6_219000_1975000 0.021
R_VDD6_16993 METAL6_219000_1975000 METAL6_219000_1976500 0.003
R_VDD6_16994 METAL6_219000_1976500 METAL6_219000_1987000 0.021
R_VDD6_16995 METAL6_219000_1987000 METAL6_219000_1988500 0.003
R_VDD6_16996 METAL6_219000_1988500 METAL6_219000_2014500 0.052
R_VDD6_16997 METAL6_219000_2014500 METAL6_219000_2026500 0.024
R_VDD6_16998 METAL6_219000_2026500 METAL6_219000_2038500 0.024
R_VDD6_16999 METAL6_219000_2038500 METAL6_219000_2114500 0.152
R_VDD6_17000 METAL6_219000_2114500 METAL6_219000_2126500 0.024
R_VDD6_17001 METAL6_219000_2126500 METAL6_219000_2138500 0.024
R_VDD6_17002 METAL6_219000_2138500 METAL6_219000_2147300 0.0176
R_VDD6_17003 METAL6_219000_2147300 METAL6_219000_2150500 0.0064
R_VDD6_17004 METAL6_219000_2150500 METAL6_219000_2154300 0.0076
R_VDD6_17005 METAL6_219000_2154300 METAL6_219000_2163000 0.0174
R_VDD6_17006 METAL6_219000_2163000 METAL6_219000_2166300 0.0066
R_VDD6_17007 METAL6_219000_2166300 METAL6_219000_2175000 0.0174
R_VDD6_17008 METAL6_219000_2175000 METAL6_219000_2178300 0.0066
R_VDD6_17009 METAL6_219000_2178300 METAL6_219000_2187000 0.0174
R_VDD6_17010 METAL6_219000_2187000 METAL6_207000_2187000 0.024
R_VDD6_17011 METAL6_207000_2187000 METAL6_207000_2190300 0.0066
R_VDD6_17012 METAL6_207000_2190300 METAL6_207000_2202300 0.024
R_VDD6_17013 METAL6_207000_2202300 METAL6_207000_2222500 0.0404
R_VDD6_17014 METAL6_207000_2222500 METAL6_207000_2234500 0.024
R_VDD6_17015 METAL6_207000_2234500 METAL6_207000_2246500 0.024
R_VDD6_17016 METAL6_207000_2246500 METAL6_207000_2256500 0.02
R_VDD6_17017 METAL6_207000_2256500 METAL6_207000_2258500 0.004
R_VDD6_17018 METAL6_207000_2258500 METAL6_207000_2268500 0.02
R_VDD6_17019 METAL6_207000_2268500 METAL6_207000_2276000 0.015
R_VDD6_17020 METAL6_207000_2276000 METAL6_207000_2280500 0.009
R_VDD6_17021 METAL6_207000_2280500 METAL6_207000_2288000 0.015
R_VDD6_17022 METAL6_207000_2288000 METAL6_207000_2292000 0.008
R_VDD6_17023 METAL6_207000_2292000 METAL6_207000_2300000 0.016
R_VDD6_17024 METAL6_207000_2300000 METAL6_207000_2304000 0.008
R_VDD6_17025 METAL6_207000_2304000 METAL6_207000_2305000 0.002
R_VDD6_17026 METAL6_207000_2305000 METAL6_207000_2312000 0.014
R_VDD6_17027 METAL6_207000_2312000 METAL6_207000_2314000 0.004
R_VDD6_17028 METAL6_207000_2314000 METAL6_207000_2316000 0.004
R_VDD6_17029 METAL6_207000_2316000 METAL6_207000_2317000 0.002
R_VDD6_17030 METAL6_207000_2317000 METAL6_207000_2326000 0.018
R_VDD6_17031 METAL6_207000_2326000 METAL6_207000_2328000 0.004
R_VDD6_17032 METAL6_207000_2328000 METAL6_207000_2329000 0.002
R_VDD6_17033 METAL6_207000_2329000 METAL6_207000_2338000 0.018
R_VDD6_17034 METAL6_207000_2338000 METAL6_207000_2340000 0.004
R_VDD6_17035 METAL6_207000_2340000 METAL6_207000_2341000 0.002
R_VDD6_17036 METAL6_207000_2341000 METAL6_207000_2350000 0.018
R_VDD6_17037 METAL6_207000_2350000 METAL6_207000_2352000 0.004
R_VDD6_17038 METAL6_207000_2352000 METAL6_207000_2353000 0.002
R_VDD6_17039 METAL6_207000_2353000 METAL6_207000_2362000 0.018
R_VDD6_17040 METAL6_207000_2362000 METAL6_207000_2364000 0.004
R_VDD6_17041 METAL6_207000_2364000 METAL6_207000_2365000 0.002
R_VDD6_17042 METAL6_207000_2365000 METAL6_207000_2374000 0.018
R_VDD6_17043 METAL6_207000_2374000 METAL6_207000_2376000 0.004
R_VDD6_17044 METAL6_207000_2376000 METAL6_207000_2377000 0.002
R_VDD6_17045 METAL6_207000_2377000 METAL6_207000_2388000 0.022
R_VDD6_17046 METAL6_207000_2388000 METAL6_207000_2389000 0.002
R_VDD6_17047 METAL6_207000_2389000 METAL6_207000_2395000 0.012
R_VDD6_17048 METAL6_207000_2395000 METAL6_207000_2400000 0.01
R_VDD6_17049 METAL6_207000_2400000 METAL6_207000_2401000 0.002
R_VDD6_17050 METAL6_207000_2401000 METAL6_207000_2407000 0.012
R_VDD6_17051 METAL6_207000_2407000 METAL6_207000_2412000 0.01
R_VDD6_17052 METAL6_207000_2412000 METAL6_207000_2413000 0.002
R_VDD6_17053 METAL6_207000_2413000 METAL6_207000_2419000 0.012
R_VDD6_17054 METAL6_207000_2419000 METAL6_207000_2424000 0.01
R_VDD6_17055 METAL6_207000_2424000 METAL6_207000_2436000 0.024
R_VDD6_17056 METAL6_207000_2436000 METAL6_207000_2438000 0.004
R_VDD6_17057 METAL6_207000_2438000 METAL6_207000_2444000 0.012
R_VDD6_17058 METAL6_207000_2444000 METAL6_207000_2450000 0.012
R_VDD6_17059 METAL6_207000_2450000 METAL6_207000_2456000 0.012
R_VDD6_17060 METAL6_207000_2456000 METAL6_207000_2462000 0.012
R_VDD6_17061 METAL6_207000_2462000 METAL6_207000_2468000 0.012
R_VDD6_17062 METAL6_207000_2468000 METAL6_207000_2469000 0.002
R_VDD6_17063 METAL6_207000_2469000 METAL6_207000_2481000 0.024
R_VDD6_17064 METAL6_207000_2481000 METAL6_207000_2493000 0.024
R_VDD6_17065 METAL6_207000_2493000 METAL6_207000_2505000 0.024
R_VDD6_17066 METAL6_207000_2505000 METAL6_207000_2512000 0.014
R_VDD6_17067 METAL6_207000_2512000 METAL6_207000_2517700 0.0114
R_VDD6_17068 METAL6_207000_2517700 METAL6_207000_2524000 0.0126
R_VDD6_17069 METAL6_207000_2524000 METAL6_207000_2529700 0.0114
R_VDD6_17070 METAL6_207000_2529700 METAL6_207000_2536000 0.0126
R_VDD6_17071 METAL6_207000_2536000 METAL6_207000_2541700 0.0114
R_VDD6_17072 METAL6_207000_2541700 METAL6_207000_2548000 0.0126
R_VDD6_17073 METAL6_207000_2548000 METAL6_207000_2553700 0.0114
R_VDD6_17074 METAL6_207000_2553700 METAL6_207000_2589000 0.0706
R_VDD6_17075 METAL6_207000_2589000 METAL6_207000_2603000 0.028
R_VDD6_17076 METAL6_207000_2603000 METAL6_207000_2644000 0.082
R_VDD6_17077 METAL6_207000_2644000 METAL6_207000_2656000 0.024
R_VDD6_17078 METAL6_207000_2656000 METAL6_207000_2665700 0.0194
R_VDD6_17079 METAL6_207000_2665700 METAL6_207000_2668000 0.0046
R_VDD6_17080 METAL6_207000_2668000 METAL6_207000_2701000 0.066
R_VDD6_17081 METAL6_207000_2701000 METAL6_207000_2701700 0.0014
R_VDD6_17082 METAL6_207000_2701700 METAL6_207000_2713000 0.0226
R_VDD6_17083 METAL6_207000_2713000 METAL6_207000_2713700 0.0014
R_VDD6_17084 METAL6_207000_2713700 METAL6_207000_2724000 0.0206
R_VDD6_17085 METAL6_207000_2724000 METAL6_207000_2725000 0.002
R_VDD6_17086 METAL6_207000_2725000 METAL6_207000_2725700 0.0014
R_VDD6_17087 METAL6_207000_2725700 METAL6_207000_2736000 0.0206
R_VDD6_17088 METAL6_207000_2736000 METAL6_207000_2737000 0.002
R_VDD6_17089 METAL6_207000_2737000 METAL6_207000_2737700 0.0014
R_VDD6_17090 METAL6_207000_2737700 METAL6_207000_2748000 0.0206
R_VDD6_17091 METAL6_207000_2748000 METAL6_207000_2777000 0.058
R_VDD6_17092 METAL6_207000_2777000 METAL6_207000_2789000 0.024
R_VDD6_17093 METAL6_207000_2789000 METAL6_207000_2801000 0.024
R_VDD6_17094 METAL6_207000_2801000 METAL6_207000_2801700 0.0014
R_VDD6_17095 METAL6_207000_2801700 METAL6_207000_2803000 0.0026
R_VDD6_17096 METAL6_207000_2803000 METAL6_207000_2808000 0.01
R_VDD6_17097 METAL6_207000_2808000 METAL6_207000_2813700 0.0114
R_VDD6_17098 METAL6_207000_2813700 METAL6_207000_2825700 0.024
R_VDD6_17099 METAL6_207000_2825700 METAL6_207000_2901700 0.152
R_VDD6_17100 METAL6_207000_2901700 METAL6_207000_2913000 0.0226
R_VDD6_17101 METAL6_207000_2913000 METAL6_207000_2913700 0.0014
R_VDD6_17102 METAL6_207000_2913700 METAL6_207000_2925000 0.0226
R_VDD6_17103 METAL6_207000_2925000 METAL6_207000_2925700 0.0014
R_VDD6_17104 METAL6_207000_2925700 METAL6_207000_2937000 0.0226
R_VDD6_17105 METAL6_207000_2937000 METAL6_207000_3001700 0.1294
R_VDD6_17106 METAL6_207000_3001700 METAL6_207000_3013700 0.024
R_VDD6_17107 METAL6_207000_3013700 METAL6_207000_3025700 0.024
R_VDD6_17108 METAL6_207000_3025700 METAL6_207000_3063000 0.0746
R_VDD6_17109 METAL6_207000_3063000 METAL6_207000_3073700 0.0214
R_VDD6_17110 METAL6_207000_3073700 METAL6_207000_3075000 0.0026
R_VDD6_17111 METAL6_195000_3075000 METAL6_207000_3075000 0.024
R_VDD6_17112 METAL6_195000_1975000 METAL6_207000_1975000 0.024
R_VDD6_17113 METAL6_219000_1926500 METAL6_207000_1926500 0.024
R_VDD6_17114 METAL6_207000_1926500 METAL6_207000_1938500 0.024
R_VDD6_17115 METAL6_207000_1938500 METAL6_207000_1939000 0.001
R_VDD6_17116 METAL6_207000_1939000 METAL6_207000_1940500 0.003
R_VDD6_17117 METAL6_207000_1940500 METAL6_207000_1950500 0.02
R_VDD6_17118 METAL6_207000_1950500 METAL6_207000_1951000 0.001
R_VDD6_17119 METAL6_207000_1951000 METAL6_207000_1952500 0.003
R_VDD6_17120 METAL6_207000_1952500 METAL6_207000_1962500 0.02
R_VDD6_17121 METAL6_207000_1962500 METAL6_207000_1963000 0.001
R_VDD6_17122 METAL6_207000_1963000 METAL6_207000_1964500 0.003
R_VDD6_17123 METAL6_207000_1964500 METAL6_207000_1975000 0.021
I_VDD6_60 METAL6_195000_3075000 gnd 0.003
I_VDD6_61 METAL6_195000_1975000 gnd 0.005

V_VDD7_24 METAL6_2000000_0 gnd 1
R_VDD7_17124 METAL6_2000000_0 METAL6_2000000_9500 0.019
R_VDD7_17125 METAL6_2000000_9500 METAL6_1988000_9500 0.024
R_VDD7_17126 METAL6_1988000_9500 METAL6_1963900_9500 0.0482
R_VDD7_17127 METAL6_1963900_9500 METAL6_1951900_9500 0.024
R_VDD7_17128 METAL6_1951900_9500 METAL6_1951900_16600 0.0142
R_VDD7_17129 METAL6_1951900_16600 METAL6_1951900_21500 0.0098
R_VDD7_17130 METAL6_1951900_21500 METAL6_1951900_28600 0.0142
R_VDD7_17131 METAL6_1951900_28600 METAL6_1951800_28600 0.0002
R_VDD7_17132 METAL6_1951800_28600 METAL6_1939900_28600 0.0238
R_VDD7_17133 METAL6_1939900_28600 METAL6_1939800_28600 0.0002
R_VDD7_17134 METAL6_1939800_28600 METAL6_1937600_28600 0.0044
R_VDD7_17135 METAL6_1937600_28600 METAL6_1931200_28600 0.0128
R_VDD7_17136 METAL6_1931200_28600 METAL6_1927800_28600 0.0068
R_VDD7_17137 METAL6_1927800_28600 METAL6_1926200_28600 0.0032
R_VDD7_17138 METAL6_1926200_28600 METAL6_1925600_28600 0.0012
R_VDD7_17139 METAL6_1925600_28600 METAL6_1919200_28600 0.0128
R_VDD7_17140 METAL6_1919200_28600 METAL6_1913600_28600 0.0112
R_VDD7_17141 METAL6_1913600_28600 METAL6_1907400_28600 0.0124
R_VDD7_17142 METAL6_1907400_28600 METAL6_1907200_28600 0.0004
R_VDD7_17143 METAL6_1907200_28600 METAL6_1901600_28600 0.0112
R_VDD7_17144 METAL6_1901600_28600 METAL6_1900700_28600 0.0018
R_VDD7_17145 METAL6_1900700_28600 METAL6_1895200_28600 0.011
R_VDD7_17146 METAL6_1895200_28600 METAL6_1889600_28600 0.0112
R_VDD7_17147 METAL6_1889600_28600 METAL6_1889400_28600 0.0004
R_VDD7_17148 METAL6_1889400_28600 METAL6_1888700_28600 0.0014
R_VDD7_17149 METAL6_1888700_28600 METAL6_1883200_28600 0.011
R_VDD7_17150 METAL6_1883200_28600 METAL6_1877600_28600 0.0112
R_VDD7_17151 METAL6_1877600_28600 METAL6_1877400_28600 0.0004
R_VDD7_17152 METAL6_1877400_28600 METAL6_1876700_28600 0.0014
R_VDD7_17153 METAL6_1876700_28600 METAL6_1874700_28600 0.004
R_VDD7_17154 METAL6_1874700_28600 METAL6_1871200_28600 0.007
R_VDD7_17155 METAL6_1871200_28600 METAL6_1870600_28600 0.0012
R_VDD7_17156 METAL6_1870600_28600 METAL6_1865600_28600 0.01
R_VDD7_17157 METAL6_1865600_28600 METAL6_1865400_28600 0.0004
R_VDD7_17158 METAL6_1865400_28600 METAL6_1864700_28600 0.0014
R_VDD7_17159 METAL6_1864700_28600 METAL6_1859200_28600 0.011
R_VDD7_17160 METAL6_1859200_28600 METAL6_1858600_28600 0.0012
R_VDD7_17161 METAL6_1858600_28600 METAL6_1858400_28600 0.0004
R_VDD7_17162 METAL6_1858400_28600 METAL6_1853400_28600 0.01
R_VDD7_17163 METAL6_1853400_28600 METAL6_1852700_28600 0.0014
R_VDD7_17164 METAL6_1852700_28600 METAL6_1847200_28600 0.011
R_VDD7_17165 METAL6_1847200_28600 METAL6_1846800_28600 0.0008
R_VDD7_17166 METAL6_1846800_28600 METAL6_1846600_28600 0.0004
R_VDD7_17167 METAL6_1846600_28600 METAL6_1846400_28600 0.0004
R_VDD7_17168 METAL6_1846400_28600 METAL6_1844800_28600 0.0032
R_VDD7_17169 METAL6_1844800_28600 METAL6_1841400_28600 0.0068
R_VDD7_17170 METAL6_1841400_28600 METAL6_1834600_28600 0.0136
R_VDD7_17171 METAL6_1834600_28600 METAL6_1834400_28600 0.0004
R_VDD7_17172 METAL6_1834400_28600 METAL6_1832800_28600 0.0032
R_VDD7_17173 METAL6_1832800_28600 METAL6_1822600_28600 0.0204
R_VDD7_17174 METAL6_1822600_28600 METAL6_1822400_28600 0.0004
R_VDD7_17175 METAL6_1822400_28600 METAL6_1820800_28600 0.0032
R_VDD7_17176 METAL6_1820800_28600 METAL6_1812000_28600 0.0176
R_VDD7_17177 METAL6_1812000_28600 METAL6_1810600_28600 0.0028
R_VDD7_17178 METAL6_1810600_28600 METAL6_1800000_28600 0.0212
R_VDD7_17179 METAL6_1800000_28600 METAL6_1788000_28600 0.024
R_VDD7_17180 METAL6_1788000_28600 METAL6_1775400_28600 0.0252
R_VDD7_17181 METAL6_1775400_28600 METAL6_1775400_33500 0.0098
R_VDD7_17182 METAL6_1775400_33500 METAL6_1775400_40600 0.0142
R_VDD7_17183 METAL6_1775400_40600 METAL6_1775400_52000 0.0228
R_VDD7_17184 METAL6_1775400_52000 METAL6_1775400_52600 0.0012
R_VDD7_17185 METAL6_1775400_52600 METAL6_1775400_64000 0.0228
R_VDD7_17186 METAL6_1775400_64000 METAL6_1775400_64600 0.0012
R_VDD7_17187 METAL6_1775400_64600 METAL6_1775400_71600 0.014
R_VDD7_17188 METAL6_1775400_71600 METAL6_1775400_76000 0.0088
R_VDD7_17189 METAL6_1775400_76000 METAL6_1775400_76600 0.0012
R_VDD7_17190 METAL6_1775400_76600 METAL6_1775400_83600 0.014
R_VDD7_17191 METAL6_1775400_83600 METAL6_1775400_88000 0.0088
R_VDD7_17192 METAL6_1775400_88000 METAL6_1775400_88600 0.0012
R_VDD7_17193 METAL6_1775400_88600 METAL6_1775400_95600 0.014
R_VDD7_17194 METAL6_1775400_95600 METAL6_1775400_100000 0.0088
R_VDD7_17195 METAL6_1775400_100000 METAL6_1775400_112000 0.024
R_VDD7_17196 METAL6_1775400_112000 METAL6_1775400_159600 0.0952
R_VDD7_17197 METAL6_1775400_159600 METAL6_1775400_166600 0.014
R_VDD7_17198 METAL6_1775400_166600 METAL6_1775400_176000 0.0188
R_VDD7_17199 METAL6_1775400_176000 METAL6_1775400_178600 0.0052
R_VDD7_17200 METAL6_1775400_178600 METAL6_1775400_188000 0.0188
R_VDD7_17201 METAL6_1775400_188000 METAL6_1775400_190600 0.0052
R_VDD7_17202 METAL6_1775400_190600 METAL6_1775400_200000 0.0188
R_VDD7_17203 METAL6_1775400_200000 METAL6_1775400_212000 0.024
R_VDD7_17204 METAL6_1775400_212000 METAL6_1775400_236300 0.0486
R_VDD7_17205 METAL6_1775400_236300 METAL6_1775400_248300 0.024
R_VDD7_17206 METAL6_1775400_248300 METAL6_1775400_251000 0.0054
R_VDD7_17207 METAL6_1775400_251000 METAL6_1775400_260300 0.0186
R_VDD7_17208 METAL6_1775400_260300 METAL6_1775400_263000 0.0054
R_VDD7_17209 METAL6_1775400_263000 METAL6_1775400_272300 0.0186
R_VDD7_17210 METAL6_1775400_272300 METAL6_1775400_275000 0.0054
R_VDD7_17211 METAL6_1775400_275000 METAL6_1775400_279300 0.0086
R_VDD7_17212 METAL6_1775400_279300 METAL6_1775400_287000 0.0154
R_VDD7_17213 METAL6_1775400_287000 METAL6_1775400_288000 0.002
R_VDD7_17214 METAL6_1775400_288000 METAL6_1775400_299000 0.022
R_VDD7_17215 METAL6_1775400_299000 METAL6_1775400_300000 0.002
R_VDD7_17216 METAL6_1775400_300000 METAL6_1775400_311000 0.022
R_VDD7_17217 METAL6_1775400_311000 METAL6_1775400_312000 0.002
R_VDD7_17218 METAL6_1775400_312000 METAL6_1775400_355300 0.0866
R_VDD7_17219 METAL6_1775400_355300 METAL6_1775400_362300 0.014
R_VDD7_17220 METAL6_1775400_362300 METAL6_1775400_366800 0.009
R_VDD7_17221 METAL6_1775400_366800 METAL6_1775400_374300 0.015
R_VDD7_17222 METAL6_1775400_374300 METAL6_1775400_378800 0.009
R_VDD7_17223 METAL6_1775400_378800 METAL6_1775400_386300 0.015
R_VDD7_17224 METAL6_1775400_386300 METAL6_1775400_388000 0.0034
R_VDD7_17225 METAL6_1775400_388000 METAL6_1775400_390800 0.0056
R_VDD7_17226 METAL6_1775400_390800 METAL6_1775400_400000 0.0184
R_VDD7_17227 METAL6_1775400_400000 METAL6_1775400_402800 0.0056
R_VDD7_17228 METAL6_1775400_402800 METAL6_1775400_412000 0.0184
R_VDD7_17229 METAL6_1775400_412000 METAL6_1775400_413000 0.002
R_VDD7_17230 METAL6_1775400_413000 METAL6_1775400_414800 0.0036
R_VDD7_17231 METAL6_1775400_414800 METAL6_1775400_425000 0.0204
R_VDD7_17232 METAL6_1775400_425000 METAL6_1775400_437000 0.024
R_VDD7_17233 METAL6_1775400_437000 METAL6_1775400_449000 0.024
R_VDD7_17234 METAL6_1775400_449000 METAL6_1775400_453000 0.008
R_VDD7_17235 METAL6_1775400_453000 METAL6_1775400_456400 0.0068
R_VDD7_17236 METAL6_1775400_456400 METAL6_1775400_459000 0.0052
R_VDD7_17237 METAL6_1775400_459000 METAL6_1775400_461000 0.004
R_VDD7_17238 METAL6_1775400_461000 METAL6_1775400_465000 0.008
R_VDD7_17239 METAL6_1775400_465000 METAL6_1775400_468400 0.0068
R_VDD7_17240 METAL6_1775400_468400 METAL6_1775400_471000 0.0052
R_VDD7_17241 METAL6_1775400_471000 METAL6_1775400_473000 0.004
R_VDD7_17242 METAL6_1775400_473000 METAL6_1775400_477000 0.008
R_VDD7_17243 METAL6_1775400_477000 METAL6_1775400_480400 0.0068
R_VDD7_17244 METAL6_1775400_480400 METAL6_1775400_483000 0.0052
R_VDD7_17245 METAL6_1775400_483000 METAL6_1775400_488000 0.01
R_VDD7_17246 METAL6_1775400_488000 METAL6_1775400_492400 0.0088
R_VDD7_17247 METAL6_1775400_492400 METAL6_1775400_495000 0.0052
R_VDD7_17248 METAL6_1775400_495000 METAL6_1775400_500000 0.01
R_VDD7_17249 METAL6_1775400_500000 METAL6_1775400_504000 0.008
R_VDD7_17250 METAL6_1775400_504000 METAL6_1775400_507000 0.006
R_VDD7_17251 METAL6_1775400_507000 METAL6_1775400_507800 0.0016
R_VDD7_17252 METAL6_1775400_507800 METAL6_1775400_512000 0.0084
R_VDD7_17253 METAL6_1775400_512000 METAL6_1775400_516000 0.008
R_VDD7_17254 METAL6_1775400_516000 METAL6_1775400_519000 0.006
R_VDD7_17255 METAL6_1775400_519000 METAL6_1775400_520200 0.0024
R_VDD7_17256 METAL6_1775400_520200 METAL6_1775400_528000 0.0156
R_VDD7_17257 METAL6_1775400_528000 METAL6_1775400_532200 0.0084
R_VDD7_17258 METAL6_1775400_532200 METAL6_1775400_535400 0.0064
R_VDD7_17259 METAL6_1775400_535400 METAL6_1775400_544200 0.0176
R_VDD7_17260 METAL6_1775400_544200 METAL6_1775400_547400 0.0064
R_VDD7_17261 METAL6_1775400_547400 METAL6_1775400_550400 0.006
R_VDD7_17262 METAL6_1775400_550400 METAL6_1775400_556200 0.0116
R_VDD7_17263 METAL6_1775400_556200 METAL6_1775400_559400 0.0064
R_VDD7_17264 METAL6_1775400_559400 METAL6_1775400_561000 0.0032
R_VDD7_17265 METAL6_1775400_561000 METAL6_1775400_562400 0.0028
R_VDD7_17266 METAL6_1775400_562400 METAL6_1775400_573000 0.0212
R_VDD7_17267 METAL6_1775400_573000 METAL6_1775400_574400 0.0028
R_VDD7_17268 METAL6_1775400_574400 METAL6_1775400_579800 0.0108
R_VDD7_17269 METAL6_1775400_579800 METAL6_1775400_585000 0.0104
R_VDD7_17270 METAL6_1775400_585000 METAL6_1775400_586400 0.0028
R_VDD7_17271 METAL6_1775400_586400 METAL6_1775400_588000 0.0032
R_VDD7_17272 METAL6_1775400_588000 METAL6_1775400_597000 0.018
R_VDD7_17273 METAL6_1775400_597000 METAL6_1775400_598400 0.0028
R_VDD7_17274 METAL6_1775400_598400 METAL6_1775400_600000 0.0032
R_VDD7_17275 METAL6_1775400_600000 METAL6_1775400_605400 0.0108
R_VDD7_17276 METAL6_1775400_605400 METAL6_1775400_612000 0.0132
R_VDD7_17277 METAL6_1775400_612000 METAL6_1775400_617400 0.0108
R_VDD7_17278 METAL6_1775400_617400 METAL6_1775400_629400 0.024
R_VDD7_17279 METAL6_1775400_629400 METAL6_1775400_637800 0.0168
R_VDD7_17280 METAL6_1775400_637800 METAL6_1775400_641400 0.0072
R_VDD7_17281 METAL6_1775400_641400 METAL6_1775400_649800 0.0168
R_VDD7_17282 METAL6_1775400_649800 METAL6_1775400_653400 0.0072
R_VDD7_17283 METAL6_1775400_653400 METAL6_1775400_661800 0.0168
R_VDD7_17284 METAL6_1775400_661800 METAL6_1775400_665400 0.0072
R_VDD7_17285 METAL6_1775400_665400 METAL6_1775400_688000 0.0452
R_VDD7_17286 METAL6_1775400_688000 METAL6_1775400_697800 0.0196
R_VDD7_17287 METAL6_1775400_697800 METAL6_1775400_700000 0.0044
R_VDD7_17288 METAL6_1775400_700000 METAL6_1775400_702800 0.0056
R_VDD7_17289 METAL6_1775400_702800 METAL6_1775400_709800 0.014
R_VDD7_17290 METAL6_1775400_709800 METAL6_1775400_712000 0.0044
R_VDD7_17291 METAL6_1775400_712000 METAL6_1775400_716800 0.0096
R_VDD7_17292 METAL6_1775400_716800 METAL6_1775400_721800 0.01
R_VDD7_17293 METAL6_1775400_721800 METAL6_1775400_733800 0.024
R_VDD7_17294 METAL6_1775400_733800 METAL6_1775400_734400 0.0012
R_VDD7_17295 METAL6_1775400_734400 METAL5_1775400_734400 0.1
R_VDD7_17296 METAL5_1775400_734400 METAL5_1775400_735400 0.004
R_VDD7_17297 METAL5_1775400_735400 METAL5_1775400_742400 0.028
R_VDD7_17298 METAL5_1775400_742400 METAL5_1775400_745800 0.0136
R_VDD7_17299 METAL5_1775400_745800 METAL5_1775400_746400 0.0024
R_VDD7_17300 METAL5_1775400_746400 METAL5_1775400_754400 0.032
R_VDD7_17301 METAL5_1775400_754400 METAL5_1775400_757800 0.0136
R_VDD7_17302 METAL5_1775400_757800 METAL5_1775400_758400 0.0024
R_VDD7_17303 METAL5_1775400_758400 METAL5_1775400_760000 0.0064
R_VDD7_17304 METAL5_1775400_760000 METAL5_1775400_763000 0.012
R_VDD7_17305 METAL5_1775400_763000 METAL5_1775400_766400 0.0136
R_VDD7_17306 METAL5_1775400_766400 METAL5_1775400_769800 0.0136
R_VDD7_17307 METAL5_1775400_769800 METAL5_1775400_770400 0.0024
R_VDD7_17308 METAL5_1775400_770400 METAL5_1775400_772000 0.0064
R_VDD7_17309 METAL5_1775400_772000 METAL5_1775400_778400 0.0256
R_VDD7_17310 METAL5_1775400_778400 METAL5_1775400_779200 0.0032
R_VDD7_17311 METAL5_1775400_779200 METAL5_1775400_782400 0.0128
R_VDD7_17312 METAL5_1775400_782400 METAL5_1775400_784000 0.0064
R_VDD7_17313 METAL5_1775400_784000 METAL5_1775400_784500 0.002
R_VDD7_17314 METAL5_1775400_784500 METAL5_1775400_788000 0.014
R_VDD7_17315 METAL5_1775400_788000 METAL5_1775400_790400 0.0096
R_VDD7_17316 METAL5_1775400_790400 METAL5_1775400_791200 0.0032
R_VDD7_17317 METAL5_1775400_791200 METAL5_1775400_794400 0.0128
R_VDD7_17318 METAL5_1775400_794400 METAL6_1775400_794400 0.1
R_VDD7_17319 METAL6_1775400_794400 METAL6_1767700_794400 0.0154
R_VDD7_17320 METAL6_1767700_794400 METAL6_1763800_794400 0.0078
R_VDD7_17321 METAL6_1763800_794400 METAL6_1763400_794400 0.0008
R_VDD7_17322 METAL6_1763400_794400 METAL6_1756000_794400 0.0148
R_VDD7_17323 METAL6_1756000_794400 METAL6_1756000_794800 0.0008
R_VDD7_17324 METAL6_1756000_794800 METAL6_1756000_800000 0.0104
R_VDD7_17325 METAL6_1756000_800000 METAL6_1756000_802400 0.0048
R_VDD7_17326 METAL6_1756000_802400 METAL6_1756000_803200 0.0016
R_VDD7_17327 METAL6_1756000_803200 METAL6_1756000_806400 0.0064
R_VDD7_17328 METAL6_1756000_806400 METAL6_1756000_808000 0.0032
R_VDD7_17329 METAL6_1756000_808000 METAL6_1756000_812000 0.008
R_VDD7_17330 METAL6_1756000_812000 METAL6_1756000_814400 0.0048
R_VDD7_17331 METAL6_1756000_814400 METAL6_1756000_818400 0.008
R_VDD7_17332 METAL6_1756000_818400 METAL6_1756000_820000 0.0032
R_VDD7_17333 METAL6_1756000_820000 METAL6_1756000_828700 0.0174
R_VDD7_17334 METAL6_1756000_828700 METAL6_1756000_830400 0.0034
R_VDD7_17335 METAL6_1756000_830400 METAL6_1756000_832000 0.0032
R_VDD7_17336 METAL6_1756000_832000 METAL6_1756000_839500 0.015
R_VDD7_17337 METAL6_1756000_839500 METAL6_1756000_840700 0.0024
R_VDD7_17338 METAL6_1756000_840700 METAL6_1756000_842400 0.0034
R_VDD7_17339 METAL6_1756000_842400 METAL6_1756000_851500 0.0182
R_VDD7_17340 METAL6_1756000_851500 METAL6_1756000_852700 0.0024
R_VDD7_17341 METAL6_1756000_852700 METAL6_1756000_854400 0.0034
R_VDD7_17342 METAL6_1756000_854400 METAL6_1756000_858200 0.0076
R_VDD7_17343 METAL6_1756000_858200 METAL6_1756000_863500 0.0106
R_VDD7_17344 METAL6_1756000_863500 METAL6_1756000_875000 0.023
R_VDD7_17345 METAL6_1756000_875000 METAL6_1756000_887000 0.024
R_VDD7_17346 METAL6_1756000_887000 METAL6_1756000_888000 0.002
R_VDD7_17347 METAL6_1756000_888000 METAL6_1756000_899000 0.022
R_VDD7_17348 METAL6_1756000_899000 METAL6_1756000_900000 0.002
R_VDD7_17349 METAL6_1756000_900000 METAL6_1756000_900400 0.0008
R_VDD7_17350 METAL6_1756000_900400 METAL6_1756000_911000 0.0212
R_VDD7_17351 METAL6_1756000_911000 METAL6_1756000_912000 0.002
R_VDD7_17352 METAL6_1756000_912000 METAL6_1756000_923000 0.022
R_VDD7_17353 METAL6_1756000_923000 METAL6_1756000_927300 0.0086
R_VDD7_17354 METAL6_1756000_927300 METAL6_1756000_935000 0.0154
R_VDD7_17355 METAL6_1756000_935000 METAL6_1756000_947000 0.024
R_VDD7_17356 METAL6_1756000_947000 METAL6_1756000_959000 0.024
R_VDD7_17357 METAL6_1756000_959000 METAL6_1756000_971000 0.024
R_VDD7_17358 METAL6_1756000_971000 METAL6_1756000_976000 0.01
R_VDD7_17359 METAL6_1756000_976000 METAL6_1756000_983000 0.014
R_VDD7_17360 METAL6_1756000_983000 METAL6_1756000_988000 0.01
R_VDD7_17361 METAL6_1756000_988000 METAL6_1756000_995000 0.014
R_VDD7_17362 METAL6_1756000_995000 METAL6_1756000_1000000 0.01
R_VDD7_17363 METAL6_1756000_1000000 METAL6_1756000_1007000 0.014
R_VDD7_17364 METAL6_1756000_1007000 METAL6_1756000_1012000 0.01
R_VDD7_17365 METAL6_1756000_1012000 METAL6_1756000_1014000 0.004
R_VDD7_17366 METAL6_1756000_1014000 METAL6_1756000_1019000 0.01
R_VDD7_17367 METAL6_1756000_1019000 METAL6_1756000_1023700 0.0094
R_VDD7_17368 METAL6_1756000_1023700 METAL6_1756000_1025400 0.0034
R_VDD7_17369 METAL6_1756000_1025400 METAL6_1756000_1026000 0.0012
R_VDD7_17370 METAL6_1756000_1026000 METAL6_1756000_1029800 0.0076
R_VDD7_17371 METAL6_1756000_1029800 METAL6_1756000_1031000 0.0024
R_VDD7_17372 METAL6_1756000_1031000 METAL6_1756000_1035700 0.0094
R_VDD7_17373 METAL6_1756000_1035700 METAL6_1756000_1037400 0.0034
R_VDD7_17374 METAL6_1756000_1037400 METAL6_1756000_1038000 0.0012
R_VDD7_17375 METAL6_1756000_1038000 METAL6_1756000_1041800 0.0076
R_VDD7_17376 METAL6_1756000_1041800 METAL6_1756000_1042700 0.0018
R_VDD7_17377 METAL6_1756000_1042700 METAL6_1756000_1043000 0.0006
R_VDD7_17378 METAL6_1756000_1043000 METAL6_1756000_1047700 0.0094
R_VDD7_17379 METAL6_1756000_1047700 METAL6_1756000_1049400 0.0034
R_VDD7_17380 METAL6_1756000_1049400 METAL6_1756000_1049800 0.0008
R_VDD7_17381 METAL6_1756000_1049800 METAL6_1756000_1053800 0.008
R_VDD7_17382 METAL6_1756000_1053800 METAL6_1756000_1054700 0.0018
R_VDD7_17383 METAL6_1756000_1054700 METAL6_1756000_1061400 0.0134
R_VDD7_17384 METAL6_1756000_1061400 METAL6_1756000_1061800 0.0008
R_VDD7_17385 METAL6_1756000_1061800 METAL6_1756000_1066700 0.0098
R_VDD7_17386 METAL6_1756000_1066700 METAL6_1756000_1073400 0.0134
R_VDD7_17387 METAL6_1756000_1073400 METAL6_1756000_1073800 0.0008
R_VDD7_17388 METAL6_1756000_1073800 METAL6_1755700_1073800 0.0006
R_VDD7_17389 METAL6_1755700_1073800 METAL6_1755700_1074000 0.0004
R_VDD7_17390 METAL6_1755700_1074000 METAL6_1755700_1074500 0.001
R_VDD7_17391 METAL6_1755700_1074500 METAL6_1755700_1085400 0.0218
R_VDD7_17392 METAL6_1755700_1085400 METAL6_1755700_1085800 0.0008
R_VDD7_17393 METAL6_1755700_1085800 METAL6_1755700_1086000 0.0004
R_VDD7_17394 METAL6_1755700_1086000 METAL6_1755700_1086300 0.0006
R_VDD7_17395 METAL6_1755700_1086300 METAL6_1755700_1086500 0.0004
R_VDD7_17396 METAL6_1755700_1086500 METAL6_1755700_1088000 0.003
R_VDD7_17397 METAL6_1755700_1088000 METAL6_1755700_1096800 0.0176
R_VDD7_17398 METAL6_1755700_1096800 METAL6_1755700_1097800 0.002
R_VDD7_17399 METAL6_1755700_1097800 METAL6_1755700_1098000 0.0004
R_VDD7_17400 METAL6_1755700_1098000 METAL6_1755700_1098300 0.0006
R_VDD7_17401 METAL6_1755700_1098300 METAL6_1755700_1098500 0.0004
R_VDD7_17402 METAL6_1755700_1098500 METAL6_1755700_1100000 0.003
R_VDD7_17403 METAL6_1755700_1100000 METAL6_1755700_1108800 0.0176
R_VDD7_17404 METAL6_1755700_1108800 METAL6_1755700_1110000 0.0024
R_VDD7_17405 METAL6_1755700_1110000 METAL6_1755700_1110300 0.0006
R_VDD7_17406 METAL6_1755700_1110300 METAL5_1755700_1110300 0.1
R_VDD7_17407 METAL5_1755700_1110300 METAL5_1755700_1110500 0.0008
R_VDD7_17408 METAL5_1755700_1110500 METAL5_1755700_1112000 0.006
R_VDD7_17409 METAL5_1755700_1112000 METAL5_1755700_1120800 0.0352
R_VDD7_17410 METAL5_1755700_1120800 METAL5_1755700_1122300 0.006
R_VDD7_17411 METAL5_1755700_1122300 METAL5_1755700_1122500 0.0008
R_VDD7_17412 METAL5_1755700_1122500 METAL5_1755700_1129300 0.0272
R_VDD7_17413 METAL5_1755700_1129300 METAL5_1755700_1132800 0.014
R_VDD7_17414 METAL5_1755700_1132800 METAL5_1755700_1134300 0.006
R_VDD7_17415 METAL5_1755700_1134300 METAL5_1755700_1134500 0.0008
R_VDD7_17416 METAL5_1755700_1134500 METAL5_1755700_1141300 0.0272
R_VDD7_17417 METAL5_1755700_1141300 METAL5_1755700_1146300 0.02
R_VDD7_17418 METAL5_1755700_1146300 METAL5_1755700_1153300 0.028
R_VDD7_17419 METAL5_1755700_1153300 METAL5_1755700_1157700 0.0176
R_VDD7_17420 METAL5_1755700_1157700 METAL5_1755700_1160600 0.0116
R_VDD7_17421 METAL5_1755700_1160600 METAL5_1755700_1169700 0.0364
R_VDD7_17422 METAL5_1755700_1169700 METAL5_1755700_1172600 0.0116
R_VDD7_17423 METAL5_1755700_1172600 METAL5_1755700_1181700 0.0364
R_VDD7_17424 METAL5_1755700_1181700 METAL5_1755700_1181800 0.0004
R_VDD7_17425 METAL5_1755700_1181800 METAL5_1755700_1184600 0.0112
R_VDD7_17426 METAL5_1755700_1184600 METAL5_1755700_1191600 0.028
R_VDD7_17427 METAL5_1755700_1191600 METAL5_1755700_1193700 0.0084
R_VDD7_17428 METAL5_1755700_1193700 METAL5_1755700_1193800 0.0004
R_VDD7_17429 METAL5_1755700_1193800 METAL5_1755700_1205700 0.0476
R_VDD7_17430 METAL5_1755700_1205700 METAL6_1755700_1205700 0.1
R_VDD7_17431 METAL6_1755700_1205700 METAL6_1753800_1205700 0.0038
R_VDD7_17432 METAL6_1753800_1205700 METAL6_1751800_1205700 0.004
R_VDD7_17433 METAL6_1751800_1205700 METAL6_1751400_1205700 0.0008
R_VDD7_17434 METAL6_1751400_1205700 METAL6_1744000_1205700 0.0148
R_VDD7_17435 METAL6_1744000_1205700 METAL6_1743700_1205700 0.0006
R_VDD7_17436 METAL6_1743700_1205700 METAL6_1741800_1205700 0.0038
R_VDD7_17437 METAL6_1741800_1205700 METAL6_1739800_1205700 0.004
R_VDD7_17438 METAL6_1739800_1205700 METAL6_1739400_1205700 0.0008
R_VDD7_17439 METAL6_1739400_1205700 METAL6_1732000_1205700 0.0148
R_VDD7_17440 METAL6_1732000_1205700 METAL6_1731700_1205700 0.0006
R_VDD7_17441 METAL6_1731700_1205700 METAL6_1729800_1205700 0.0038
R_VDD7_17442 METAL6_1729800_1205700 METAL6_1727800_1205700 0.004
R_VDD7_17443 METAL6_1727800_1205700 METAL6_1719700_1205700 0.0162
R_VDD7_17444 METAL6_1719700_1205700 METAL6_1717800_1205700 0.0038
R_VDD7_17445 METAL6_1717800_1205700 METAL6_1710800_1205700 0.014
R_VDD7_17446 METAL6_1710800_1205700 METAL6_1707700_1205700 0.0062
R_VDD7_17447 METAL6_1707700_1205700 METAL6_1699000_1205700 0.0174
R_VDD7_17448 METAL6_1699000_1205700 METAL6_1692000_1205700 0.014
R_VDD7_17449 METAL6_1692000_1205700 METAL6_1682800_1205700 0.0184
R_VDD7_17450 METAL6_1682800_1205700 METAL6_1680000_1205700 0.0056
R_VDD7_17451 METAL6_1680000_1205700 METAL6_1670800_1205700 0.0184
R_VDD7_17452 METAL6_1670800_1205700 METAL6_1668000_1205700 0.0056
R_VDD7_17453 METAL6_1668000_1205700 METAL6_1658800_1205700 0.0184
R_VDD7_17454 METAL6_1658800_1205700 METAL6_1646800_1205700 0.024
R_VDD7_17455 METAL6_1646800_1205700 METAL6_1636700_1205700 0.0202
R_VDD7_17456 METAL6_1636700_1205700 METAL6_1636000_1205700 0.0014
R_VDD7_17457 METAL6_1636000_1205700 METAL6_1634800_1205700 0.0024
R_VDD7_17458 METAL6_1634800_1205700 METAL6_1632800_1205700 0.004
R_VDD7_17459 METAL6_1632800_1205700 METAL6_1627800_1205700 0.01
R_VDD7_17460 METAL6_1627800_1205700 METAL6_1624700_1205700 0.0062
R_VDD7_17461 METAL6_1624700_1205700 METAL6_1624000_1205700 0.0014
R_VDD7_17462 METAL6_1624000_1205700 METAL6_1615800_1205700 0.0164
R_VDD7_17463 METAL6_1615800_1205700 METAL6_1612700_1205700 0.0062
R_VDD7_17464 METAL6_1612700_1205700 METAL6_1612000_1205700 0.0014
R_VDD7_17465 METAL6_1612000_1205700 METAL6_1607900_1205700 0.0082
R_VDD7_17466 METAL6_1607900_1205700 METAL6_1603800_1205700 0.0082
R_VDD7_17467 METAL6_1603800_1205700 METAL6_1600700_1205700 0.0062
R_VDD7_17468 METAL6_1600700_1205700 METAL6_1600000_1205700 0.0014
R_VDD7_17469 METAL6_1600000_1205700 METAL6_1591800_1205700 0.0164
R_VDD7_17470 METAL6_1591800_1205700 METAL6_1588700_1205700 0.0062
R_VDD7_17471 METAL6_1588700_1205700 METAL6_1588000_1205700 0.0014
R_VDD7_17472 METAL6_1588000_1205700 METAL6_1579800_1205700 0.0164
R_VDD7_17473 METAL6_1579800_1205700 METAL6_1576700_1205700 0.0062
R_VDD7_17474 METAL6_1576700_1205700 METAL6_1576000_1205700 0.0014
R_VDD7_17475 METAL6_1576000_1205700 METAL6_1574700_1205700 0.0026
R_VDD7_17476 METAL6_1574700_1205700 METAL6_1569000_1205700 0.0114
R_VDD7_17477 METAL6_1569000_1205700 METAL6_1567800_1205700 0.0024
R_VDD7_17478 METAL6_1567800_1205700 METAL6_1564000_1205700 0.0076
R_VDD7_17479 METAL6_1564000_1205700 METAL6_1557000_1205700 0.014
R_VDD7_17480 METAL6_1557000_1205700 METAL6_1555400_1205700 0.0032
R_VDD7_17481 METAL6_1555400_1205700 METAL6_1552000_1205700 0.0068
R_VDD7_17482 METAL6_1552000_1205700 METAL6_1551800_1205700 0.0004
R_VDD7_17483 METAL6_1551800_1205700 METAL6_1545000_1205700 0.0136
R_VDD7_17484 METAL6_1545000_1205700 METAL6_1540000_1205700 0.01
R_VDD7_17485 METAL6_1540000_1205700 METAL6_1539800_1205700 0.0004
R_VDD7_17486 METAL6_1539800_1205700 METAL6_1527800_1205700 0.024
R_VDD7_17487 METAL6_1527800_1205700 METAL6_1512000_1205700 0.0316
R_VDD7_17488 METAL6_1512000_1205700 METAL6_1510400_1205700 0.0032
R_VDD7_17489 METAL6_1510400_1205700 METAL6_1503400_1205700 0.014
R_VDD7_17490 METAL6_1503400_1205700 METAL6_1500000_1205700 0.0068
R_VDD7_17491 METAL6_1500000_1205700 METAL6_1498300_1205700 0.0034
R_VDD7_17492 METAL6_1498300_1205700 METAL6_1491400_1205700 0.0138
R_VDD7_17493 METAL6_1491400_1205700 METAL6_1488000_1205700 0.0068
R_VDD7_17494 METAL6_1488000_1205700 METAL6_1479400_1205700 0.0172
R_VDD7_17495 METAL6_1479400_1205700 METAL6_1444800_1205700 0.0692
R_VDD7_17496 METAL6_1444800_1205700 METAL6_1443700_1205700 0.0022
R_VDD7_17497 METAL6_1443700_1205700 METAL6_1432800_1205700 0.0218
R_VDD7_17498 METAL6_1432800_1205700 METAL6_1431700_1205700 0.0022
R_VDD7_17499 METAL6_1431700_1205700 METAL6_1424000_1205700 0.0154
R_VDD7_17500 METAL6_1424000_1205700 METAL6_1420800_1205700 0.0064
R_VDD7_17501 METAL6_1420800_1205700 METAL6_1419700_1205700 0.0022
R_VDD7_17502 METAL6_1419700_1205700 METAL6_1412000_1205700 0.0154
R_VDD7_17503 METAL6_1412000_1205700 METAL6_1408800_1205700 0.0064
R_VDD7_17504 METAL6_1408800_1205700 METAL6_1400000_1205700 0.0176
R_VDD7_17505 METAL6_1400000_1205700 METAL6_1396800_1205700 0.0064
R_VDD7_17506 METAL6_1396800_1205700 METAL6_1388000_1205700 0.0176
R_VDD7_17507 METAL6_1388000_1205700 METAL6_1349000_1205700 0.078
R_VDD7_17508 METAL6_1349000_1205700 METAL6_1348000_1205700 0.002
R_VDD7_17509 METAL6_1348000_1205700 METAL6_1337000_1205700 0.022
R_VDD7_17510 METAL6_1337000_1205700 METAL6_1336000_1205700 0.002
R_VDD7_17511 METAL6_1336000_1205700 METAL6_1325000_1205700 0.022
R_VDD7_17512 METAL6_1325000_1205700 METAL6_1324000_1205700 0.002
R_VDD7_17513 METAL6_1324000_1205700 METAL6_1323800_1205700 0.0004
R_VDD7_17514 METAL6_1323800_1205700 METAL6_1313000_1205700 0.0216
R_VDD7_17515 METAL6_1313000_1205700 METAL6_1312000_1205700 0.002
R_VDD7_17516 METAL6_1312000_1205700 METAL6_1312000_1205800 0.0002
R_VDD7_17517 METAL6_1312000_1205800 METAL6_1312000_1217700 0.0238
R_VDD7_17518 METAL6_1312000_1217700 METAL6_1312000_1223700 0.012
R_VDD7_17519 METAL6_1312000_1223700 METAL6_1312000_1229700 0.012
R_VDD7_17520 METAL6_1312000_1229700 METAL6_1312000_1235700 0.012
R_VDD7_17521 METAL6_1312000_1235700 METAL6_1312000_1238000 0.0046
R_VDD7_17522 METAL6_1312000_1238000 METAL6_1312000_1247700 0.0194
R_VDD7_17523 METAL6_1312000_1247700 METAL6_1312000_1250000 0.0046
R_VDD7_17524 METAL6_1312000_1250000 METAL6_1312000_1259700 0.0194
R_VDD7_17525 METAL6_1312000_1259700 METAL6_1312000_1261000 0.0026
R_VDD7_17526 METAL6_1312000_1261000 METAL6_1312000_1262000 0.002
R_VDD7_17527 METAL6_1312000_1262000 METAL6_1312000_1271700 0.0194
R_VDD7_17528 METAL6_1312000_1271700 METAL6_1312000_1273000 0.0026
R_VDD7_17529 METAL6_1312000_1273000 METAL6_1312000_1283700 0.0214
R_VDD7_17530 METAL6_1312000_1283700 METAL6_1312000_1285000 0.0026
R_VDD7_17531 METAL6_1312000_1285000 METAL6_1312000_1295700 0.0214
R_VDD7_17532 METAL6_1312000_1295700 METAL6_1312000_1297000 0.0026
R_VDD7_17533 METAL6_1312000_1297000 METAL6_1312000_1302000 0.01
R_VDD7_17534 METAL6_1312000_1302000 METAL6_1311800_1302000 0.0004
R_VDD7_17535 METAL6_1311800_1302000 METAL6_1301000_1302000 0.0216
R_VDD7_17536 METAL6_1301000_1302000 METAL6_1300000_1302000 0.002
R_VDD7_17537 METAL6_1300000_1302000 METAL6_1299800_1302000 0.0004
R_VDD7_17538 METAL6_1299800_1302000 METAL6_1289000_1302000 0.0216
R_VDD7_17539 METAL6_1289000_1302000 METAL6_1288000_1302000 0.002
R_VDD7_17540 METAL6_1288000_1302000 METAL6_1287800_1302000 0.0004
R_VDD7_17541 METAL6_1287800_1302000 METAL6_1286700_1302000 0.0022
R_VDD7_17542 METAL6_1286700_1302000 METAL6_1282300_1302000 0.0088
R_VDD7_17543 METAL6_1282300_1302000 METAL5_1282300_1302000 0.1
R_VDD7_17544 METAL5_1282300_1302000 METAL5_1276000_1302000 0.0252
R_VDD7_17545 METAL5_1276000_1302000 METAL5_1274700_1302000 0.0052
R_VDD7_17546 METAL5_1274700_1302000 METAL5_1270300_1302000 0.0176
R_VDD7_17547 METAL5_1270300_1302000 METAL5_1266800_1302000 0.014
R_VDD7_17548 METAL5_1266800_1302000 METAL5_1262700_1302000 0.0164
R_VDD7_17549 METAL5_1262700_1302000 METAL5_1259800_1302000 0.0116
R_VDD7_17550 METAL5_1259800_1302000 METAL5_1258300_1302000 0.006
R_VDD7_17551 METAL5_1258300_1302000 METAL5_1254700_1302000 0.0144
R_VDD7_17552 METAL5_1254700_1302000 METAL5_1253300_1302000 0.0056
R_VDD7_17553 METAL5_1253300_1302000 METAL5_1248000_1302000 0.0212
R_VDD7_17554 METAL5_1248000_1302000 METAL5_1247800_1302000 0.0008
R_VDD7_17555 METAL5_1247800_1302000 METAL5_1246300_1302000 0.006
R_VDD7_17556 METAL5_1246300_1302000 METAL5_1242700_1302000 0.0144
R_VDD7_17557 METAL5_1242700_1302000 METAL5_1236000_1302000 0.0268
R_VDD7_17558 METAL5_1236000_1302000 METAL5_1235800_1302000 0.0008
R_VDD7_17559 METAL5_1235800_1302000 METAL5_1234300_1302000 0.006
R_VDD7_17560 METAL5_1234300_1302000 METAL5_1230700_1302000 0.0144
R_VDD7_17561 METAL5_1230700_1302000 METAL5_1224000_1302000 0.0268
R_VDD7_17562 METAL5_1224000_1302000 METAL5_1223800_1302000 0.0008
R_VDD7_17563 METAL5_1223800_1302000 METAL5_1222300_1302000 0.006
R_VDD7_17564 METAL5_1222300_1302000 METAL5_1218700_1302000 0.0144
R_VDD7_17565 METAL5_1218700_1302000 METAL5_1216400_1302000 0.0092
R_VDD7_17566 METAL5_1216400_1302000 METAL5_1212000_1302000 0.0176
R_VDD7_17567 METAL5_1212000_1302000 METAL5_1211800_1302000 0.0008
R_VDD7_17568 METAL5_1211800_1302000 METAL5_1210300_1302000 0.006
R_VDD7_17569 METAL5_1210300_1302000 METAL5_1206700_1302000 0.0144
R_VDD7_17570 METAL5_1206700_1302000 METAL5_1204400_1302000 0.0092
R_VDD7_17571 METAL5_1204400_1302000 METAL5_1200000_1302000 0.0176
R_VDD7_17572 METAL5_1200000_1302000 METAL5_1199800_1302000 0.0008
R_VDD7_17573 METAL5_1199800_1302000 METAL5_1198300_1302000 0.006
R_VDD7_17574 METAL5_1198300_1302000 METAL5_1194700_1302000 0.0144
R_VDD7_17575 METAL5_1194700_1302000 METAL6_1194700_1302000 0.1
R_VDD7_17576 METAL6_1194700_1302000 METAL6_1194700_1307700 0.0114
R_VDD7_17577 METAL6_1194700_1307700 METAL6_1192400_1307700 0.0046
R_VDD7_17578 METAL6_1192400_1307700 METAL6_1188000_1307700 0.0088
R_VDD7_17579 METAL6_1188000_1307700 METAL6_1188000_1309000 0.0026
R_VDD7_17580 METAL6_1188000_1309000 METAL6_1188000_1314000 0.01
R_VDD7_17581 METAL6_1188000_1314000 METAL6_1187800_1314000 0.0004
R_VDD7_17582 METAL6_1187800_1314000 METAL6_1186300_1314000 0.003
R_VDD7_17583 METAL6_1186300_1314000 METAL6_1180400_1314000 0.0118
R_VDD7_17584 METAL6_1180400_1314000 METAL6_1174300_1314000 0.0122
R_VDD7_17585 METAL6_1174300_1314000 METAL6_1173700_1314000 0.0012
R_VDD7_17586 METAL6_1173700_1314000 METAL6_1166700_1314000 0.014
R_VDD7_17587 METAL6_1166700_1314000 METAL6_1162300_1314000 0.0088
R_VDD7_17588 METAL6_1162300_1314000 METAL6_1154700_1314000 0.0152
R_VDD7_17589 METAL6_1154700_1314000 METAL6_1150300_1314000 0.0088
R_VDD7_17590 METAL6_1150300_1314000 METAL6_1142700_1314000 0.0152
R_VDD7_17591 METAL6_1142700_1314000 METAL6_1137000_1314000 0.0114
R_VDD7_17592 METAL6_1137000_1314000 METAL6_1130700_1314000 0.0126
R_VDD7_17593 METAL6_1130700_1314000 METAL6_1125000_1314000 0.0114
R_VDD7_17594 METAL6_1125000_1314000 METAL6_1118700_1314000 0.0126
R_VDD7_17595 METAL6_1118700_1314000 METAL6_1113000_1314000 0.0114
R_VDD7_17596 METAL6_1113000_1314000 METAL6_1019000_1314000 0.188
R_VDD7_17597 METAL6_1019000_1314000 METAL6_1007000_1314000 0.024
R_VDD7_17598 METAL6_1007000_1314000 METAL6_995000_1314000 0.024
R_VDD7_17599 METAL6_995000_1314000 METAL6_988000_1314000 0.014
R_VDD7_17600 METAL6_988000_1314000 METAL6_964400_1314000 0.0472
R_VDD7_17601 METAL6_964400_1314000 METAL6_952400_1314000 0.024
R_VDD7_17602 METAL6_952400_1314000 METAL6_947400_1314000 0.01
R_VDD7_17603 METAL6_947400_1314000 METAL6_940400_1314000 0.014
R_VDD7_17604 METAL6_940400_1314000 METAL5_940400_1314000 0.1
R_VDD7_17605 METAL5_940400_1314000 METAL5_928400_1314000 0.048
R_VDD7_17606 METAL5_928400_1314000 METAL5_916400_1314000 0.048
R_VDD7_17607 METAL5_916400_1314000 METAL5_904400_1314000 0.048
R_VDD7_17608 METAL5_904400_1314000 METAL5_892400_1314000 0.048
R_VDD7_17609 METAL5_892400_1314000 METAL5_880400_1314000 0.048
R_VDD7_17610 METAL5_880400_1314000 METAL5_880400_1319700 0.0228
R_VDD7_17611 METAL5_880400_1319700 METAL5_880400_1326000 0.0252
R_VDD7_17612 METAL5_880400_1326000 METAL5_880400_1338000 0.048
R_VDD7_17613 METAL5_880400_1338000 METAL5_880400_1350000 0.048
R_VDD7_17614 METAL5_880400_1350000 METAL5_880400_1357000 0.028
R_VDD7_17615 METAL5_880400_1357000 METAL5_880400_1362000 0.02
R_VDD7_17616 METAL5_880400_1362000 METAL6_880400_1362000 0.1
R_VDD7_17617 METAL6_880400_1362000 METAL6_868400_1362000 0.024
R_VDD7_17618 METAL6_868400_1362000 METAL6_743000_1362000 0.2508
R_VDD7_17619 METAL6_743000_1362000 METAL6_731000_1362000 0.024
R_VDD7_17620 METAL6_731000_1362000 METAL6_724000_1362000 0.014
R_VDD7_17621 METAL6_724000_1362000 METAL6_724000_1369000 0.014
R_VDD7_17622 METAL6_724000_1369000 METAL6_724000_1374000 0.01
R_VDD7_17623 METAL6_724000_1374000 METAL6_724000_1381000 0.014
R_VDD7_17624 METAL6_724000_1381000 METAL6_724000_1386600 0.0112
R_VDD7_17625 METAL6_724000_1386600 METAL6_724000_1393000 0.0128
R_VDD7_17626 METAL6_724000_1393000 METAL6_724000_1405000 0.024
R_VDD7_17627 METAL6_724000_1405000 METAL6_724000_1417000 0.024
R_VDD7_17628 METAL6_724000_1417000 METAL6_724000_1437700 0.0414
R_VDD7_17629 METAL6_724000_1437700 METAL6_724000_1449700 0.024
R_VDD7_17630 METAL6_724000_1449700 METAL6_724000_1461700 0.024
R_VDD7_17631 METAL6_724000_1461700 METAL6_724000_1492300 0.0612
R_VDD7_17632 METAL6_724000_1492300 METAL6_724000_1504300 0.024
R_VDD7_17633 METAL6_724000_1504300 METAL6_724000_1516300 0.024
R_VDD7_17634 METAL6_724000_1516300 METAL6_724000_1528300 0.024
R_VDD7_17635 METAL6_724000_1528300 METAL6_724000_1540300 0.024
R_VDD7_17636 METAL6_724000_1540300 METAL6_724000_1552300 0.024
R_VDD7_17637 METAL6_724000_1552300 METAL6_719000_1552300 0.01
R_VDD7_17638 METAL6_719000_1552300 METAL6_712000_1552300 0.014
R_VDD7_17639 METAL6_712000_1552300 METAL6_707000_1552300 0.01
R_VDD7_17640 METAL6_707000_1552300 METAL6_700000_1552300 0.014
R_VDD7_17641 METAL6_700000_1552300 METAL6_695000_1552300 0.01
R_VDD7_17642 METAL6_695000_1552300 METAL6_688000_1552300 0.014
R_VDD7_17643 METAL6_688000_1552300 METAL6_676000_1552300 0.024
R_VDD7_17644 METAL6_676000_1552300 METAL6_581000_1552300 0.19
R_VDD7_17645 METAL6_581000_1552300 METAL6_581000_1554500 0.0044
R_VDD7_17646 METAL6_581000_1554500 METAL6_581000_1564300 0.0196
R_VDD7_17647 METAL6_581000_1564300 METAL6_581000_1571300 0.014
R_VDD7_17648 METAL6_581000_1571300 METAL6_581000_1576300 0.01
R_VDD7_17649 METAL6_581000_1576300 METAL6_581000_1714500 0.2764
R_VDD7_17650 METAL6_581000_1714500 METAL6_581000_1720500 0.012
R_VDD7_17651 METAL6_581000_1720500 METAL6_581000_1726500 0.012
R_VDD7_17652 METAL6_581000_1726500 METAL6_581000_1731700 0.0104
R_VDD7_17653 METAL6_581000_1731700 METAL6_581000_1738500 0.0136
R_VDD7_17654 METAL6_581000_1738500 METAL6_581000_1750500 0.024
R_VDD7_17655 METAL6_581000_1750500 METAL6_581000_1762500 0.024
R_VDD7_17656 METAL6_581000_1762500 METAL6_581000_1774500 0.024
R_VDD7_17657 METAL6_581000_1774500 METAL6_581000_1802500 0.056
R_VDD7_17658 METAL6_581000_1802500 METAL6_581000_1814500 0.024
R_VDD7_17659 METAL6_581000_1814500 METAL6_581000_1826500 0.024
R_VDD7_17660 METAL6_581000_1826500 METAL6_581000_1838500 0.024
R_VDD7_17661 METAL6_581000_1838500 METAL6_581000_1852300 0.0276
R_VDD7_17662 METAL6_581000_1852300 METAL6_581000_1866300 0.028
R_VDD7_17663 METAL6_581000_1866300 METAL6_581000_1902500 0.0724
R_VDD7_17664 METAL6_581000_1902500 METAL6_581000_1914500 0.024
R_VDD7_17665 METAL6_581000_1914500 METAL6_581000_1926500 0.024
R_VDD7_17666 METAL6_581000_1926500 METAL5_581000_1926500 0.1
R_VDD7_17667 METAL5_581000_1926500 METAL5_581000_1938500 0.048
R_VDD7_17668 METAL5_581000_1938500 METAL5_581000_1939000 0.002
R_VDD7_17669 METAL5_581000_1939000 METAL5_581000_1940500 0.006
R_VDD7_17670 METAL5_581000_1940500 METAL5_581000_1950500 0.04
R_VDD7_17671 METAL5_581000_1950500 METAL6_581000_1950500 0.1
R_VDD7_17672 METAL6_581000_1950500 METAL6_581000_1951000 0.001
R_VDD7_17673 METAL6_581000_1951000 METAL6_581000_1952500 0.003
R_VDD7_17674 METAL6_581000_1952500 METAL6_581000_1962500 0.02
R_VDD7_17675 METAL6_581000_1962500 METAL6_581000_1963000 0.001
R_VDD7_17676 METAL6_581000_1963000 METAL6_581000_1964500 0.003
R_VDD7_17677 METAL6_581000_1964500 METAL6_581000_1974500 0.02
R_VDD7_17678 METAL6_581000_1974500 METAL6_581000_1975000 0.001
R_VDD7_17679 METAL6_581000_1975000 METAL6_581000_1976500 0.003
R_VDD7_17680 METAL6_581000_1976500 METAL6_581000_1987000 0.021
R_VDD7_17681 METAL6_581000_1987000 METAL6_581000_1988500 0.003
R_VDD7_17682 METAL6_581000_1988500 METAL6_581000_1999000 0.021
R_VDD7_17683 METAL6_581000_1999000 METAL6_581000_2014500 0.031
R_VDD7_17684 METAL6_581000_2014500 METAL6_581000_2026500 0.024
R_VDD7_17685 METAL6_581000_2026500 METAL6_581000_2038500 0.024
R_VDD7_17686 METAL6_581000_2038500 METAL6_581000_2114500 0.152
R_VDD7_17687 METAL6_581000_2114500 METAL6_581000_2126500 0.024
R_VDD7_17688 METAL6_581000_2126500 METAL6_581000_2138500 0.024
R_VDD7_17689 METAL6_581000_2138500 METAL6_581000_2147300 0.0176
R_VDD7_17690 METAL6_581000_2147300 METAL6_581000_2150500 0.0064
R_VDD7_17691 METAL6_581000_2150500 METAL6_581000_2154300 0.0076
R_VDD7_17692 METAL6_581000_2154300 METAL6_581000_2163000 0.0174
R_VDD7_17693 METAL6_581000_2163000 METAL6_581000_2166300 0.0066
R_VDD7_17694 METAL6_581000_2166300 METAL6_581000_2175000 0.0174
R_VDD7_17695 METAL6_581000_2175000 METAL6_581000_2178300 0.0066
R_VDD7_17696 METAL6_581000_2178300 METAL6_581000_2187000 0.0174
R_VDD7_17697 METAL6_581000_2187000 METAL6_581000_2190300 0.0066
R_VDD7_17698 METAL6_581000_2190300 METAL6_581000_2199000 0.0174
R_VDD7_17699 METAL6_581000_2199000 METAL6_581000_2202300 0.0066
R_VDD7_17700 METAL6_581000_2202300 METAL6_581000_2211000 0.0174
R_VDD7_17701 METAL6_581000_2211000 METAL6_581000_2222500 0.023
R_VDD7_17702 METAL6_581000_2222500 METAL6_581000_2234500 0.024
R_VDD7_17703 METAL6_581000_2234500 METAL6_581000_2246500 0.024
R_VDD7_17704 METAL6_581000_2246500 METAL6_581000_2256500 0.02
R_VDD7_17705 METAL6_581000_2256500 METAL6_581000_2258500 0.004
R_VDD7_17706 METAL6_581000_2258500 METAL6_581000_2268500 0.02
R_VDD7_17707 METAL6_581000_2268500 METAL6_581000_2270500 0.004
R_VDD7_17708 METAL6_581000_2270500 METAL6_569000_2270500 0.024
R_VDD7_17709 METAL6_569000_2270500 METAL6_569000_2276000 0.011
R_VDD7_17710 METAL6_569000_2276000 METAL6_569000_2280500 0.009
R_VDD7_17711 METAL6_569000_2280500 METAL6_569000_2288000 0.015
R_VDD7_17712 METAL6_569000_2288000 METAL6_569000_2292000 0.008
R_VDD7_17713 METAL6_569000_2292000 METAL6_569000_2300000 0.016
R_VDD7_17714 METAL6_569000_2300000 METAL6_569000_2304000 0.008
R_VDD7_17715 METAL6_569000_2304000 METAL6_569000_2305000 0.002
R_VDD7_17716 METAL6_569000_2305000 METAL6_569000_2312000 0.014
R_VDD7_17717 METAL6_569000_2312000 METAL6_569000_2314000 0.004
R_VDD7_17718 METAL6_569000_2314000 METAL6_569000_2316000 0.004
R_VDD7_17719 METAL6_569000_2316000 METAL6_569000_2317000 0.002
R_VDD7_17720 METAL6_569000_2317000 METAL6_569000_2324000 0.014
R_VDD7_17721 METAL6_569000_2324000 METAL6_569000_2326000 0.004
R_VDD7_17722 METAL6_569000_2326000 METAL6_569000_2328000 0.004
R_VDD7_17723 METAL6_569000_2328000 METAL6_569000_2329000 0.002
R_VDD7_17724 METAL6_569000_2329000 METAL6_569000_2336000 0.014
R_VDD7_17725 METAL6_569000_2336000 METAL6_569000_2338000 0.004
R_VDD7_17726 METAL6_569000_2338000 METAL6_569000_2340000 0.004
R_VDD7_17727 METAL6_569000_2340000 METAL6_569000_2341000 0.002
R_VDD7_17728 METAL6_569000_2341000 METAL6_569000_2350000 0.018
R_VDD7_17729 METAL6_569000_2350000 METAL6_569000_2352000 0.004
R_VDD7_17730 METAL6_569000_2352000 METAL6_569000_2353000 0.002
R_VDD7_17731 METAL6_569000_2353000 METAL6_569000_2362000 0.018
R_VDD7_17732 METAL6_569000_2362000 METAL6_569000_2364000 0.004
R_VDD7_17733 METAL6_569000_2364000 METAL6_569000_2365000 0.002
R_VDD7_17734 METAL6_569000_2365000 METAL6_569000_2374000 0.018
R_VDD7_17735 METAL6_569000_2374000 METAL6_569000_2376000 0.004
R_VDD7_17736 METAL6_569000_2376000 METAL6_569000_2377000 0.002
R_VDD7_17737 METAL6_569000_2377000 METAL6_569000_2388000 0.022
R_VDD7_17738 METAL6_569000_2388000 METAL6_569000_2389000 0.002
R_VDD7_17739 METAL6_569000_2389000 METAL6_569000_2395000 0.012
R_VDD7_17740 METAL6_569000_2395000 METAL6_569000_2400000 0.01
R_VDD7_17741 METAL6_569000_2400000 METAL6_569000_2401000 0.002
R_VDD7_17742 METAL6_569000_2401000 METAL6_569000_2407000 0.012
R_VDD7_17743 METAL6_569000_2407000 METAL6_569000_2412000 0.01
R_VDD7_17744 METAL6_569000_2412000 METAL6_569000_2413000 0.002
R_VDD7_17745 METAL6_569000_2413000 METAL6_569000_2419000 0.012
R_VDD7_17746 METAL6_569000_2419000 METAL6_569000_2424000 0.01
R_VDD7_17747 METAL6_569000_2424000 METAL6_569000_2436000 0.024
R_VDD7_17748 METAL6_569000_2436000 METAL6_569000_2438000 0.004
R_VDD7_17749 METAL6_569000_2438000 METAL6_569000_2444000 0.012
R_VDD7_17750 METAL6_569000_2444000 METAL6_569000_2448000 0.008
R_VDD7_17751 METAL6_569000_2448000 METAL6_569000_2450000 0.004
R_VDD7_17752 METAL6_569000_2450000 METAL6_569000_2456000 0.012
R_VDD7_17753 METAL6_569000_2456000 METAL6_569000_2462000 0.012
R_VDD7_17754 METAL6_569000_2462000 METAL6_569000_2468000 0.012
R_VDD7_17755 METAL6_569000_2468000 METAL6_569000_2469000 0.002
R_VDD7_17756 METAL6_569000_2469000 METAL6_569000_2481000 0.024
R_VDD7_17757 METAL6_569000_2481000 METAL6_569000_2493000 0.024
R_VDD7_17758 METAL6_569000_2493000 METAL6_569000_2505000 0.024
R_VDD7_17759 METAL6_569000_2505000 METAL6_569000_2512000 0.014
R_VDD7_17760 METAL6_569000_2512000 METAL6_569000_2517700 0.0114
R_VDD7_17761 METAL6_569000_2517700 METAL6_569000_2524000 0.0126
R_VDD7_17762 METAL6_569000_2524000 METAL6_569000_2529700 0.0114
R_VDD7_17763 METAL6_569000_2529700 METAL6_569000_2536000 0.0126
R_VDD7_17764 METAL6_569000_2536000 METAL6_569000_2541700 0.0114
R_VDD7_17765 METAL6_569000_2541700 METAL6_569000_2548000 0.0126
R_VDD7_17766 METAL6_569000_2548000 METAL6_569000_2553700 0.0114
R_VDD7_17767 METAL6_569000_2553700 METAL6_569000_2589000 0.0706
R_VDD7_17768 METAL6_569000_2589000 METAL6_569000_2603000 0.028
R_VDD7_17769 METAL6_569000_2603000 METAL6_569000_2644000 0.082
R_VDD7_17770 METAL6_569000_2644000 METAL6_569000_2656000 0.024
R_VDD7_17771 METAL6_569000_2656000 METAL6_569000_2665700 0.0194
R_VDD7_17772 METAL6_569000_2665700 METAL6_569000_2668000 0.0046
R_VDD7_17773 METAL6_569000_2668000 METAL6_569000_2701000 0.066
R_VDD7_17774 METAL6_569000_2701000 METAL6_569000_2701700 0.0014
R_VDD7_17775 METAL6_569000_2701700 METAL6_569000_2713000 0.0226
R_VDD7_17776 METAL6_569000_2713000 METAL6_569000_2713700 0.0014
R_VDD7_17777 METAL6_569000_2713700 METAL6_569000_2724000 0.0206
R_VDD7_17778 METAL6_569000_2724000 METAL6_569000_2725000 0.002
R_VDD7_17779 METAL6_569000_2725000 METAL6_569000_2725700 0.0014
R_VDD7_17780 METAL6_569000_2725700 METAL6_569000_2736000 0.0206
R_VDD7_17781 METAL6_569000_2736000 METAL6_569000_2737000 0.002
R_VDD7_17782 METAL6_569000_2737000 METAL6_557000_2737000 0.024
R_VDD7_17783 METAL6_557000_2737000 METAL6_557000_2737700 0.0014
R_VDD7_17784 METAL6_557000_2737700 METAL6_557000_2748000 0.0206
R_VDD7_17785 METAL6_557000_2748000 METAL6_557000_2749700 0.0034
R_VDD7_17786 METAL6_557000_2749700 METAL6_557000_2777000 0.0546
R_VDD7_17787 METAL6_557000_2777000 METAL6_557000_2789000 0.024
R_VDD7_17788 METAL6_557000_2789000 METAL6_557000_2801000 0.024
R_VDD7_17789 METAL6_557000_2801000 METAL6_557000_2801700 0.0014
R_VDD7_17790 METAL6_557000_2801700 METAL6_557000_2803000 0.0026
R_VDD7_17791 METAL6_557000_2803000 METAL6_557000_2808000 0.01
R_VDD7_17792 METAL6_557000_2808000 METAL6_557000_2813700 0.0114
R_VDD7_17793 METAL6_557000_2813700 METAL6_557000_2825700 0.024
R_VDD7_17794 METAL6_557000_2825700 METAL6_557000_2901700 0.152
R_VDD7_17795 METAL6_557000_2901700 METAL6_557000_2913000 0.0226
R_VDD7_17796 METAL6_557000_2913000 METAL6_557000_2913700 0.0014
R_VDD7_17797 METAL6_557000_2913700 METAL6_557000_2925000 0.0226
R_VDD7_17798 METAL6_545000_2925000 METAL6_557000_2925000 0.024
R_VDD7_17799 METAL6_545000_1975000 METAL6_557000_1975000 0.024
R_VDD7_17800 METAL6_581000_1866300 METAL6_569000_1866300 0.024
R_VDD7_17801 METAL6_569000_1866300 METAL6_569000_1902500 0.0724
R_VDD7_17802 METAL6_569000_1902500 METAL6_557000_1902500 0.024
R_VDD7_17803 METAL6_557000_1902500 METAL6_557000_1914500 0.024
R_VDD7_17804 METAL6_557000_1914500 METAL6_557000_1926500 0.024
R_VDD7_17805 METAL6_557000_1926500 METAL6_557000_1938500 0.024
R_VDD7_17806 METAL6_557000_1938500 METAL6_557000_1939000 0.001
R_VDD7_17807 METAL6_557000_1939000 METAL6_557000_1940500 0.003
R_VDD7_17808 METAL6_557000_1940500 METAL6_557000_1950500 0.02
R_VDD7_17809 METAL6_557000_1950500 METAL6_557000_1951000 0.001
R_VDD7_17810 METAL6_557000_1951000 METAL6_557000_1952500 0.003
R_VDD7_17811 METAL6_557000_1952500 METAL6_557000_1962500 0.02
R_VDD7_17812 METAL6_557000_1962500 METAL6_557000_1963000 0.001
R_VDD7_17813 METAL6_557000_1963000 METAL6_557000_1964500 0.003
R_VDD7_17814 METAL6_557000_1964500 METAL6_557000_1974500 0.02
R_VDD7_17815 METAL6_557000_1974500 METAL6_557000_1975000 0.001
I_VDD7_62 METAL6_545000_2925000 gnd 0.001
I_VDD7_63 METAL6_545000_1975000 gnd 0.002

V_VDD8_25 METAL6_2500000_0 gnd 1.05
R_VDD8_17816 METAL6_2500000_0 METAL6_2500000_9500 0.019
R_VDD8_17817 METAL6_2500000_9500 METAL6_2500000_21500 0.024
R_VDD8_17818 METAL6_2500000_21500 METAL6_2500000_28600 0.0142
R_VDD8_17819 METAL6_2500000_28600 METAL6_2498900_28600 0.0022
R_VDD8_17820 METAL6_2498900_28600 METAL6_2496600_28600 0.0046
R_VDD8_17821 METAL6_2496600_28600 METAL6_2493000_28600 0.0072
R_VDD8_17822 METAL6_2493000_28600 METAL6_2492400_28600 0.0012
R_VDD8_17823 METAL6_2492400_28600 METAL6_2489600_28600 0.0056
R_VDD8_17824 METAL6_2489600_28600 METAL6_2488000_28600 0.0032
R_VDD8_17825 METAL6_2488000_28600 METAL6_2486900_28600 0.0022
R_VDD8_17826 METAL6_2486900_28600 METAL6_2484600_28600 0.0046
R_VDD8_17827 METAL6_2484600_28600 METAL6_2481000_28600 0.0072
R_VDD8_17828 METAL6_2481000_28600 METAL6_2480400_28600 0.0012
R_VDD8_17829 METAL6_2480400_28600 METAL6_2477600_28600 0.0056
R_VDD8_17830 METAL6_2477600_28600 METAL6_2476000_28600 0.0032
R_VDD8_17831 METAL6_2476000_28600 METAL6_2472600_28600 0.0068
R_VDD8_17832 METAL6_2472600_28600 METAL6_2470600_28600 0.004
R_VDD8_17833 METAL6_2470600_28600 METAL6_2469000_28600 0.0032
R_VDD8_17834 METAL6_2469000_28600 METAL6_2468400_28600 0.0012
R_VDD8_17835 METAL6_2468400_28600 METAL6_2465600_28600 0.0056
R_VDD8_17836 METAL6_2465600_28600 METAL6_2464000_28600 0.0032
R_VDD8_17837 METAL6_2464000_28600 METAL6_2460600_28600 0.0068
R_VDD8_17838 METAL6_2460600_28600 METAL6_2458600_28600 0.004
R_VDD8_17839 METAL6_2458600_28600 METAL6_2457000_28600 0.0032
R_VDD8_17840 METAL6_2457000_28600 METAL6_2448600_28600 0.0168
R_VDD8_17841 METAL6_2448600_28600 METAL6_2446600_28600 0.004
R_VDD8_17842 METAL6_2446600_28600 METAL6_2436600_28600 0.02
R_VDD8_17843 METAL6_2436600_28600 METAL6_2434600_28600 0.004
R_VDD8_17844 METAL6_2434600_28600 METAL6_2424600_28600 0.02
R_VDD8_17845 METAL6_2424600_28600 METAL6_2422600_28600 0.004
R_VDD8_17846 METAL6_2422600_28600 METAL6_2419100_28600 0.007
R_VDD8_17847 METAL6_2419100_28600 METAL6_2407100_28600 0.024
R_VDD8_17848 METAL6_2407100_28600 METAL6_2405600_28600 0.003
R_VDD8_17849 METAL6_2405600_28600 METAL6_2402100_28600 0.007
R_VDD8_17850 METAL6_2402100_28600 METAL6_2395100_28600 0.014
R_VDD8_17851 METAL6_2395100_28600 METAL6_2393600_28600 0.003
R_VDD8_17852 METAL6_2393600_28600 METAL6_2383100_28600 0.021
R_VDD8_17853 METAL6_2383100_28600 METAL6_2381600_28600 0.003
R_VDD8_17854 METAL6_2381600_28600 METAL6_2371100_28600 0.021
R_VDD8_17855 METAL6_2371100_28600 METAL6_2369600_28600 0.003
R_VDD8_17856 METAL6_2369600_28600 METAL6_2365900_28600 0.0074
R_VDD8_17857 METAL6_2365900_28600 METAL6_2357600_28600 0.0166
R_VDD8_17858 METAL6_2357600_28600 METAL6_2351900_28600 0.0114
R_VDD8_17859 METAL6_2351900_28600 METAL6_2343700_28600 0.0164
R_VDD8_17860 METAL6_2343700_28600 METAL6_2320600_28600 0.0462
R_VDD8_17861 METAL6_2320600_28600 METAL6_2310900_28600 0.0194
R_VDD8_17862 METAL6_2310900_28600 METAL6_2310900_33500 0.0098
R_VDD8_17863 METAL6_2310900_33500 METAL6_2310900_40600 0.0142
R_VDD8_17864 METAL6_2310900_40600 METAL6_2308600_40600 0.0046
R_VDD8_17865 METAL6_2308600_40600 METAL6_2298900_40600 0.0194
R_VDD8_17866 METAL6_2298900_40600 METAL6_2296600_40600 0.0046
R_VDD8_17867 METAL6_2296600_40600 METAL6_2286900_40600 0.0194
R_VDD8_17868 METAL6_2286900_40600 METAL6_2284600_40600 0.0046
R_VDD8_17869 METAL6_2284600_40600 METAL6_2284400_40600 0.0004
R_VDD8_17870 METAL6_2284400_40600 METAL6_2274900_40600 0.019
R_VDD8_17871 METAL6_2274900_40600 METAL6_2272600_40600 0.0046
R_VDD8_17872 METAL6_2272600_40600 METAL6_2272400_40600 0.0004
R_VDD8_17873 METAL6_2272400_40600 METAL6_2260600_40600 0.0236
R_VDD8_17874 METAL6_2260600_40600 METAL6_2260400_40600 0.0004
R_VDD8_17875 METAL6_2260400_40600 METAL6_2258600_40600 0.0036
R_VDD8_17876 METAL6_2258600_40600 METAL6_2248700_40600 0.0198
R_VDD8_17877 METAL6_2248700_40600 METAL6_2248600_40600 0.0002
R_VDD8_17878 METAL6_2248600_40600 METAL6_2248400_40600 0.0004
R_VDD8_17879 METAL6_2248400_40600 METAL6_2246600_40600 0.0036
R_VDD8_17880 METAL6_2246600_40600 METAL6_2236700_40600 0.0198
R_VDD8_17881 METAL6_2236700_40600 METAL6_2236600_40600 0.0002
R_VDD8_17882 METAL6_2236600_40600 METAL6_2234600_40600 0.004
R_VDD8_17883 METAL6_2234600_40600 METAL6_2233900_40600 0.0014
R_VDD8_17884 METAL6_2233900_40600 METAL6_2224700_40600 0.0184
R_VDD8_17885 METAL6_2224700_40600 METAL6_2224600_40600 0.0002
R_VDD8_17886 METAL6_2224600_40600 METAL6_2222600_40600 0.004
R_VDD8_17887 METAL6_2222600_40600 METAL6_2221900_40600 0.0014
R_VDD8_17888 METAL6_2221900_40600 METAL6_2212700_40600 0.0184
R_VDD8_17889 METAL6_2212700_40600 METAL6_2210600_40600 0.0042
R_VDD8_17890 METAL6_2210600_40600 METAL6_2209900_40600 0.0014
R_VDD8_17891 METAL6_2209900_40600 METAL6_2200700_40600 0.0184
R_VDD8_17892 METAL6_2200700_40600 METAL6_2189900_40600 0.0216
R_VDD8_17893 METAL6_2189900_40600 METAL6_2188700_40600 0.0024
R_VDD8_17894 METAL6_2188700_40600 METAL6_2177900_40600 0.0216
R_VDD8_17895 METAL6_2177900_40600 METAL6_2176700_40600 0.0024
R_VDD8_17896 METAL6_2176700_40600 METAL6_2165900_40600 0.0216
R_VDD8_17897 METAL6_2165900_40600 METAL6_2165400_40600 0.001
R_VDD8_17898 METAL6_2165400_40600 METAL6_2153900_40600 0.023
R_VDD8_17899 METAL6_2153900_40600 METAL6_2153400_40600 0.001
R_VDD8_17900 METAL6_2153400_40600 METAL6_2151900_40600 0.003
R_VDD8_17901 METAL6_2151900_40600 METAL6_2141900_40600 0.02
R_VDD8_17902 METAL6_2141900_40600 METAL6_2141400_40600 0.001
R_VDD8_17903 METAL6_2141400_40600 METAL6_2129900_40600 0.023
R_VDD8_17904 METAL6_2129900_40600 METAL6_2129700_40600 0.0004
R_VDD8_17905 METAL6_2129700_40600 METAL6_2125600_40600 0.0082
R_VDD8_17906 METAL6_2125600_40600 METAL6_2121400_40600 0.0084
R_VDD8_17907 METAL6_2121400_40600 METAL6_2117900_40600 0.007
R_VDD8_17908 METAL6_2117900_40600 METAL6_2113900_40600 0.008
R_VDD8_17909 METAL6_2113900_40600 METAL6_2113600_40600 0.0006
R_VDD8_17910 METAL6_2113600_40600 METAL6_2105900_40600 0.0154
R_VDD8_17911 METAL6_2105900_40600 METAL6_2101900_40600 0.008
R_VDD8_17912 METAL6_2101900_40600 METAL6_2101600_40600 0.0006
R_VDD8_17913 METAL6_2101600_40600 METAL6_2089900_40600 0.0234
R_VDD8_17914 METAL6_2089900_40600 METAL6_2079700_40600 0.0204
R_VDD8_17915 METAL6_2079700_40600 METAL6_2077900_40600 0.0036
R_VDD8_17916 METAL6_2077900_40600 METAL6_2067700_40600 0.0204
R_VDD8_17917 METAL6_2067700_40600 METAL6_2060600_40600 0.0142
R_VDD8_17918 METAL6_2060600_40600 METAL6_2058800_40600 0.0036
R_VDD8_17919 METAL6_2058800_40600 METAL6_2055700_40600 0.0062
R_VDD8_17920 METAL6_2055700_40600 METAL6_2046800_40600 0.0178
R_VDD8_17921 METAL6_2046800_40600 METAL6_2046600_40600 0.0004
R_VDD8_17922 METAL6_2046600_40600 METAL6_2046400_40600 0.0004
R_VDD8_17923 METAL6_2046400_40600 METAL6_2043700_40600 0.0054
R_VDD8_17924 METAL6_2043700_40600 METAL6_2034800_40600 0.0178
R_VDD8_17925 METAL6_2034800_40600 METAL6_2031700_40600 0.0062
R_VDD8_17926 METAL6_2031700_40600 METAL6_2030900_40600 0.0016
R_VDD8_17927 METAL6_2030900_40600 METAL6_2026400_40600 0.009
R_VDD8_17928 METAL6_2026400_40600 METAL6_2021200_40600 0.0104
R_VDD8_17929 METAL6_2021200_40600 METAL6_2019700_40600 0.003
R_VDD8_17930 METAL6_2019700_40600 METAL6_2018900_40600 0.0016
R_VDD8_17931 METAL6_2018900_40600 METAL6_2014400_40600 0.009
R_VDD8_17932 METAL6_2014400_40600 METAL6_2012000_40600 0.0048
R_VDD8_17933 METAL6_2012000_40600 METAL6_2007700_40600 0.0086
R_VDD8_17934 METAL6_2007700_40600 METAL6_2006900_40600 0.0016
R_VDD8_17935 METAL6_2006900_40600 METAL6_2002400_40600 0.009
R_VDD8_17936 METAL6_2002400_40600 METAL6_2000000_40600 0.0048
R_VDD8_17937 METAL6_2000000_40600 METAL6_1988000_40600 0.024
R_VDD8_17938 METAL6_1988000_40600 METAL6_1963900_40600 0.0482
R_VDD8_17939 METAL6_1963900_40600 METAL6_1951900_40600 0.024
R_VDD8_17940 METAL6_1951900_40600 METAL6_1951800_40600 0.0002
R_VDD8_17941 METAL6_1951800_40600 METAL6_1939900_40600 0.0238
R_VDD8_17942 METAL6_1939900_40600 METAL6_1939800_40600 0.0002
R_VDD8_17943 METAL6_1939800_40600 METAL6_1937600_40600 0.0044
R_VDD8_17944 METAL6_1937600_40600 METAL6_1931200_40600 0.0128
R_VDD8_17945 METAL6_1931200_40600 METAL6_1927800_40600 0.0068
R_VDD8_17946 METAL6_1927800_40600 METAL6_1926200_40600 0.0032
R_VDD8_17947 METAL6_1926200_40600 METAL6_1925600_40600 0.0012
R_VDD8_17948 METAL6_1925600_40600 METAL6_1919200_40600 0.0128
R_VDD8_17949 METAL6_1919200_40600 METAL6_1913600_40600 0.0112
R_VDD8_17950 METAL6_1913600_40600 METAL6_1907400_40600 0.0124
R_VDD8_17951 METAL6_1907400_40600 METAL6_1907200_40600 0.0004
R_VDD8_17952 METAL6_1907200_40600 METAL6_1901600_40600 0.0112
R_VDD8_17953 METAL6_1901600_40600 METAL6_1900700_40600 0.0018
R_VDD8_17954 METAL6_1900700_40600 METAL6_1895200_40600 0.011
R_VDD8_17955 METAL6_1895200_40600 METAL6_1889600_40600 0.0112
R_VDD8_17956 METAL6_1889600_40600 METAL6_1889400_40600 0.0004
R_VDD8_17957 METAL6_1889400_40600 METAL6_1888700_40600 0.0014
R_VDD8_17958 METAL6_1888700_40600 METAL6_1883200_40600 0.011
R_VDD8_17959 METAL6_1883200_40600 METAL6_1877600_40600 0.0112
R_VDD8_17960 METAL6_1877600_40600 METAL6_1877400_40600 0.0004
R_VDD8_17961 METAL6_1877400_40600 METAL6_1876700_40600 0.0014
R_VDD8_17962 METAL6_1876700_40600 METAL6_1874700_40600 0.004
R_VDD8_17963 METAL6_1874700_40600 METAL6_1871200_40600 0.007
R_VDD8_17964 METAL6_1871200_40600 METAL6_1870600_40600 0.0012
R_VDD8_17965 METAL6_1870600_40600 METAL6_1865600_40600 0.01
R_VDD8_17966 METAL6_1865600_40600 METAL6_1865400_40600 0.0004
R_VDD8_17967 METAL6_1865400_40600 METAL6_1864700_40600 0.0014
R_VDD8_17968 METAL6_1864700_40600 METAL6_1859200_40600 0.011
R_VDD8_17969 METAL6_1859200_40600 METAL6_1858600_40600 0.0012
R_VDD8_17970 METAL6_1858600_40600 METAL6_1858400_40600 0.0004
R_VDD8_17971 METAL6_1858400_40600 METAL6_1853400_40600 0.01
R_VDD8_17972 METAL6_1853400_40600 METAL6_1852700_40600 0.0014
R_VDD8_17973 METAL6_1852700_40600 METAL6_1847200_40600 0.011
R_VDD8_17974 METAL6_1847200_40600 METAL6_1846800_40600 0.0008
R_VDD8_17975 METAL6_1846800_40600 METAL6_1846600_40600 0.0004
R_VDD8_17976 METAL6_1846600_40600 METAL6_1846400_40600 0.0004
R_VDD8_17977 METAL6_1846400_40600 METAL6_1844800_40600 0.0032
R_VDD8_17978 METAL6_1844800_40600 METAL6_1841400_40600 0.0068
R_VDD8_17979 METAL6_1841400_40600 METAL6_1834600_40600 0.0136
R_VDD8_17980 METAL6_1834600_40600 METAL6_1834400_40600 0.0004
R_VDD8_17981 METAL6_1834400_40600 METAL6_1832800_40600 0.0032
R_VDD8_17982 METAL6_1832800_40600 METAL6_1822600_40600 0.0204
R_VDD8_17983 METAL6_1822600_40600 METAL6_1822600_52600 0.024
R_VDD8_17984 METAL6_1822600_52600 METAL6_1822600_64000 0.0228
R_VDD8_17985 METAL6_1822600_64000 METAL6_1822600_64600 0.0012
R_VDD8_17986 METAL6_1822600_64600 METAL6_1822600_71600 0.014
R_VDD8_17987 METAL6_1822600_71600 METAL6_1822600_76000 0.0088
R_VDD8_17988 METAL6_1822600_76000 METAL6_1822600_76600 0.0012
R_VDD8_17989 METAL6_1822600_76600 METAL6_1822600_83600 0.014
R_VDD8_17990 METAL6_1822600_83600 METAL6_1822600_88000 0.0088
R_VDD8_17991 METAL6_1822600_88000 METAL6_1822600_88600 0.0012
R_VDD8_17992 METAL6_1822600_88600 METAL6_1822600_95600 0.014
R_VDD8_17993 METAL6_1822600_95600 METAL6_1822600_100000 0.0088
R_VDD8_17994 METAL6_1822600_100000 METAL6_1822600_112000 0.024
R_VDD8_17995 METAL6_1822600_112000 METAL6_1822600_159600 0.0952
R_VDD8_17996 METAL6_1822600_159600 METAL6_1822600_166600 0.014
R_VDD8_17997 METAL6_1822600_166600 METAL6_1822600_176000 0.0188
R_VDD8_17998 METAL6_1822600_176000 METAL6_1822600_178600 0.0052
R_VDD8_17999 METAL6_1822600_178600 METAL6_1822600_188000 0.0188
R_VDD8_18000 METAL6_1822600_188000 METAL6_1822600_190600 0.0052
R_VDD8_18001 METAL6_1822600_190600 METAL6_1822600_200000 0.0188
R_VDD8_18002 METAL6_1822600_200000 METAL6_1822600_212000 0.024
R_VDD8_18003 METAL6_1822600_212000 METAL6_1822600_248300 0.0726
R_VDD8_18004 METAL6_1822600_248300 METAL6_1822600_251000 0.0054
R_VDD8_18005 METAL6_1822600_251000 METAL6_1822600_260300 0.0186
R_VDD8_18006 METAL6_1822600_260300 METAL6_1822600_263000 0.0054
R_VDD8_18007 METAL6_1822600_263000 METAL6_1822600_272300 0.0186
R_VDD8_18008 METAL6_1822600_272300 METAL6_1822600_275000 0.0054
R_VDD8_18009 METAL6_1822600_275000 METAL6_1822600_279300 0.0086
R_VDD8_18010 METAL6_1822600_279300 METAL6_1822600_287000 0.0154
R_VDD8_18011 METAL6_1822600_287000 METAL6_1822600_288000 0.002
R_VDD8_18012 METAL6_1822600_288000 METAL6_1822600_299000 0.022
R_VDD8_18013 METAL6_1822600_299000 METAL6_1822600_300000 0.002
R_VDD8_18014 METAL6_1822600_300000 METAL6_1822600_312000 0.024
R_VDD8_18015 METAL6_1822600_312000 METAL6_1822600_355300 0.0866
R_VDD8_18016 METAL6_1822600_355300 METAL6_1822600_362300 0.014
R_VDD8_18017 METAL6_1822600_362300 METAL6_1822600_366800 0.009
R_VDD8_18018 METAL6_1822600_366800 METAL6_1822600_374300 0.015
R_VDD8_18019 METAL6_1822600_374300 METAL6_1822600_378800 0.009
R_VDD8_18020 METAL6_1822600_378800 METAL6_1822600_386300 0.015
R_VDD8_18021 METAL6_1822600_386300 METAL6_1822600_388000 0.0034
R_VDD8_18022 METAL6_1822600_388000 METAL6_1822600_390800 0.0056
R_VDD8_18023 METAL6_1822600_390800 METAL6_1822600_400000 0.0184
R_VDD8_18024 METAL6_1822600_400000 METAL6_1822600_402800 0.0056
R_VDD8_18025 METAL6_1822600_402800 METAL6_1822600_412000 0.0184
R_VDD8_18026 METAL6_1822600_412000 METAL6_1822600_413000 0.002
R_VDD8_18027 METAL6_1822600_413000 METAL6_1822600_414800 0.0036
R_VDD8_18028 METAL6_1822600_414800 METAL6_1822600_425000 0.0204
R_VDD8_18029 METAL6_1822600_425000 METAL6_1822600_437000 0.024
R_VDD8_18030 METAL6_1822600_437000 METAL6_1822600_449000 0.024
R_VDD8_18031 METAL6_1822600_449000 METAL6_1822600_453000 0.008
R_VDD8_18032 METAL6_1822600_453000 METAL6_1822600_459000 0.012
R_VDD8_18033 METAL6_1822600_459000 METAL6_1822600_461000 0.004
R_VDD8_18034 METAL6_1822600_461000 METAL6_1822600_465000 0.008
R_VDD8_18035 METAL6_1822600_465000 METAL6_1822600_468400 0.0068
R_VDD8_18036 METAL6_1822600_468400 METAL6_1822600_471000 0.0052
R_VDD8_18037 METAL6_1822600_471000 METAL6_1822600_473000 0.004
R_VDD8_18038 METAL6_1822600_473000 METAL6_1822600_477000 0.008
R_VDD8_18039 METAL6_1822600_477000 METAL6_1822600_480400 0.0068
R_VDD8_18040 METAL6_1822600_480400 METAL6_1822600_483000 0.0052
R_VDD8_18041 METAL6_1822600_483000 METAL6_1822600_488000 0.01
R_VDD8_18042 METAL6_1822600_488000 METAL6_1822600_492400 0.0088
R_VDD8_18043 METAL6_1822600_492400 METAL6_1822600_495000 0.0052
R_VDD8_18044 METAL6_1822600_495000 METAL6_1822600_500000 0.01
R_VDD8_18045 METAL6_1822600_500000 METAL6_1822600_504000 0.008
R_VDD8_18046 METAL6_1822600_504000 METAL6_1822600_507000 0.006
R_VDD8_18047 METAL6_1822600_507000 METAL6_1822600_507800 0.0016
R_VDD8_18048 METAL6_1822600_507800 METAL6_1822600_512000 0.0084
R_VDD8_18049 METAL6_1822600_512000 METAL6_1822600_516000 0.008
R_VDD8_18050 METAL6_1822600_516000 METAL6_1822600_519000 0.006
R_VDD8_18051 METAL6_1822600_519000 METAL6_1822600_520200 0.0024
R_VDD8_18052 METAL6_1822600_520200 METAL6_1822600_528000 0.0156
R_VDD8_18053 METAL6_1822600_528000 METAL6_1822600_532200 0.0084
R_VDD8_18054 METAL6_1822600_532200 METAL6_1822600_535400 0.0064
R_VDD8_18055 METAL6_1822600_535400 METAL6_1822600_544200 0.0176
R_VDD8_18056 METAL6_1822600_544200 METAL6_1822600_547400 0.0064
R_VDD8_18057 METAL6_1822600_547400 METAL6_1822600_550400 0.006
R_VDD8_18058 METAL6_1822600_550400 METAL6_1822600_556200 0.0116
R_VDD8_18059 METAL6_1822600_556200 METAL6_1822600_559400 0.0064
R_VDD8_18060 METAL6_1822600_559400 METAL6_1822600_561000 0.0032
R_VDD8_18061 METAL6_1822600_561000 METAL6_1822600_562400 0.0028
R_VDD8_18062 METAL6_1822600_562400 METAL6_1822600_573000 0.0212
R_VDD8_18063 METAL6_1822600_573000 METAL6_1822600_574400 0.0028
R_VDD8_18064 METAL6_1822600_574400 METAL6_1822600_579800 0.0108
R_VDD8_18065 METAL6_1822600_579800 METAL6_1822600_585000 0.0104
R_VDD8_18066 METAL6_1822600_585000 METAL6_1822600_586400 0.0028
R_VDD8_18067 METAL6_1822600_586400 METAL6_1822600_588000 0.0032
R_VDD8_18068 METAL6_1822600_588000 METAL6_1822600_598400 0.0208
R_VDD8_18069 METAL6_1822600_598400 METAL6_1822600_600000 0.0032
R_VDD8_18070 METAL6_1822600_600000 METAL6_1822600_612000 0.024
R_VDD8_18071 METAL6_1822600_612000 METAL6_1822600_629400 0.0348
R_VDD8_18072 METAL6_1822600_629400 METAL6_1822600_637800 0.0168
R_VDD8_18073 METAL6_1822600_637800 METAL6_1822600_641400 0.0072
R_VDD8_18074 METAL6_1822600_641400 METAL6_1822600_649800 0.0168
R_VDD8_18075 METAL6_1822600_649800 METAL6_1822600_653400 0.0072
R_VDD8_18076 METAL6_1822600_653400 METAL6_1822600_661800 0.0168
R_VDD8_18077 METAL6_1822600_661800 METAL6_1822600_665400 0.0072
R_VDD8_18078 METAL6_1822600_665400 METAL6_1822600_688000 0.0452
R_VDD8_18079 METAL6_1822600_688000 METAL6_1822600_697800 0.0196
R_VDD8_18080 METAL6_1822600_697800 METAL6_1822600_700000 0.0044
R_VDD8_18081 METAL6_1822600_700000 METAL6_1822600_702800 0.0056
R_VDD8_18082 METAL6_1822600_702800 METAL6_1822600_709800 0.014
R_VDD8_18083 METAL6_1822600_709800 METAL6_1822600_712000 0.0044
R_VDD8_18084 METAL6_1822600_712000 METAL6_1822600_716800 0.0096
R_VDD8_18085 METAL6_1822600_716800 METAL6_1822600_721800 0.01
R_VDD8_18086 METAL6_1822600_721800 METAL6_1822600_733800 0.024
R_VDD8_18087 METAL6_1822600_733800 METAL6_1822600_735400 0.0032
R_VDD8_18088 METAL6_1822600_735400 METAL6_1822600_742400 0.014
R_VDD8_18089 METAL6_1822600_742400 METAL6_1822600_745800 0.0068
R_VDD8_18090 METAL6_1822600_745800 METAL6_1822600_746400 0.0012
R_VDD8_18091 METAL6_1822600_746400 METAL6_1822400_746400 0.0004
R_VDD8_18092 METAL6_1822400_746400 METAL6_1820800_746400 0.0032
R_VDD8_18093 METAL6_1820800_746400 METAL6_1812000_746400 0.0176
R_VDD8_18094 METAL6_1812000_746400 METAL6_1800000_746400 0.024
R_VDD8_18095 METAL6_1800000_746400 METAL6_1788000_746400 0.024
R_VDD8_18096 METAL6_1788000_746400 METAL6_1775400_746400 0.0252
R_VDD8_18097 METAL6_1775400_746400 METAL6_1767700_746400 0.0154
R_VDD8_18098 METAL6_1767700_746400 METAL6_1763800_746400 0.0078
R_VDD8_18099 METAL6_1763800_746400 METAL6_1763400_746400 0.0008
R_VDD8_18100 METAL6_1763400_746400 METAL5_1763400_746400 0.1
R_VDD8_18101 METAL5_1763400_746400 METAL5_1763400_754400 0.032
R_VDD8_18102 METAL5_1763400_754400 METAL5_1755700_754400 0.0308
R_VDD8_18103 METAL5_1755700_754400 METAL5_1755700_757800 0.0136
R_VDD8_18104 METAL5_1755700_757800 METAL5_1753800_757800 0.0076
R_VDD8_18105 METAL5_1753800_757800 METAL5_1751800_757800 0.008
R_VDD8_18106 METAL5_1751800_757800 METAL5_1751800_758400 0.0024
R_VDD8_18107 METAL5_1751800_758400 METAL5_1751800_760000 0.0064
R_VDD8_18108 METAL5_1751800_760000 METAL5_1751800_763000 0.012
R_VDD8_18109 METAL5_1751800_763000 METAL5_1751800_766400 0.0136
R_VDD8_18110 METAL5_1751800_766400 METAL5_1751800_770400 0.016
R_VDD8_18111 METAL5_1751800_770400 METAL5_1751800_772000 0.0064
R_VDD8_18112 METAL5_1751800_772000 METAL5_1751800_778400 0.0256
R_VDD8_18113 METAL5_1751800_778400 METAL5_1751800_779200 0.0032
R_VDD8_18114 METAL5_1751800_779200 METAL5_1751800_782400 0.0128
R_VDD8_18115 METAL5_1751800_782400 METAL5_1751800_784000 0.0064
R_VDD8_18116 METAL5_1751800_784000 METAL5_1751800_784500 0.002
R_VDD8_18117 METAL5_1751800_784500 METAL5_1751800_788000 0.014
R_VDD8_18118 METAL5_1751800_788000 METAL5_1751800_790400 0.0096
R_VDD8_18119 METAL5_1751800_790400 METAL5_1751800_791200 0.0032
R_VDD8_18120 METAL5_1751800_791200 METAL5_1751800_794400 0.0128
R_VDD8_18121 METAL5_1751800_794400 METAL5_1751400_794400 0.0016
R_VDD8_18122 METAL5_1751400_794400 METAL5_1744000_794400 0.0296
R_VDD8_18123 METAL5_1744000_794400 METAL5_1744000_794800 0.0016
R_VDD8_18124 METAL5_1744000_794800 METAL5_1744000_800000 0.0208
R_VDD8_18125 METAL5_1744000_800000 METAL5_1744000_802400 0.0096
R_VDD8_18126 METAL5_1744000_802400 METAL5_1744000_803200 0.0032
R_VDD8_18127 METAL5_1744000_803200 METAL5_1744000_806400 0.0128
R_VDD8_18128 METAL5_1744000_806400 METAL5_1744000_808000 0.0064
R_VDD8_18129 METAL5_1744000_808000 METAL5_1744000_812000 0.016
R_VDD8_18130 METAL5_1744000_812000 METAL5_1744000_814400 0.0096
R_VDD8_18131 METAL5_1744000_814400 METAL5_1744000_818400 0.016
R_VDD8_18132 METAL5_1744000_818400 METAL5_1743700_818400 0.0012
R_VDD8_18133 METAL5_1743700_818400 METAL5_1741800_818400 0.0076
R_VDD8_18134 METAL5_1741800_818400 METAL5_1739800_818400 0.008
R_VDD8_18135 METAL5_1739800_818400 METAL5_1739400_818400 0.0016
R_VDD8_18136 METAL5_1739400_818400 METAL5_1731700_818400 0.0308
R_VDD8_18137 METAL5_1731700_818400 METAL6_1731700_818400 0.1
R_VDD8_18138 METAL6_1731700_818400 METAL6_1729800_818400 0.0038
R_VDD8_18139 METAL6_1729800_818400 METAL6_1727800_818400 0.004
R_VDD8_18140 METAL6_1727800_818400 METAL6_1719700_818400 0.0162
R_VDD8_18141 METAL6_1719700_818400 METAL6_1717800_818400 0.0038
R_VDD8_18142 METAL6_1717800_818400 METAL6_1710800_818400 0.014
R_VDD8_18143 METAL6_1710800_818400 METAL6_1707700_818400 0.0062
R_VDD8_18144 METAL6_1707700_818400 METAL6_1699000_818400 0.0174
R_VDD8_18145 METAL6_1699000_818400 METAL6_1692000_818400 0.014
R_VDD8_18146 METAL6_1692000_818400 METAL6_1680000_818400 0.024
R_VDD8_18147 METAL6_1680000_818400 METAL6_1670800_818400 0.0184
R_VDD8_18148 METAL6_1670800_818400 METAL6_1670800_820000 0.0032
R_VDD8_18149 METAL6_1670800_820000 METAL6_1670800_828700 0.0174
R_VDD8_18150 METAL6_1670800_828700 METAL6_1670800_830400 0.0034
R_VDD8_18151 METAL6_1670800_830400 METAL6_1668000_830400 0.0056
R_VDD8_18152 METAL6_1668000_830400 METAL6_1658800_830400 0.0184
R_VDD8_18153 METAL6_1658800_830400 METAL6_1646800_830400 0.024
R_VDD8_18154 METAL6_1646800_830400 METAL6_1634800_830400 0.024
R_VDD8_18155 METAL6_1634800_830400 METAL6_1632800_830400 0.004
R_VDD8_18156 METAL6_1632800_830400 METAL6_1627800_830400 0.01
R_VDD8_18157 METAL6_1627800_830400 METAL6_1624000_830400 0.0076
R_VDD8_18158 METAL6_1624000_830400 METAL6_1615800_830400 0.0164
R_VDD8_18159 METAL6_1615800_830400 METAL6_1612700_830400 0.0062
R_VDD8_18160 METAL6_1612700_830400 METAL6_1612700_832000 0.0032
R_VDD8_18161 METAL6_1612700_832000 METAL6_1612700_839500 0.015
R_VDD8_18162 METAL6_1612700_839500 METAL6_1612700_840700 0.0024
R_VDD8_18163 METAL6_1612700_840700 METAL6_1612700_851500 0.0216
R_VDD8_18164 METAL6_1612700_851500 METAL6_1612700_852700 0.0024
R_VDD8_18165 METAL6_1612700_852700 METAL6_1612700_858200 0.011
R_VDD8_18166 METAL6_1612700_858200 METAL6_1612700_863500 0.0106
R_VDD8_18167 METAL6_1612700_863500 METAL6_1612700_875000 0.023
R_VDD8_18168 METAL6_1612700_875000 METAL6_1612700_887000 0.024
R_VDD8_18169 METAL6_1612700_887000 METAL6_1612700_888000 0.002
R_VDD8_18170 METAL6_1612700_888000 METAL6_1612700_899000 0.022
R_VDD8_18171 METAL6_1612700_899000 METAL6_1612700_900000 0.002
R_VDD8_18172 METAL6_1612700_900000 METAL6_1612700_900400 0.0008
R_VDD8_18173 METAL6_1612700_900400 METAL6_1612700_912000 0.0232
R_VDD8_18174 METAL6_1612700_912000 METAL6_1612700_927300 0.0306
R_VDD8_18175 METAL6_1612700_927300 METAL6_1612700_935000 0.0154
R_VDD8_18176 METAL6_1612700_935000 METAL6_1612700_947000 0.024
R_VDD8_18177 METAL6_1612700_947000 METAL6_1612700_959000 0.024
R_VDD8_18178 METAL6_1612700_959000 METAL6_1612700_971000 0.024
R_VDD8_18179 METAL6_1612700_971000 METAL6_1612700_976000 0.01
R_VDD8_18180 METAL6_1612700_976000 METAL6_1612700_983000 0.014
R_VDD8_18181 METAL6_1612700_983000 METAL6_1612700_988000 0.01
R_VDD8_18182 METAL6_1612700_988000 METAL6_1612700_995000 0.014
R_VDD8_18183 METAL6_1612700_995000 METAL6_1612700_1000000 0.01
R_VDD8_18184 METAL6_1612700_1000000 METAL6_1612700_1007000 0.014
R_VDD8_18185 METAL6_1612700_1007000 METAL6_1612700_1012000 0.01
R_VDD8_18186 METAL6_1612700_1012000 METAL6_1612700_1014000 0.004
R_VDD8_18187 METAL6_1612700_1014000 METAL6_1612700_1019000 0.01
R_VDD8_18188 METAL6_1612700_1019000 METAL6_1612700_1023700 0.0094
R_VDD8_18189 METAL6_1612700_1023700 METAL6_1612700_1025400 0.0034
R_VDD8_18190 METAL6_1612700_1025400 METAL6_1612700_1026000 0.0012
R_VDD8_18191 METAL6_1612700_1026000 METAL6_1612700_1029800 0.0076
R_VDD8_18192 METAL6_1612700_1029800 METAL6_1612700_1031000 0.0024
R_VDD8_18193 METAL6_1612700_1031000 METAL6_1612700_1035700 0.0094
R_VDD8_18194 METAL6_1612700_1035700 METAL6_1612700_1037400 0.0034
R_VDD8_18195 METAL6_1612700_1037400 METAL6_1612700_1038000 0.0012
R_VDD8_18196 METAL6_1612700_1038000 METAL6_1612700_1041800 0.0076
R_VDD8_18197 METAL6_1612700_1041800 METAL6_1612700_1042700 0.0018
R_VDD8_18198 METAL6_1612700_1042700 METAL6_1612700_1047700 0.01
R_VDD8_18199 METAL6_1612700_1047700 METAL6_1612700_1049400 0.0034
R_VDD8_18200 METAL6_1612700_1049400 METAL6_1612700_1049800 0.0008
R_VDD8_18201 METAL6_1612700_1049800 METAL6_1612700_1053800 0.008
R_VDD8_18202 METAL6_1612700_1053800 METAL6_1612700_1054700 0.0018
R_VDD8_18203 METAL6_1612700_1054700 METAL6_1612700_1061400 0.0134
R_VDD8_18204 METAL6_1612700_1061400 METAL6_1612000_1061400 0.0014
R_VDD8_18205 METAL6_1612000_1061400 METAL6_1607900_1061400 0.0082
R_VDD8_18206 METAL6_1607900_1061400 METAL6_1603800_1061400 0.0082
R_VDD8_18207 METAL6_1603800_1061400 METAL6_1600700_1061400 0.0062
R_VDD8_18208 METAL6_1600700_1061400 METAL6_1600000_1061400 0.0014
R_VDD8_18209 METAL6_1600000_1061400 METAL6_1591800_1061400 0.0164
R_VDD8_18210 METAL6_1591800_1061400 METAL6_1588700_1061400 0.0062
R_VDD8_18211 METAL6_1588700_1061400 METAL6_1588000_1061400 0.0014
R_VDD8_18212 METAL6_1588000_1061400 METAL6_1579800_1061400 0.0164
R_VDD8_18213 METAL6_1579800_1061400 METAL6_1576700_1061400 0.0062
R_VDD8_18214 METAL6_1576700_1061400 METAL6_1576000_1061400 0.0014
R_VDD8_18215 METAL6_1576000_1061400 METAL6_1574700_1061400 0.0026
R_VDD8_18216 METAL6_1574700_1061400 METAL6_1564000_1061400 0.0214
R_VDD8_18217 METAL6_1564000_1061400 METAL6_1557000_1061400 0.014
R_VDD8_18218 METAL6_1557000_1061400 METAL6_1555400_1061400 0.0032
R_VDD8_18219 METAL6_1555400_1061400 METAL6_1551800_1061400 0.0072
R_VDD8_18220 METAL6_1551800_1061400 METAL6_1539800_1061400 0.024
R_VDD8_18221 METAL6_1539800_1061400 METAL6_1527800_1061400 0.024
R_VDD8_18222 METAL6_1527800_1061400 METAL6_1512000_1061400 0.0316
R_VDD8_18223 METAL6_1512000_1061400 METAL6_1510400_1061400 0.0032
R_VDD8_18224 METAL6_1510400_1061400 METAL6_1503400_1061400 0.014
R_VDD8_18225 METAL6_1503400_1061400 METAL6_1500000_1061400 0.0068
R_VDD8_18226 METAL6_1500000_1061400 METAL6_1498300_1061400 0.0034
R_VDD8_18227 METAL6_1498300_1061400 METAL6_1491400_1061400 0.0138
R_VDD8_18228 METAL6_1491400_1061400 METAL6_1488000_1061400 0.0068
R_VDD8_18229 METAL6_1488000_1061400 METAL6_1479400_1061400 0.0172
R_VDD8_18230 METAL6_1479400_1061400 METAL6_1444800_1061400 0.0692
R_VDD8_18231 METAL6_1444800_1061400 METAL6_1443700_1061400 0.0022
R_VDD8_18232 METAL6_1443700_1061400 METAL6_1432800_1061400 0.0218
R_VDD8_18233 METAL6_1432800_1061400 METAL6_1431700_1061400 0.0022
R_VDD8_18234 METAL6_1431700_1061400 METAL6_1424000_1061400 0.0154
R_VDD8_18235 METAL6_1424000_1061400 METAL6_1420800_1061400 0.0064
R_VDD8_18236 METAL6_1420800_1061400 METAL6_1419700_1061400 0.0022
R_VDD8_18237 METAL6_1419700_1061400 METAL6_1412000_1061400 0.0154
R_VDD8_18238 METAL6_1412000_1061400 METAL6_1400000_1061400 0.024
R_VDD8_18239 METAL6_1400000_1061400 METAL6_1388000_1061400 0.024
R_VDD8_18240 METAL6_1388000_1061400 METAL6_1337000_1061400 0.102
R_VDD8_18241 METAL6_1337000_1061400 METAL6_1336000_1061400 0.002
R_VDD8_18242 METAL6_1336000_1061400 METAL6_1325000_1061400 0.022
R_VDD8_18243 METAL6_1325000_1061400 METAL6_1324000_1061400 0.002
R_VDD8_18244 METAL6_1324000_1061400 METAL6_1324000_1061800 0.0008
R_VDD8_18245 METAL6_1324000_1061800 METAL6_1324000_1066700 0.0098
R_VDD8_18246 METAL6_1324000_1066700 METAL6_1324000_1073800 0.0142
R_VDD8_18247 METAL6_1324000_1073800 METAL6_1324000_1074000 0.0004
R_VDD8_18248 METAL6_1324000_1074000 METAL6_1324000_1074500 0.001
R_VDD8_18249 METAL6_1324000_1074500 METAL6_1324000_1085800 0.0226
R_VDD8_18250 METAL6_1324000_1085800 METAL6_1324000_1086000 0.0004
R_VDD8_18251 METAL6_1324000_1086000 METAL6_1324000_1086300 0.0006
R_VDD8_18252 METAL6_1324000_1086300 METAL6_1324000_1086500 0.0004
R_VDD8_18253 METAL6_1324000_1086500 METAL6_1324000_1088000 0.003
R_VDD8_18254 METAL6_1324000_1088000 METAL6_1324000_1096800 0.0176
R_VDD8_18255 METAL6_1324000_1096800 METAL6_1324000_1098000 0.0024
R_VDD8_18256 METAL6_1324000_1098000 METAL6_1324000_1098300 0.0006
R_VDD8_18257 METAL6_1324000_1098300 METAL6_1324000_1098500 0.0004
R_VDD8_18258 METAL6_1324000_1098500 METAL6_1324000_1100000 0.003
R_VDD8_18259 METAL6_1324000_1100000 METAL6_1324000_1108800 0.0176
R_VDD8_18260 METAL6_1324000_1108800 METAL6_1324000_1110000 0.0024
R_VDD8_18261 METAL6_1324000_1110000 METAL6_1324000_1110300 0.0006
R_VDD8_18262 METAL6_1324000_1110300 METAL6_1323800_1110300 0.0004
R_VDD8_18263 METAL6_1323800_1110300 METAL6_1313000_1110300 0.0216
R_VDD8_18264 METAL6_1313000_1110300 METAL6_1312000_1110300 0.002
R_VDD8_18265 METAL6_1312000_1110300 METAL6_1311800_1110300 0.0004
R_VDD8_18266 METAL6_1311800_1110300 METAL6_1301000_1110300 0.0216
R_VDD8_18267 METAL6_1301000_1110300 METAL6_1300000_1110300 0.002
R_VDD8_18268 METAL6_1300000_1110300 METAL6_1299800_1110300 0.0004
R_VDD8_18269 METAL6_1299800_1110300 METAL6_1289000_1110300 0.0216
R_VDD8_18270 METAL6_1289000_1110300 METAL6_1288000_1110300 0.002
R_VDD8_18271 METAL6_1288000_1110300 METAL6_1288000_1110500 0.0004
R_VDD8_18272 METAL6_1288000_1110500 METAL6_1288000_1112000 0.003
R_VDD8_18273 METAL6_1288000_1112000 METAL6_1288000_1120800 0.0176
R_VDD8_18274 METAL6_1288000_1120800 METAL6_1288000_1122300 0.003
R_VDD8_18275 METAL6_1288000_1122300 METAL6_1288000_1122500 0.0004
R_VDD8_18276 METAL6_1288000_1122500 METAL6_1288000_1129300 0.0136
R_VDD8_18277 METAL6_1288000_1129300 METAL6_1288000_1132800 0.007
R_VDD8_18278 METAL6_1288000_1132800 METAL6_1288000_1134300 0.003
R_VDD8_18279 METAL6_1288000_1134300 METAL6_1287800_1134300 0.0004
R_VDD8_18280 METAL6_1287800_1134300 METAL6_1286700_1134300 0.0022
R_VDD8_18281 METAL6_1286700_1134300 METAL6_1274700_1134300 0.024
R_VDD8_18282 METAL6_1274700_1134300 METAL6_1266800_1134300 0.0158
R_VDD8_18283 METAL6_1266800_1134300 METAL6_1262700_1134300 0.0082
R_VDD8_18284 METAL6_1262700_1134300 METAL6_1259800_1134300 0.0058
R_VDD8_18285 METAL6_1259800_1134300 METAL6_1258300_1134300 0.003
R_VDD8_18286 METAL6_1258300_1134300 METAL6_1258300_1134500 0.0004
R_VDD8_18287 METAL6_1258300_1134500 METAL6_1258300_1141300 0.0136
R_VDD8_18288 METAL6_1258300_1141300 METAL6_1258300_1146300 0.01
R_VDD8_18289 METAL6_1258300_1146300 METAL6_1258300_1153300 0.014
R_VDD8_18290 METAL6_1258300_1153300 METAL6_1258300_1157700 0.0088
R_VDD8_18291 METAL6_1258300_1157700 METAL6_1258300_1160600 0.0058
R_VDD8_18292 METAL6_1258300_1160600 METAL6_1258300_1169700 0.0182
R_VDD8_18293 METAL6_1258300_1169700 METAL5_1258300_1169700 0.1
R_VDD8_18294 METAL5_1258300_1169700 METAL5_1258300_1172600 0.0116
R_VDD8_18295 METAL5_1258300_1172600 METAL5_1258300_1181700 0.0364
R_VDD8_18296 METAL5_1258300_1181700 METAL5_1258300_1181800 0.0004
R_VDD8_18297 METAL5_1258300_1181800 METAL5_1258300_1184600 0.0112
R_VDD8_18298 METAL5_1258300_1184600 METAL5_1258300_1191600 0.028
R_VDD8_18299 METAL5_1258300_1191600 METAL5_1258300_1193700 0.0084
R_VDD8_18300 METAL5_1258300_1193700 METAL5_1258300_1193800 0.0004
R_VDD8_18301 METAL5_1258300_1193800 METAL5_1258300_1205700 0.0476
R_VDD8_18302 METAL5_1258300_1205700 METAL6_1258300_1205700 0.1
R_VDD8_18303 METAL6_1258300_1205700 METAL6_1258300_1205800 0.0002
R_VDD8_18304 METAL6_1258300_1205800 METAL6_1258300_1217700 0.0238
R_VDD8_18305 METAL6_1258300_1217700 METAL6_1258300_1223700 0.012
R_VDD8_18306 METAL6_1258300_1223700 METAL6_1258300_1229700 0.012
R_VDD8_18307 METAL6_1258300_1229700 METAL6_1258300_1235700 0.012
R_VDD8_18308 METAL6_1258300_1235700 METAL6_1258300_1238000 0.0046
R_VDD8_18309 METAL6_1258300_1238000 METAL6_1258300_1247700 0.0194
R_VDD8_18310 METAL6_1258300_1247700 METAL6_1258300_1250000 0.0046
R_VDD8_18311 METAL6_1258300_1250000 METAL6_1258300_1259700 0.0194
R_VDD8_18312 METAL6_1258300_1259700 METAL6_1258300_1261000 0.0026
R_VDD8_18313 METAL6_1258300_1261000 METAL6_1258300_1262000 0.002
R_VDD8_18314 METAL6_1258300_1262000 METAL6_1258300_1271700 0.0194
R_VDD8_18315 METAL6_1258300_1271700 METAL6_1258300_1273000 0.0026
R_VDD8_18316 METAL6_1258300_1273000 METAL6_1258300_1283700 0.0214
R_VDD8_18317 METAL6_1258300_1283700 METAL6_1258300_1285000 0.0026
R_VDD8_18318 METAL6_1258300_1285000 METAL6_1258300_1295700 0.0214
R_VDD8_18319 METAL6_1258300_1295700 METAL6_1258300_1297000 0.0026
R_VDD8_18320 METAL6_1258300_1297000 METAL6_1258300_1302000 0.01
R_VDD8_18321 METAL6_1258300_1302000 METAL6_1258300_1307700 0.0114
R_VDD8_18322 METAL6_1258300_1307700 METAL6_1258300_1309000 0.0026
R_VDD8_18323 METAL6_1258300_1309000 METAL6_1258300_1314000 0.01
R_VDD8_18324 METAL6_1258300_1314000 METAL5_1258300_1314000 0.1
R_VDD8_18325 METAL5_1258300_1314000 METAL5_1258300_1319700 0.0228
R_VDD8_18326 METAL5_1258300_1319700 METAL5_1258300_1326000 0.0252
R_VDD8_18327 METAL5_1258300_1326000 METAL5_1258300_1338000 0.048
R_VDD8_18328 METAL5_1258300_1338000 METAL5_1258300_1350000 0.048
R_VDD8_18329 METAL5_1258300_1350000 METAL5_1258300_1357000 0.028
R_VDD8_18330 METAL5_1258300_1357000 METAL5_1258300_1362000 0.02
R_VDD8_18331 METAL5_1258300_1362000 METAL6_1258300_1362000 0.1
R_VDD8_18332 METAL6_1258300_1362000 METAL6_1258300_1369000 0.014
R_VDD8_18333 METAL6_1258300_1369000 METAL6_1258300_1374000 0.01
R_VDD8_18334 METAL6_1258300_1374000 METAL6_1258300_1381000 0.014
R_VDD8_18335 METAL6_1258300_1381000 METAL6_1258300_1386600 0.0112
R_VDD8_18336 METAL6_1258300_1386600 METAL6_1258300_1393000 0.0128
R_VDD8_18337 METAL6_1258300_1393000 METAL6_1258300_1405000 0.024
R_VDD8_18338 METAL6_1258300_1405000 METAL6_1258300_1437700 0.0654
R_VDD8_18339 METAL6_1258300_1437700 METAL6_1258300_1449700 0.024
R_VDD8_18340 METAL6_1258300_1449700 METAL6_1258300_1461700 0.024
R_VDD8_18341 METAL6_1258300_1461700 METAL6_1258300_1492300 0.0612
R_VDD8_18342 METAL6_1258300_1492300 METAL6_1258300_1504300 0.024
R_VDD8_18343 METAL6_1258300_1504300 METAL6_1258300_1516300 0.024
R_VDD8_18344 METAL6_1258300_1516300 METAL6_1258300_1528300 0.024
R_VDD8_18345 METAL6_1258300_1528300 METAL6_1258300_1540300 0.024
R_VDD8_18346 METAL6_1258300_1540300 METAL6_1258300_1552300 0.024
R_VDD8_18347 METAL6_1258300_1552300 METAL6_1258300_1554500 0.0044
R_VDD8_18348 METAL6_1258300_1554500 METAL6_1258300_1564300 0.0196
R_VDD8_18349 METAL6_1258300_1564300 METAL6_1258300_1571300 0.014
R_VDD8_18350 METAL6_1258300_1571300 METAL6_1258300_1576300 0.01
R_VDD8_18351 METAL6_1258300_1576300 METAL6_1258300_1714500 0.2764
R_VDD8_18352 METAL6_1258300_1714500 METAL6_1258300_1720500 0.012
R_VDD8_18353 METAL6_1258300_1720500 METAL6_1258300_1726500 0.012
R_VDD8_18354 METAL6_1258300_1726500 METAL6_1258300_1731700 0.0104
R_VDD8_18355 METAL6_1258300_1731700 METAL6_1258300_1738500 0.0136
R_VDD8_18356 METAL6_1258300_1738500 METAL6_1258300_1750500 0.024
R_VDD8_18357 METAL6_1258300_1750500 METAL6_1258300_1762500 0.024
R_VDD8_18358 METAL6_1258300_1762500 METAL6_1258300_1774500 0.024
R_VDD8_18359 METAL6_1258300_1774500 METAL6_1258300_1802500 0.056
R_VDD8_18360 METAL6_1258300_1802500 METAL6_1258300_1814500 0.024
R_VDD8_18361 METAL6_1258300_1814500 METAL6_1258300_1826500 0.024
R_VDD8_18362 METAL6_1258300_1826500 METAL6_1258300_1838500 0.024
R_VDD8_18363 METAL6_1258300_1838500 METAL6_1258300_1852300 0.0276
R_VDD8_18364 METAL6_1258300_1852300 METAL6_1258300_1866300 0.028
R_VDD8_18365 METAL6_1258300_1866300 METAL6_1258300_1902500 0.0724
R_VDD8_18366 METAL6_1258300_1902500 METAL6_1258300_1914500 0.024
R_VDD8_18367 METAL6_1258300_1914500 METAL6_1258300_1926500 0.024
R_VDD8_18368 METAL6_1258300_1926500 METAL6_1258300_1938500 0.024
R_VDD8_18369 METAL6_1258300_1938500 METAL6_1258300_1939000 0.001
R_VDD8_18370 METAL6_1258300_1939000 METAL6_1258300_1940500 0.003
R_VDD8_18371 METAL6_1258300_1940500 METAL6_1258300_1950500 0.02
R_VDD8_18372 METAL6_1258300_1950500 METAL6_1258300_1951000 0.001
R_VDD8_18373 METAL6_1258300_1951000 METAL6_1258300_1952500 0.003
R_VDD8_18374 METAL6_1258300_1952500 METAL6_1258300_1962500 0.02
R_VDD8_18375 METAL6_1258300_1962500 METAL6_1258300_1963000 0.001
R_VDD8_18376 METAL6_1258300_1963000 METAL6_1258300_1964500 0.003
R_VDD8_18377 METAL6_1258300_1964500 METAL6_1258300_1975000 0.021
R_VDD8_18378 METAL6_1258300_1975000 METAL6_1258300_1976500 0.003
R_VDD8_18379 METAL6_1258300_1976500 METAL6_1258300_1987000 0.021
R_VDD8_18380 METAL6_1258300_1987000 METAL6_1258300_1988500 0.003
R_VDD8_18381 METAL6_1258300_1988500 METAL6_1258300_2014500 0.052
R_VDD8_18382 METAL6_1258300_2014500 METAL6_1258300_2026500 0.024
R_VDD8_18383 METAL6_1258300_2026500 METAL6_1258300_2038500 0.024
R_VDD8_18384 METAL6_1258300_2038500 METAL6_1258300_2114500 0.152
R_VDD8_18385 METAL6_1258300_2114500 METAL6_1258300_2126500 0.024
R_VDD8_18386 METAL6_1258300_2126500 METAL6_1258300_2138500 0.024
R_VDD8_18387 METAL6_1258300_2138500 METAL6_1258300_2147300 0.0176
R_VDD8_18388 METAL6_1258300_2147300 METAL6_1258300_2150500 0.0064
R_VDD8_18389 METAL6_1258300_2150500 METAL6_1258300_2154300 0.0076
R_VDD8_18390 METAL6_1258300_2154300 METAL6_1258300_2163000 0.0174
R_VDD8_18391 METAL6_1258300_2163000 METAL6_1258300_2166300 0.0066
R_VDD8_18392 METAL6_1258300_2166300 METAL6_1258300_2175000 0.0174
R_VDD8_18393 METAL6_1258300_2175000 METAL6_1258300_2178300 0.0066
R_VDD8_18394 METAL6_1258300_2178300 METAL6_1258300_2187000 0.0174
R_VDD8_18395 METAL6_1258300_2187000 METAL6_1258300_2190300 0.0066
R_VDD8_18396 METAL6_1258300_2190300 METAL6_1258300_2199000 0.0174
R_VDD8_18397 METAL6_1258300_2199000 METAL6_1258300_2202300 0.0066
R_VDD8_18398 METAL6_1258300_2202300 METAL6_1258300_2222500 0.0404
R_VDD8_18399 METAL6_1258300_2222500 METAL6_1258300_2234500 0.024
R_VDD8_18400 METAL6_1258300_2234500 METAL6_1258300_2246500 0.024
R_VDD8_18401 METAL6_1258300_2246500 METAL6_1258300_2256500 0.02
R_VDD8_18402 METAL6_1258300_2256500 METAL6_1258300_2258500 0.004
R_VDD8_18403 METAL6_1258300_2258500 METAL6_1258300_2268500 0.02
R_VDD8_18404 METAL6_1258300_2268500 METAL6_1258300_2276000 0.015
R_VDD8_18405 METAL6_1258300_2276000 METAL6_1258300_2280500 0.009
R_VDD8_18406 METAL6_1258300_2280500 METAL6_1258300_2288000 0.015
R_VDD8_18407 METAL6_1258300_2288000 METAL6_1258300_2292000 0.008
R_VDD8_18408 METAL6_1258300_2292000 METAL6_1258300_2300000 0.016
R_VDD8_18409 METAL6_1258300_2300000 METAL6_1258300_2304000 0.008
R_VDD8_18410 METAL6_1258300_2304000 METAL6_1258300_2305000 0.002
R_VDD8_18411 METAL6_1258300_2305000 METAL6_1258300_2312000 0.014
R_VDD8_18412 METAL6_1258300_2312000 METAL5_1258300_2312000 0.1
R_VDD8_18413 METAL5_1258300_2312000 METAL5_1254700_2312000 0.0144
R_VDD8_18414 METAL5_1254700_2312000 METAL5_1253300_2312000 0.0056
R_VDD8_18415 METAL5_1253300_2312000 METAL5_1247800_2312000 0.022
R_VDD8_18416 METAL5_1247800_2312000 METAL5_1246300_2312000 0.006
R_VDD8_18417 METAL5_1246300_2312000 METAL5_1242700_2312000 0.0144
R_VDD8_18418 METAL5_1242700_2312000 METAL5_1236000_2312000 0.0268
R_VDD8_18419 METAL5_1236000_2312000 METAL5_1235800_2312000 0.0008
R_VDD8_18420 METAL5_1235800_2312000 METAL5_1234300_2312000 0.006
R_VDD8_18421 METAL5_1234300_2312000 METAL5_1230700_2312000 0.0144
R_VDD8_18422 METAL5_1230700_2312000 METAL5_1224000_2312000 0.0268
R_VDD8_18423 METAL5_1224000_2312000 METAL5_1223800_2312000 0.0008
R_VDD8_18424 METAL5_1223800_2312000 METAL5_1222300_2312000 0.006
R_VDD8_18425 METAL5_1222300_2312000 METAL5_1218700_2312000 0.0144
R_VDD8_18426 METAL5_1218700_2312000 METAL5_1216400_2312000 0.0092
R_VDD8_18427 METAL5_1216400_2312000 METAL5_1212000_2312000 0.0176
R_VDD8_18428 METAL5_1212000_2312000 METAL5_1211800_2312000 0.0008
R_VDD8_18429 METAL5_1211800_2312000 METAL5_1210300_2312000 0.006
R_VDD8_18430 METAL5_1210300_2312000 METAL5_1206700_2312000 0.0144
R_VDD8_18431 METAL5_1206700_2312000 METAL5_1204400_2312000 0.0092
R_VDD8_18432 METAL5_1204400_2312000 METAL5_1200000_2312000 0.0176
R_VDD8_18433 METAL5_1200000_2312000 METAL5_1199800_2312000 0.0008
R_VDD8_18434 METAL5_1199800_2312000 METAL5_1198300_2312000 0.006
R_VDD8_18435 METAL5_1198300_2312000 METAL5_1194700_2312000 0.0144
R_VDD8_18436 METAL5_1194700_2312000 METAL5_1192400_2312000 0.0092
R_VDD8_18437 METAL5_1192400_2312000 METAL5_1188000_2312000 0.0176
R_VDD8_18438 METAL5_1188000_2312000 METAL5_1186300_2312000 0.0068
R_VDD8_18439 METAL5_1186300_2312000 METAL5_1180400_2312000 0.0236
R_VDD8_18440 METAL5_1180400_2312000 METAL5_1174300_2312000 0.0244
R_VDD8_18441 METAL5_1174300_2312000 METAL6_1174300_2312000 0.1
R_VDD8_18442 METAL6_1174300_2312000 METAL6_1174300_2314000 0.004
R_VDD8_18443 METAL6_1174300_2314000 METAL6_1174300_2316000 0.004
R_VDD8_18444 METAL6_1174300_2316000 METAL6_1174300_2317000 0.002
R_VDD8_18445 METAL6_1174300_2317000 METAL6_1174300_2326000 0.018
R_VDD8_18446 METAL6_1174300_2326000 METAL6_1174300_2328000 0.004
R_VDD8_18447 METAL6_1174300_2328000 METAL6_1174300_2329000 0.002
R_VDD8_18448 METAL6_1174300_2329000 METAL6_1174300_2338000 0.018
R_VDD8_18449 METAL6_1174300_2338000 METAL6_1174300_2340000 0.004
R_VDD8_18450 METAL6_1174300_2340000 METAL6_1174300_2341000 0.002
R_VDD8_18451 METAL6_1174300_2341000 METAL6_1174300_2350000 0.018
R_VDD8_18452 METAL6_1174300_2350000 METAL6_1174300_2352000 0.004
R_VDD8_18453 METAL6_1174300_2352000 METAL6_1174300_2353000 0.002
R_VDD8_18454 METAL6_1174300_2353000 METAL6_1174300_2362000 0.018
R_VDD8_18455 METAL6_1174300_2362000 METAL6_1174300_2364000 0.004
R_VDD8_18456 METAL6_1174300_2364000 METAL6_1174300_2365000 0.002
R_VDD8_18457 METAL6_1174300_2365000 METAL6_1174300_2374000 0.018
R_VDD8_18458 METAL6_1174300_2374000 METAL6_1174300_2376000 0.004
R_VDD8_18459 METAL6_1174300_2376000 METAL6_1174300_2377000 0.002
R_VDD8_18460 METAL6_1174300_2377000 METAL6_1174300_2388000 0.022
R_VDD8_18461 METAL6_1174300_2388000 METAL6_1174300_2389000 0.002
R_VDD8_18462 METAL6_1174300_2389000 METAL6_1174300_2395000 0.012
R_VDD8_18463 METAL6_1174300_2395000 METAL6_1174300_2400000 0.01
R_VDD8_18464 METAL6_1174300_2400000 METAL6_1174300_2401000 0.002
R_VDD8_18465 METAL6_1174300_2401000 METAL6_1174300_2407000 0.012
R_VDD8_18466 METAL6_1174300_2407000 METAL6_1174300_2412000 0.01
R_VDD8_18467 METAL6_1174300_2412000 METAL6_1174300_2413000 0.002
R_VDD8_18468 METAL6_1174300_2413000 METAL6_1174300_2419000 0.012
R_VDD8_18469 METAL6_1174300_2419000 METAL6_1174300_2424000 0.01
R_VDD8_18470 METAL6_1174300_2424000 METAL6_1174300_2436000 0.024
R_VDD8_18471 METAL6_1174300_2436000 METAL6_1174300_2438000 0.004
R_VDD8_18472 METAL6_1174300_2438000 METAL6_1174300_2444000 0.012
R_VDD8_18473 METAL6_1174300_2444000 METAL6_1174300_2450000 0.012
R_VDD8_18474 METAL6_1174300_2450000 METAL6_1174300_2456000 0.012
R_VDD8_18475 METAL6_1174300_2456000 METAL6_1174300_2462000 0.012
R_VDD8_18476 METAL6_1174300_2462000 METAL6_1174300_2468000 0.012
R_VDD8_18477 METAL6_1174300_2468000 METAL6_1174300_2469000 0.002
R_VDD8_18478 METAL6_1174300_2469000 METAL6_1174300_2481000 0.024
R_VDD8_18479 METAL6_1174300_2481000 METAL6_1174300_2493000 0.024
R_VDD8_18480 METAL6_1174300_2493000 METAL6_1174300_2505000 0.024
R_VDD8_18481 METAL6_1174300_2505000 METAL6_1174300_2512000 0.014
R_VDD8_18482 METAL6_1174300_2512000 METAL6_1174300_2517700 0.0114
R_VDD8_18483 METAL6_1174300_2517700 METAL6_1174300_2524000 0.0126
R_VDD8_18484 METAL6_1174300_2524000 METAL6_1174300_2529700 0.0114
R_VDD8_18485 METAL6_1174300_2529700 METAL6_1174300_2536000 0.0126
R_VDD8_18486 METAL6_1174300_2536000 METAL6_1174300_2541700 0.0114
R_VDD8_18487 METAL6_1174300_2541700 METAL6_1174300_2548000 0.0126
R_VDD8_18488 METAL6_1174300_2548000 METAL6_1174300_2553700 0.0114
R_VDD8_18489 METAL6_1174300_2553700 METAL6_1174300_2589000 0.0706
R_VDD8_18490 METAL6_1174300_2589000 METAL6_1174300_2603000 0.028
R_VDD8_18491 METAL6_1174300_2603000 METAL6_1174300_2644000 0.082
R_VDD8_18492 METAL6_1174300_2644000 METAL6_1174300_2656000 0.024
R_VDD8_18493 METAL6_1174300_2656000 METAL6_1174300_2665700 0.0194
R_VDD8_18494 METAL6_1174300_2665700 METAL6_1174300_2668000 0.0046
R_VDD8_18495 METAL6_1174300_2668000 METAL6_1174300_2701000 0.066
R_VDD8_18496 METAL6_1174300_2701000 METAL6_1174300_2701700 0.0014
R_VDD8_18497 METAL6_1174300_2701700 METAL6_1174300_2713000 0.0226
R_VDD8_18498 METAL6_1174300_2713000 METAL6_1174300_2713700 0.0014
R_VDD8_18499 METAL6_1174300_2713700 METAL6_1174300_2724000 0.0206
R_VDD8_18500 METAL6_1174300_2724000 METAL6_1174300_2725000 0.002
R_VDD8_18501 METAL6_1174300_2725000 METAL6_1174300_2725700 0.0014
R_VDD8_18502 METAL6_1174300_2725700 METAL6_1174300_2736000 0.0206
R_VDD8_18503 METAL6_1174300_2736000 METAL6_1174300_2737000 0.002
R_VDD8_18504 METAL6_1174300_2737000 METAL6_1174300_2737700 0.0014
R_VDD8_18505 METAL6_1174300_2737700 METAL6_1174300_2748000 0.0206
R_VDD8_18506 METAL6_1174300_2748000 METAL6_1174300_2777000 0.058
R_VDD8_18507 METAL6_1174300_2777000 METAL6_1174300_2789000 0.024
R_VDD8_18508 METAL6_1174300_2789000 METAL6_1174300_2801000 0.024
R_VDD8_18509 METAL6_1174300_2801000 METAL6_1174300_2801700 0.0014
R_VDD8_18510 METAL6_1174300_2801700 METAL6_1174300_2803000 0.0026
R_VDD8_18511 METAL6_1174300_2803000 METAL6_1174300_2808000 0.01
R_VDD8_18512 METAL6_1174300_2808000 METAL6_1174300_2813700 0.0114
R_VDD8_18513 METAL6_1174300_2813700 METAL6_1174300_2825700 0.024
R_VDD8_18514 METAL6_1174300_2825700 METAL6_1174300_2901700 0.152
R_VDD8_18515 METAL6_1174300_2901700 METAL6_1174300_2913000 0.0226
R_VDD8_18516 METAL6_1174300_2913000 METAL6_1174300_2913700 0.0014
R_VDD8_18517 METAL6_1174300_2913700 METAL6_1174300_2925000 0.0226
R_VDD8_18518 METAL6_1174300_2925000 METAL6_1174300_2925700 0.0014
R_VDD8_18519 METAL6_1174300_2925700 METAL6_1174300_2937000 0.0226
R_VDD8_18520 METAL6_1174300_2937000 METAL6_1174300_3001700 0.1294
R_VDD8_18521 METAL6_1174300_3001700 METAL6_1174300_3013700 0.024
R_VDD8_18522 METAL6_1174300_3013700 METAL6_1174300_3025700 0.024
R_VDD8_18523 METAL6_1174300_3025700 METAL6_1174300_3063000 0.0746
R_VDD8_18524 METAL6_1174300_3063000 METAL6_1174300_3073700 0.0214
R_VDD8_18525 METAL6_1174300_3073700 METAL6_1174300_3075000 0.0026
R_VDD8_18526 METAL6_1174300_3075000 METAL6_1174300_3085700 0.0214
R_VDD8_18527 METAL6_1174300_3085700 METAL6_1174300_3087000 0.0026
R_VDD8_18528 METAL6_1174300_3087000 METAL6_1174300_3089700 0.0054
R_VDD8_18529 METAL6_1174300_3089700 METAL6_1174300_3097700 0.016
R_VDD8_18530 METAL6_1174300_3097700 METAL6_1174300_3101700 0.008
R_VDD8_18531 METAL6_1174300_3101700 METAL6_1174300_3109700 0.016
R_VDD8_18532 METAL6_1174300_3109700 METAL6_1174300_3113700 0.008
R_VDD8_18533 METAL6_1174300_3113700 METAL6_1174300_3125700 0.024
R_VDD8_18534 METAL6_1174300_3125700 METAL6_1174300_3179700 0.108
R_VDD8_18535 METAL6_1174300_3179700 METAL6_1174300_3255700 0.152
R_VDD8_18536 METAL6_1174300_3255700 METAL6_1174300_3263000 0.0146
R_VDD8_18537 METAL6_1174300_3263000 METAL6_1174300_3275000 0.024
R_VDD8_18538 METAL6_1174300_3275000 METAL6_1174300_3281000 0.012
R_VDD8_18539 METAL6_1174300_3281000 METAL6_1174300_3287000 0.012
R_VDD8_18540 METAL6_1174300_3287000 METAL6_1174300_3293000 0.012
R_VDD8_18541 METAL6_1174300_3293000 METAL6_1173700_3293000 0.0012
R_VDD8_18542 METAL6_1173700_3293000 METAL6_1166700_3293000 0.014
R_VDD8_18543 METAL6_1166700_3293000 METAL6_1154700_3293000 0.024
R_VDD8_18544 METAL6_1154700_3293000 METAL6_1142700_3293000 0.024
R_VDD8_18545 METAL6_1142700_3293000 METAL6_1137000_3293000 0.0114
R_VDD8_18546 METAL6_1137000_3293000 METAL6_1130700_3293000 0.0126
R_VDD8_18547 METAL6_1130700_3293000 METAL6_1125000_3293000 0.0114
R_VDD8_18548 METAL6_1125000_3305000 METAL6_1125000_3293000 0.024
I_VDD8_64 METAL6_1125000_3305000 gnd 0.003

V_VDD9_26 METAL6_2800000_0 gnd 1.05
R_VDD9_18549 METAL6_2800000_0 METAL6_2800000_9500 0.019
R_VDD9_18550 METAL6_2800000_9500 METAL6_2800000_16000 0.013
R_VDD9_18551 METAL6_2800000_16000 METAL6_2800000_16600 0.0012
R_VDD9_18552 METAL6_2800000_16600 METAL6_2800000_21500 0.0098
R_VDD9_18553 METAL6_2800000_21500 METAL6_2800000_28000 0.013
R_VDD9_18554 METAL6_2800000_28000 METAL6_2805600_28000 0.0112
R_VDD9_18555 METAL6_2805600_28000 METAL6_2810800_28000 0.0104
R_VDD9_18556 METAL6_2810800_28000 METAL6_2812000_28000 0.0024
R_VDD9_18557 METAL6_2812000_28000 METAL6_2817600_28000 0.0112
R_VDD9_18558 METAL6_2817600_28000 METAL6_2824000_28000 0.0128
R_VDD9_18559 METAL6_2824000_28000 METAL6_2843800_28000 0.0396
R_VDD9_18560 METAL6_2843800_28000 METAL6_2846600_28000 0.0056
R_VDD9_18561 METAL6_2846600_28000 METAL6_2850800_28000 0.0084
R_VDD9_18562 METAL6_2850800_28000 METAL6_2860600_28000 0.0196
R_VDD9_18563 METAL6_2860600_28000 METAL6_2862800_28000 0.0044
R_VDD9_18564 METAL6_2862800_28000 METAL6_2874800_28000 0.024
R_VDD9_18565 METAL6_2874800_28000 METAL6_2874800_28600 0.0012
R_VDD9_18566 METAL6_2874800_28600 METAL6_2874900_28600 0.0002
R_VDD9_18567 METAL6_2874900_28600 METAL6_2886900_28600 0.024
R_VDD9_18568 METAL6_2886900_28600 METAL6_2897100_28600 0.0204
R_VDD9_18569 METAL6_2897100_28600 METAL6_2898900_28600 0.0036
R_VDD9_18570 METAL6_2898900_28600 METAL6_2901600_28600 0.0054
R_VDD9_18571 METAL6_2901600_28600 METAL6_2910900_28600 0.0186
R_VDD9_18572 METAL6_2910900_28600 METAL6_2913600_28600 0.0054
R_VDD9_18573 METAL6_2913600_28600 METAL6_2918200_28600 0.0092
R_VDD9_18574 METAL6_2918200_28600 METAL6_2925600_28600 0.0148
R_VDD9_18575 METAL6_2925600_28600 METAL6_2930200_28600 0.0092
R_VDD9_18576 METAL6_2930200_28600 METAL6_2942200_28600 0.024
R_VDD9_18577 METAL6_2942200_28600 METAL6_2951900_28600 0.0194
R_VDD9_18578 METAL6_2951900_28600 METAL6_2958200_28600 0.0126
R_VDD9_18579 METAL6_2958200_28600 METAL6_2963200_28600 0.01
R_VDD9_18580 METAL6_2963200_28600 METAL6_2965900_28600 0.0054
R_VDD9_18581 METAL6_2965900_28600 METAL6_2970200_28600 0.0086
R_VDD9_18582 METAL6_2970200_28600 METAL6_2975200_28600 0.01
R_VDD9_18583 METAL6_2975200_28600 METAL6_2976000_28600 0.0016
R_VDD9_18584 METAL6_2976000_28600 METAL6_2982200_28600 0.0124
R_VDD9_18585 METAL6_2982200_28600 METAL6_2987200_28600 0.01
R_VDD9_18586 METAL6_2987200_28600 METAL6_2988000_28600 0.0016
R_VDD9_18587 METAL6_2988000_28600 METAL5_2988000_28600 0.1
R_VDD9_18588 METAL5_2988000_28600 METAL5_2993000_28600 0.02
R_VDD9_18589 METAL5_2993000_28600 METAL5_2994200_28600 0.0048
R_VDD9_18590 METAL5_2994200_28600 METAL5_3000000_28600 0.0232
R_VDD9_18591 METAL5_3000000_28600 METAL5_3006200_28600 0.0248
R_VDD9_18592 METAL5_3006200_28600 METAL5_3011200_28600 0.02
R_VDD9_18593 METAL5_3011200_28600 METAL5_3012000_28600 0.0032
R_VDD9_18594 METAL5_3012000_28600 METAL5_3018200_28600 0.0248
R_VDD9_18595 METAL5_3018200_28600 METAL5_3023200_28600 0.02
R_VDD9_18596 METAL5_3023200_28600 METAL5_3024000_28600 0.0032
R_VDD9_18597 METAL5_3024000_28600 METAL5_3035200_28600 0.0448
R_VDD9_18598 METAL5_3035200_28600 METAL5_3052000_28600 0.0672
R_VDD9_18599 METAL5_3052000_28600 METAL5_3060600_28600 0.0344
R_VDD9_18600 METAL5_3060600_28600 METAL5_3060600_33500 0.0196
R_VDD9_18601 METAL5_3060600_33500 METAL5_3060600_40000 0.026
R_VDD9_18602 METAL5_3060600_40000 METAL5_3060600_40600 0.0024
R_VDD9_18603 METAL5_3060600_40600 METAL5_3060600_52000 0.0456
R_VDD9_18604 METAL5_3060600_52000 METAL5_3060600_52600 0.0024
R_VDD9_18605 METAL5_3060600_52600 METAL5_3060600_64000 0.0456
R_VDD9_18606 METAL5_3060600_64000 METAL5_3060600_64600 0.0024
R_VDD9_18607 METAL5_3060600_64600 METAL5_3060600_71600 0.028
R_VDD9_18608 METAL5_3060600_71600 METAL5_3060600_76000 0.0176
R_VDD9_18609 METAL5_3060600_76000 METAL5_3060600_76600 0.0024
R_VDD9_18610 METAL5_3060600_76600 METAL6_3060600_76600 0.1
R_VDD9_18611 METAL6_3060600_76600 METAL6_3060600_83600 0.014
R_VDD9_18612 METAL6_3060600_83600 METAL6_3060600_88000 0.0088
R_VDD9_18613 METAL6_3060600_88000 METAL6_3060600_88600 0.0012
R_VDD9_18614 METAL6_3060600_88600 METAL6_3060600_95600 0.014
R_VDD9_18615 METAL6_3060600_95600 METAL6_3060600_100000 0.0088
R_VDD9_18616 METAL6_3060600_100000 METAL6_3060600_100600 0.0012
R_VDD9_18617 METAL6_3060600_100600 METAL6_3060600_112000 0.0228
R_VDD9_18618 METAL6_3060600_112000 METAL6_3060600_147600 0.0712
R_VDD9_18619 METAL6_3060600_147600 METAL6_3060600_159600 0.024
R_VDD9_18620 METAL6_3060600_159600 METAL6_3060600_164000 0.0088
R_VDD9_18621 METAL6_3060600_164000 METAL6_3060600_166600 0.0052
R_VDD9_18622 METAL6_3060600_166600 METAL6_3060600_171600 0.01
R_VDD9_18623 METAL6_3060600_171600 METAL6_3060600_176000 0.0088
R_VDD9_18624 METAL6_3060600_176000 METAL6_3060600_178600 0.0052
R_VDD9_18625 METAL6_3060600_178600 METAL5_3060600_178600 0.1
R_VDD9_18626 METAL5_3060600_178600 METAL5_3060600_188000 0.0376
R_VDD9_18627 METAL5_3060600_188000 METAL5_3060600_190600 0.0104
R_VDD9_18628 METAL5_3060600_190600 METAL5_3060600_200000 0.0376
R_VDD9_18629 METAL5_3060600_200000 METAL5_3060600_202600 0.0104
R_VDD9_18630 METAL5_3060600_202600 METAL5_3060600_212000 0.0376
R_VDD9_18631 METAL5_3060600_212000 METAL5_3060600_214600 0.0104
R_VDD9_18632 METAL5_3060600_214600 METAL6_3060600_214600 0.1
R_VDD9_18633 METAL6_3060600_214600 METAL6_3060600_236300 0.0434
R_VDD9_18634 METAL6_3060600_236300 METAL6_3052000_236300 0.0172
R_VDD9_18635 METAL6_3052000_236300 METAL6_3035200_236300 0.0336
R_VDD9_18636 METAL6_3035200_236300 METAL6_3024000_236300 0.0224
R_VDD9_18637 METAL6_3024000_236300 METAL6_3023200_236300 0.0016
R_VDD9_18638 METAL6_3023200_236300 METAL6_3018200_236300 0.01
R_VDD9_18639 METAL6_3018200_236300 METAL6_3012000_236300 0.0124
R_VDD9_18640 METAL6_3012000_236300 METAL6_3011200_236300 0.0016
R_VDD9_18641 METAL6_3011200_236300 METAL6_3006200_236300 0.01
R_VDD9_18642 METAL6_3006200_236300 METAL6_3000000_236300 0.0124
R_VDD9_18643 METAL6_3000000_236300 METAL6_2994200_236300 0.0116
R_VDD9_18644 METAL6_2994200_236300 METAL6_2993000_236300 0.0024
R_VDD9_18645 METAL6_2993000_236300 METAL6_2988000_236300 0.01
R_VDD9_18646 METAL6_2988000_236300 METAL6_2987200_236300 0.0016
R_VDD9_18647 METAL6_2987200_236300 METAL6_2982200_236300 0.01
R_VDD9_18648 METAL6_2982200_236300 METAL6_2976000_236300 0.0124
R_VDD9_18649 METAL6_2976000_236300 METAL6_2975200_236300 0.0016
R_VDD9_18650 METAL6_2975200_236300 METAL6_2970200_236300 0.01
R_VDD9_18651 METAL6_2970200_236300 METAL6_2965900_236300 0.0086
R_VDD9_18652 METAL6_2965900_236300 METAL6_2963200_236300 0.0054
R_VDD9_18653 METAL6_2963200_236300 METAL6_2958200_236300 0.01
R_VDD9_18654 METAL6_2958200_236300 METAL6_2951900_236300 0.0126
R_VDD9_18655 METAL6_2951900_236300 METAL6_2942200_236300 0.0194
R_VDD9_18656 METAL6_2942200_236300 METAL6_2930200_236300 0.024
R_VDD9_18657 METAL6_2930200_236300 METAL6_2925600_236300 0.0092
R_VDD9_18658 METAL6_2925600_236300 METAL6_2918200_236300 0.0148
R_VDD9_18659 METAL6_2918200_236300 METAL6_2913600_236300 0.0092
R_VDD9_18660 METAL6_2913600_236300 METAL6_2910900_236300 0.0054
R_VDD9_18661 METAL6_2910900_236300 METAL6_2901600_236300 0.0186
R_VDD9_18662 METAL6_2901600_236300 METAL6_2898900_236300 0.0054
R_VDD9_18663 METAL6_2898900_236300 METAL6_2897100_236300 0.0036
R_VDD9_18664 METAL6_2897100_236300 METAL6_2886900_236300 0.0204
R_VDD9_18665 METAL6_2886900_236300 METAL6_2874900_236300 0.024
R_VDD9_18666 METAL6_2874900_236300 METAL6_2874800_236300 0.0002
R_VDD9_18667 METAL6_2874800_236300 METAL6_2862800_236300 0.024
R_VDD9_18668 METAL6_2862800_236300 METAL6_2860600_236300 0.0044
R_VDD9_18669 METAL6_2860600_236300 METAL6_2850800_236300 0.0196
R_VDD9_18670 METAL6_2850800_236300 METAL6_2846600_236300 0.0084
R_VDD9_18671 METAL6_2846600_236300 METAL6_2843800_236300 0.0056
R_VDD9_18672 METAL6_2843800_236300 METAL6_2824000_236300 0.0396
R_VDD9_18673 METAL6_2824000_236300 METAL6_2817600_236300 0.0128
R_VDD9_18674 METAL6_2817600_236300 METAL6_2812000_236300 0.0112
R_VDD9_18675 METAL6_2812000_236300 METAL6_2810800_236300 0.0024
R_VDD9_18676 METAL6_2810800_236300 METAL6_2805600_236300 0.0104
R_VDD9_18677 METAL6_2805600_236300 METAL6_2800000_236300 0.0112
R_VDD9_18678 METAL6_2800000_236300 METAL6_2798800_236300 0.0024
R_VDD9_18679 METAL6_2798800_236300 METAL6_2793600_236300 0.0104
R_VDD9_18680 METAL6_2793600_236300 METAL6_2788000_236300 0.0112
R_VDD9_18681 METAL6_2788000_236300 METAL6_2786800_236300 0.0024
R_VDD9_18682 METAL6_2786800_236300 METAL6_2781600_236300 0.0104
R_VDD9_18683 METAL6_2781600_236300 METAL6_2769600_236300 0.024
R_VDD9_18684 METAL6_2769600_236300 METAL6_2765900_236300 0.0074
R_VDD9_18685 METAL6_2765900_236300 METAL6_2751900_236300 0.028
R_VDD9_18686 METAL6_2751900_236300 METAL6_2728200_236300 0.0474
R_VDD9_18687 METAL6_2728200_236300 METAL6_2710900_236300 0.0346
R_VDD9_18688 METAL6_2710900_236300 METAL6_2698900_236300 0.024
R_VDD9_18689 METAL6_2698900_236300 METAL6_2686900_236300 0.024
R_VDD9_18690 METAL6_2686900_236300 METAL6_2683200_236300 0.0074
R_VDD9_18691 METAL6_2683200_236300 METAL6_2676200_236300 0.014
R_VDD9_18692 METAL6_2676200_236300 METAL6_2664200_236300 0.024
R_VDD9_18693 METAL6_2664200_236300 METAL6_2660600_236300 0.0072
R_VDD9_18694 METAL6_2660600_236300 METAL6_2652200_236300 0.0168
R_VDD9_18695 METAL6_2652200_236300 METAL6_2646600_236300 0.0112
R_VDD9_18696 METAL6_2646600_236300 METAL6_2604400_236300 0.0844
R_VDD9_18697 METAL6_2604400_236300 METAL6_2592400_236300 0.024
R_VDD9_18698 METAL6_2592400_236300 METAL6_2580400_236300 0.024
R_VDD9_18699 METAL6_2580400_236300 METAL6_2568400_236300 0.024
R_VDD9_18700 METAL6_2568400_236300 METAL6_2565900_236300 0.005
R_VDD9_18701 METAL6_2565900_236300 METAL6_2556400_236300 0.019
R_VDD9_18702 METAL6_2556400_236300 METAL6_2551900_236300 0.009
R_VDD9_18703 METAL6_2551900_236300 METAL6_2548000_236300 0.0078
R_VDD9_18704 METAL6_2548000_236300 METAL6_2537600_236300 0.0208
R_VDD9_18705 METAL6_2537600_236300 METAL6_2536000_236300 0.0032
R_VDD9_18706 METAL6_2536000_236300 METAL6_2535400_236300 0.0012
R_VDD9_18707 METAL6_2535400_236300 METAL6_2529000_236300 0.0128
R_VDD9_18708 METAL6_2529000_236300 METAL6_2528400_236300 0.0012
R_VDD9_18709 METAL6_2528400_236300 METAL6_2525600_236300 0.0056
R_VDD9_18710 METAL6_2525600_236300 METAL6_2524000_236300 0.0032
R_VDD9_18711 METAL6_2524000_236300 METAL6_2517000_236300 0.014
R_VDD9_18712 METAL6_2517000_236300 METAL6_2516400_236300 0.0012
R_VDD9_18713 METAL6_2516400_236300 METAL6_2513600_236300 0.0056
R_VDD9_18714 METAL6_2513600_236300 METAL6_2512000_236300 0.0032
R_VDD9_18715 METAL6_2512000_236300 METAL6_2510900_236300 0.0022
R_VDD9_18716 METAL6_2510900_236300 METAL6_2505000_236300 0.0118
R_VDD9_18717 METAL6_2505000_236300 METAL6_2504400_236300 0.0012
R_VDD9_18718 METAL6_2504400_236300 METAL6_2501600_236300 0.0056
R_VDD9_18719 METAL6_2501600_236300 METAL6_2500000_236300 0.0032
R_VDD9_18720 METAL6_2500000_236300 METAL6_2498900_236300 0.0022
R_VDD9_18721 METAL6_2498900_236300 METAL6_2496600_236300 0.0046
R_VDD9_18722 METAL6_2496600_236300 METAL6_2493000_236300 0.0072
R_VDD9_18723 METAL6_2493000_236300 METAL6_2492400_236300 0.0012
R_VDD9_18724 METAL6_2492400_236300 METAL6_2489600_236300 0.0056
R_VDD9_18725 METAL6_2489600_236300 METAL6_2488000_236300 0.0032
R_VDD9_18726 METAL6_2488000_236300 METAL6_2486900_236300 0.0022
R_VDD9_18727 METAL6_2486900_236300 METAL5_2486900_236300 0.1
R_VDD9_18728 METAL5_2486900_236300 METAL5_2486900_248300 0.048
R_VDD9_18729 METAL5_2486900_248300 METAL5_2486900_251000 0.0108
R_VDD9_18730 METAL5_2486900_251000 METAL5_2486900_260300 0.0372
R_VDD9_18731 METAL5_2486900_260300 METAL6_2486900_260300 0.1
R_VDD9_18732 METAL6_2486900_260300 METAL6_2484600_260300 0.0046
R_VDD9_18733 METAL6_2484600_260300 METAL6_2482600_260300 0.004
R_VDD9_18734 METAL6_2482600_260300 METAL6_2481000_260300 0.0032
R_VDD9_18735 METAL6_2481000_260300 METAL6_2480400_260300 0.0012
R_VDD9_18736 METAL6_2480400_260300 METAL6_2477600_260300 0.0056
R_VDD9_18737 METAL6_2477600_260300 METAL6_2476000_260300 0.0032
R_VDD9_18738 METAL6_2476000_260300 METAL6_2472600_260300 0.0068
R_VDD9_18739 METAL6_2472600_260300 METAL6_2470600_260300 0.004
R_VDD9_18740 METAL6_2470600_260300 METAL6_2469000_260300 0.0032
R_VDD9_18741 METAL6_2469000_260300 METAL6_2468400_260300 0.0012
R_VDD9_18742 METAL6_2468400_260300 METAL6_2465600_260300 0.0056
R_VDD9_18743 METAL6_2465600_260300 METAL6_2464000_260300 0.0032
R_VDD9_18744 METAL6_2464000_260300 METAL6_2460600_260300 0.0068
R_VDD9_18745 METAL6_2460600_260300 METAL6_2458600_260300 0.004
R_VDD9_18746 METAL6_2458600_260300 METAL6_2457000_260300 0.0032
R_VDD9_18747 METAL6_2457000_260300 METAL6_2452000_260300 0.01
R_VDD9_18748 METAL6_2452000_260300 METAL6_2448600_260300 0.0068
R_VDD9_18749 METAL6_2448600_260300 METAL6_2446600_260300 0.004
R_VDD9_18750 METAL6_2446600_260300 METAL6_2440000_260300 0.0132
R_VDD9_18751 METAL6_2440000_260300 METAL6_2436600_260300 0.0068
R_VDD9_18752 METAL6_2436600_260300 METAL6_2434600_260300 0.004
R_VDD9_18753 METAL6_2434600_260300 METAL6_2424600_260300 0.02
R_VDD9_18754 METAL6_2424600_260300 METAL6_2422600_260300 0.004
R_VDD9_18755 METAL6_2422600_260300 METAL6_2419100_260300 0.007
R_VDD9_18756 METAL6_2419100_260300 METAL6_2407100_260300 0.024
R_VDD9_18757 METAL6_2407100_260300 METAL6_2405600_260300 0.003
R_VDD9_18758 METAL6_2405600_260300 METAL6_2402100_260300 0.007
R_VDD9_18759 METAL6_2402100_260300 METAL6_2395100_260300 0.014
R_VDD9_18760 METAL6_2395100_260300 METAL6_2393600_260300 0.003
R_VDD9_18761 METAL6_2393600_260300 METAL6_2383100_260300 0.021
R_VDD9_18762 METAL6_2383100_260300 METAL6_2381600_260300 0.003
R_VDD9_18763 METAL6_2381600_260300 METAL6_2371100_260300 0.021
R_VDD9_18764 METAL6_2371100_260300 METAL6_2369600_260300 0.003
R_VDD9_18765 METAL6_2369600_260300 METAL6_2365900_260300 0.0074
R_VDD9_18766 METAL6_2365900_260300 METAL6_2357600_260300 0.0166
R_VDD9_18767 METAL6_2357600_260300 METAL6_2351900_260300 0.0114
R_VDD9_18768 METAL6_2351900_260300 METAL6_2343700_260300 0.0164
R_VDD9_18769 METAL6_2343700_260300 METAL6_2332600_260300 0.0222
R_VDD9_18770 METAL6_2332600_260300 METAL6_2322900_260300 0.0194
R_VDD9_18771 METAL6_2322900_260300 METAL6_2320600_260300 0.0046
R_VDD9_18772 METAL6_2320600_260300 METAL6_2310900_260300 0.0194
R_VDD9_18773 METAL6_2310900_260300 METAL6_2308600_260300 0.0046
R_VDD9_18774 METAL6_2308600_260300 METAL6_2298900_260300 0.0194
R_VDD9_18775 METAL6_2298900_272300 METAL6_2298900_260300 0.024
R_VDD9_18776 METAL6_2498900_272300 METAL6_2498900_260300 0.024
R_VDD9_18777 METAL6_2500000_236300 METAL5_2500000_236300 0.1
R_VDD9_18778 METAL5_2500000_236300 METAL5_2500000_248300 0.048
R_VDD9_18779 METAL5_2500000_248300 METAL5_2498900_248300 0.0044
R_VDD9_18780 METAL5_2498900_248300 METAL5_2498900_251000 0.0108
R_VDD9_18781 METAL5_2498900_251000 METAL5_2498900_260300 0.0372
R_VDD9_18782 METAL5_2498900_260300 METAL6_2498900_260300 0.1
I_VDD9_65 METAL6_2298900_272300 gnd 0.003
I_VDD9_66 METAL6_2498900_272300 gnd 0.003

V_VDD_111a_27 METAL5_3500000_2400000 gnd 5
V_VDD_111a_28 METAL5_0_1250000 gnd 5
R_VDD_111a_18783 METAL5_3500000_2400000 METAL5_3490500_2400000 0.038
R_VDD_111a_18784 METAL5_3490500_2400000 METAL5_3478500_2400000 0.048
R_VDD_111a_18785 METAL5_3478500_2400000 METAL5_3477000_2400000 0.006
R_VDD_111a_18786 METAL5_3477000_2400000 METAL5_3466500_2400000 0.042
R_VDD_111a_18787 METAL5_3466500_2400000 METAL5_3466500_2401000 0.004
R_VDD_111a_18788 METAL5_3466500_2401000 METAL6_3466500_2401000 0.1
R_VDD_111a_18789 METAL6_3466500_2401000 METAL6_3465000_2401000 0.003
R_VDD_111a_18790 METAL6_3465000_2401000 METAL6_3454500_2401000 0.021
R_VDD_111a_18791 METAL6_3454500_2401000 METAL6_3453000_2401000 0.003
R_VDD_111a_18792 METAL6_3453000_2401000 METAL6_3442500_2401000 0.021
R_VDD_111a_18793 METAL6_3442500_2401000 METAL6_3372400_2401000 0.1402
R_VDD_111a_18794 METAL6_3372400_2401000 METAL6_3360400_2401000 0.024
R_VDD_111a_18795 METAL6_3360400_2401000 METAL6_3348400_2401000 0.024
R_VDD_111a_18796 METAL6_3348400_2401000 METAL6_3336400_2401000 0.024
R_VDD_111a_18797 METAL6_3336400_2401000 METAL6_3324400_2401000 0.024
R_VDD_111a_18798 METAL6_3324400_2401000 METAL6_3312400_2401000 0.024
R_VDD_111a_18799 METAL6_3312400_2401000 METAL6_3312000_2401000 0.0008
R_VDD_111a_18800 METAL6_3312000_2401000 METAL6_3305400_2401000 0.0132
R_VDD_111a_18801 METAL6_3305400_2401000 METAL6_3300400_2401000 0.01
R_VDD_111a_18802 METAL6_3300400_2401000 METAL6_3300400_2400000 0.002
R_VDD_111a_18803 METAL6_3300400_2400000 METAL6_3300400_2395000 0.01
R_VDD_111a_18804 METAL6_3300400_2395000 METAL6_3300400_2389000 0.012
R_VDD_111a_18805 METAL6_3300400_2389000 METAL6_3300400_2388000 0.002
R_VDD_111a_18806 METAL6_3300400_2388000 METAL6_3300400_2377000 0.022
R_VDD_111a_18807 METAL6_3300400_2377000 METAL6_3300400_2376000 0.002
R_VDD_111a_18808 METAL6_3300400_2376000 METAL6_3300400_2374000 0.004
R_VDD_111a_18809 METAL6_3300400_2374000 METAL6_3300400_2365000 0.018
R_VDD_111a_18810 METAL6_3300400_2365000 METAL6_3300400_2364000 0.002
R_VDD_111a_18811 METAL6_3300400_2364000 METAL6_3300000_2364000 0.0008
R_VDD_111a_18812 METAL6_3300000_2364000 METAL6_3299000_2364000 0.002
R_VDD_111a_18813 METAL6_3299000_2364000 METAL6_3288400_2364000 0.0212
R_VDD_111a_18814 METAL6_3288400_2364000 METAL6_3288000_2364000 0.0008
R_VDD_111a_18815 METAL6_3288000_2364000 METAL6_3287000_2364000 0.002
R_VDD_111a_18816 METAL6_3287000_2364000 METAL6_3276400_2364000 0.0212
R_VDD_111a_18817 METAL6_3276400_2364000 METAL6_3275000_2364000 0.0028
R_VDD_111a_18818 METAL6_3275000_2364000 METAL6_3263000_2364000 0.024
R_VDD_111a_18819 METAL6_3263000_2364000 METAL6_3260400_2364000 0.0052
R_VDD_111a_18820 METAL6_3260400_2364000 METAL6_3255500_2364000 0.0098
R_VDD_111a_18821 METAL6_3255500_2364000 METAL6_3243500_2364000 0.024
R_VDD_111a_18822 METAL6_3243500_2364000 METAL6_3231500_2364000 0.024
R_VDD_111a_18823 METAL6_3231500_2364000 METAL6_3224500_2364000 0.014
R_VDD_111a_18824 METAL6_3224500_2364000 METAL6_3219500_2364000 0.01
R_VDD_111a_18825 METAL6_3219500_2364000 METAL6_3212500_2364000 0.014
R_VDD_111a_18826 METAL6_3212500_2364000 METAL6_3212000_2364000 0.001
R_VDD_111a_18827 METAL6_3212000_2364000 METAL6_3207500_2364000 0.009
R_VDD_111a_18828 METAL6_3207500_2364000 METAL6_3200500_2364000 0.014
R_VDD_111a_18829 METAL6_3200500_2364000 METAL6_3200000_2364000 0.001
R_VDD_111a_18830 METAL6_3200000_2364000 METAL6_3188000_2364000 0.024
R_VDD_111a_18831 METAL6_3188000_2364000 METAL6_3179500_2364000 0.017
R_VDD_111a_18832 METAL6_3179500_2364000 METAL6_3167500_2364000 0.024
R_VDD_111a_18833 METAL6_3167500_2364000 METAL6_3165900_2364000 0.0032
R_VDD_111a_18834 METAL6_3165900_2364000 METAL6_3155500_2364000 0.0208
R_VDD_111a_18835 METAL6_3155500_2364000 METAL6_3124000_2364000 0.063
R_VDD_111a_18836 METAL6_3124000_2364000 METAL6_3123200_2364000 0.0016
R_VDD_111a_18837 METAL6_3123200_2364000 METAL6_3112000_2364000 0.0224
R_VDD_111a_18838 METAL6_3112000_2364000 METAL6_3111200_2364000 0.0016
R_VDD_111a_18839 METAL6_3111200_2364000 METAL6_3110900_2364000 0.0006
R_VDD_111a_18840 METAL6_3110900_2364000 METAL6_3100000_2364000 0.0218
R_VDD_111a_18841 METAL6_3100000_2364000 METAL6_3099200_2364000 0.0016
R_VDD_111a_18842 METAL6_3099200_2364000 METAL6_3098900_2364000 0.0006
R_VDD_111a_18843 METAL6_3098900_2364000 METAL6_3088000_2364000 0.0218
R_VDD_111a_18844 METAL6_3088000_2364000 METAL6_3087200_2364000 0.0016
R_VDD_111a_18845 METAL6_3087200_2364000 METAL6_3086900_2364000 0.0006
R_VDD_111a_18846 METAL6_3086900_2364000 METAL6_3076000_2364000 0.0218
R_VDD_111a_18847 METAL6_3076000_2364000 METAL6_3075200_2364000 0.0016
R_VDD_111a_18848 METAL6_3075200_2364000 METAL6_3072600_2364000 0.0052
R_VDD_111a_18849 METAL6_3072600_2364000 METAL6_3068200_2364000 0.0088
R_VDD_111a_18850 METAL6_3068200_2364000 METAL6_3064000_2364000 0.0084
R_VDD_111a_18851 METAL6_3064000_2364000 METAL6_3063200_2364000 0.0016
R_VDD_111a_18852 METAL6_3063200_2364000 METAL6_3060600_2364000 0.0052
R_VDD_111a_18853 METAL6_3060600_2364000 METAL6_3052000_2364000 0.0172
R_VDD_111a_18854 METAL6_3052000_2364000 METAL6_3048600_2364000 0.0068
R_VDD_111a_18855 METAL6_3048600_2364000 METAL6_3035200_2364000 0.0268
R_VDD_111a_18856 METAL6_3035200_2364000 METAL6_3024000_2364000 0.0224
R_VDD_111a_18857 METAL6_3024000_2364000 METAL6_3023200_2364000 0.0016
R_VDD_111a_18858 METAL6_3023200_2364000 METAL6_3018200_2364000 0.01
R_VDD_111a_18859 METAL6_3018200_2364000 METAL6_3012000_2364000 0.0124
R_VDD_111a_18860 METAL6_3012000_2364000 METAL6_3011200_2364000 0.0016
R_VDD_111a_18861 METAL6_3011200_2364000 METAL6_3006200_2364000 0.01
R_VDD_111a_18862 METAL6_3006200_2364000 METAL6_3000000_2364000 0.0124
R_VDD_111a_18863 METAL6_3000000_2364000 METAL6_2994200_2364000 0.0116
R_VDD_111a_18864 METAL6_2994200_2364000 METAL6_2993000_2364000 0.0024
R_VDD_111a_18865 METAL6_2993000_2364000 METAL6_2988000_2364000 0.01
R_VDD_111a_18866 METAL6_2988000_2364000 METAL6_2987200_2364000 0.0016
R_VDD_111a_18867 METAL6_2987200_2364000 METAL6_2982200_2364000 0.01
R_VDD_111a_18868 METAL6_2982200_2364000 METAL6_2976000_2364000 0.0124
R_VDD_111a_18869 METAL6_2976000_2364000 METAL6_2975200_2364000 0.0016
R_VDD_111a_18870 METAL6_2975200_2364000 METAL6_2970200_2364000 0.01
R_VDD_111a_18871 METAL6_2970200_2364000 METAL6_2965900_2364000 0.0086
R_VDD_111a_18872 METAL6_2965900_2364000 METAL6_2963200_2364000 0.0054
R_VDD_111a_18873 METAL6_2963200_2364000 METAL6_2958200_2364000 0.01
R_VDD_111a_18874 METAL6_2958200_2364000 METAL6_2951900_2364000 0.0126
R_VDD_111a_18875 METAL6_2951900_2364000 METAL6_2942200_2364000 0.0194
R_VDD_111a_18876 METAL6_2942200_2364000 METAL6_2930200_2364000 0.024
R_VDD_111a_18877 METAL6_2930200_2364000 METAL6_2925600_2364000 0.0092
R_VDD_111a_18878 METAL6_2925600_2364000 METAL6_2918200_2364000 0.0148
R_VDD_111a_18879 METAL6_2918200_2364000 METAL6_2913600_2364000 0.0092
R_VDD_111a_18880 METAL6_2913600_2364000 METAL6_2910900_2364000 0.0054
R_VDD_111a_18881 METAL6_2910900_2364000 METAL6_2901600_2364000 0.0186
R_VDD_111a_18882 METAL6_2901600_2364000 METAL6_2898900_2364000 0.0054
R_VDD_111a_18883 METAL6_2898900_2364000 METAL6_2897100_2364000 0.0036
R_VDD_111a_18884 METAL6_2897100_2364000 METAL6_2886900_2364000 0.0204
R_VDD_111a_18885 METAL6_2886900_2364000 METAL6_2886800_2364000 0.0002
R_VDD_111a_18886 METAL6_2886800_2364000 METAL6_2874900_2364000 0.0238
R_VDD_111a_18887 METAL6_2874900_2364000 METAL6_2874800_2364000 0.0002
R_VDD_111a_18888 METAL6_2874800_2364000 METAL6_2862800_2364000 0.024
R_VDD_111a_18889 METAL6_2862800_2364000 METAL6_2860600_2364000 0.0044
R_VDD_111a_18890 METAL6_2860600_2364000 METAL6_2850800_2364000 0.0196
R_VDD_111a_18891 METAL6_2850800_2364000 METAL6_2846600_2364000 0.0084
R_VDD_111a_18892 METAL6_2846600_2364000 METAL6_2843800_2364000 0.0056
R_VDD_111a_18893 METAL6_2843800_2364000 METAL6_2824000_2364000 0.0396
R_VDD_111a_18894 METAL6_2824000_2364000 METAL6_2817600_2364000 0.0128
R_VDD_111a_18895 METAL6_2817600_2364000 METAL6_2812000_2364000 0.0112
R_VDD_111a_18896 METAL6_2812000_2364000 METAL6_2810800_2364000 0.0024
R_VDD_111a_18897 METAL6_2810800_2364000 METAL6_2805600_2364000 0.0104
R_VDD_111a_18898 METAL6_2805600_2364000 METAL6_2800000_2364000 0.0112
R_VDD_111a_18899 METAL6_2800000_2364000 METAL6_2798800_2364000 0.0024
R_VDD_111a_18900 METAL6_2798800_2364000 METAL6_2793600_2364000 0.0104
R_VDD_111a_18901 METAL6_2793600_2364000 METAL6_2788000_2364000 0.0112
R_VDD_111a_18902 METAL6_2788000_2364000 METAL6_2786800_2364000 0.0024
R_VDD_111a_18903 METAL6_2786800_2364000 METAL6_2781600_2364000 0.0104
R_VDD_111a_18904 METAL6_2781600_2364000 METAL6_2769600_2364000 0.024
R_VDD_111a_18905 METAL6_2769600_2364000 METAL6_2765900_2364000 0.0074
R_VDD_111a_18906 METAL6_2765900_2364000 METAL6_2751900_2364000 0.028
R_VDD_111a_18907 METAL6_2751900_2364000 METAL6_2728200_2364000 0.0474
R_VDD_111a_18908 METAL6_2728200_2364000 METAL6_2710900_2364000 0.0346
R_VDD_111a_18909 METAL6_2710900_2364000 METAL6_2698900_2364000 0.024
R_VDD_111a_18910 METAL6_2698900_2364000 METAL6_2686900_2364000 0.024
R_VDD_111a_18911 METAL6_2686900_2364000 METAL6_2683200_2364000 0.0074
R_VDD_111a_18912 METAL6_2683200_2364000 METAL6_2676200_2364000 0.014
R_VDD_111a_18913 METAL6_2676200_2364000 METAL6_2664200_2364000 0.024
R_VDD_111a_18914 METAL6_2664200_2364000 METAL6_2660600_2364000 0.0072
R_VDD_111a_18915 METAL6_2660600_2364000 METAL6_2652200_2364000 0.0168
R_VDD_111a_18916 METAL6_2652200_2364000 METAL6_2646600_2364000 0.0112
R_VDD_111a_18917 METAL6_2646600_2364000 METAL6_2604400_2364000 0.0844
R_VDD_111a_18918 METAL6_2604400_2364000 METAL6_2592400_2364000 0.024
R_VDD_111a_18919 METAL6_2592400_2364000 METAL6_2580400_2364000 0.024
R_VDD_111a_18920 METAL6_2580400_2364000 METAL6_2568400_2364000 0.024
R_VDD_111a_18921 METAL6_2568400_2364000 METAL6_2565900_2364000 0.005
R_VDD_111a_18922 METAL6_2565900_2364000 METAL6_2556400_2364000 0.019
R_VDD_111a_18923 METAL6_2556400_2364000 METAL6_2551900_2364000 0.009
R_VDD_111a_18924 METAL6_2551900_2364000 METAL6_2548000_2364000 0.0078
R_VDD_111a_18925 METAL6_2548000_2364000 METAL6_2537600_2364000 0.0208
R_VDD_111a_18926 METAL6_2537600_2364000 METAL6_2536000_2364000 0.0032
R_VDD_111a_18927 METAL6_2536000_2364000 METAL6_2535400_2364000 0.0012
R_VDD_111a_18928 METAL6_2535400_2364000 METAL6_2529000_2364000 0.0128
R_VDD_111a_18929 METAL6_2529000_2364000 METAL6_2528400_2364000 0.0012
R_VDD_111a_18930 METAL6_2528400_2364000 METAL6_2525600_2364000 0.0056
R_VDD_111a_18931 METAL6_2525600_2364000 METAL6_2524000_2364000 0.0032
R_VDD_111a_18932 METAL6_2524000_2364000 METAL6_2517000_2364000 0.014
R_VDD_111a_18933 METAL6_2517000_2364000 METAL6_2516400_2364000 0.0012
R_VDD_111a_18934 METAL6_2516400_2364000 METAL5_2516400_2364000 0.1
R_VDD_111a_18935 METAL5_2516400_2364000 METAL5_2513600_2364000 0.0112
R_VDD_111a_18936 METAL5_2513600_2364000 METAL5_2512000_2364000 0.0064
R_VDD_111a_18937 METAL5_2512000_2364000 METAL5_2510900_2364000 0.0044
R_VDD_111a_18938 METAL5_2510900_2364000 METAL5_2505000_2364000 0.0236
R_VDD_111a_18939 METAL5_2505000_2364000 METAL5_2504400_2364000 0.0024
R_VDD_111a_18940 METAL5_2504400_2364000 METAL5_2501600_2364000 0.0112
R_VDD_111a_18941 METAL5_2501600_2364000 METAL5_2500000_2364000 0.0064
R_VDD_111a_18942 METAL5_2500000_2364000 METAL5_2498900_2364000 0.0044
R_VDD_111a_18943 METAL5_2498900_2364000 METAL5_2496600_2364000 0.0092
R_VDD_111a_18944 METAL5_2496600_2364000 METAL5_2493000_2364000 0.0144
R_VDD_111a_18945 METAL5_2493000_2364000 METAL5_2492400_2364000 0.0024
R_VDD_111a_18946 METAL5_2492400_2364000 METAL5_2489600_2364000 0.0112
R_VDD_111a_18947 METAL5_2489600_2364000 METAL5_2488000_2364000 0.0064
R_VDD_111a_18948 METAL5_2488000_2364000 METAL5_2486900_2364000 0.0044
R_VDD_111a_18949 METAL5_2486900_2364000 METAL5_2484600_2364000 0.0092
R_VDD_111a_18950 METAL5_2484600_2364000 METAL5_2482600_2364000 0.008
R_VDD_111a_18951 METAL5_2482600_2364000 METAL5_2481000_2364000 0.0064
R_VDD_111a_18952 METAL5_2481000_2364000 METAL5_2480400_2364000 0.0024
R_VDD_111a_18953 METAL5_2480400_2364000 METAL5_2477600_2364000 0.0112
R_VDD_111a_18954 METAL5_2477600_2364000 METAL5_2476000_2364000 0.0064
R_VDD_111a_18955 METAL5_2476000_2364000 METAL5_2474900_2364000 0.0044
R_VDD_111a_18956 METAL5_2474900_2364000 METAL5_2472600_2364000 0.0092
R_VDD_111a_18957 METAL5_2472600_2364000 METAL5_2470600_2364000 0.008
R_VDD_111a_18958 METAL5_2470600_2364000 METAL5_2469000_2364000 0.0064
R_VDD_111a_18959 METAL5_2469000_2364000 METAL5_2468400_2364000 0.0024
R_VDD_111a_18960 METAL5_2468400_2364000 METAL6_2468400_2364000 0.1
R_VDD_111a_18961 METAL6_2468400_2364000 METAL6_2465600_2364000 0.0056
R_VDD_111a_18962 METAL6_2465600_2364000 METAL6_2464000_2364000 0.0032
R_VDD_111a_18963 METAL6_2464000_2364000 METAL6_2460600_2364000 0.0068
R_VDD_111a_18964 METAL6_2460600_2364000 METAL6_2458600_2364000 0.004
R_VDD_111a_18965 METAL6_2458600_2364000 METAL6_2457000_2364000 0.0032
R_VDD_111a_18966 METAL6_2457000_2364000 METAL6_2452000_2364000 0.01
R_VDD_111a_18967 METAL6_2452000_2364000 METAL6_2448600_2364000 0.0068
R_VDD_111a_18968 METAL6_2448600_2364000 METAL6_2446600_2364000 0.004
R_VDD_111a_18969 METAL6_2446600_2364000 METAL6_2440000_2364000 0.0132
R_VDD_111a_18970 METAL6_2440000_2364000 METAL6_2436600_2364000 0.0068
R_VDD_111a_18971 METAL6_2436600_2364000 METAL6_2434600_2364000 0.004
R_VDD_111a_18972 METAL6_2434600_2364000 METAL6_2424600_2364000 0.02
R_VDD_111a_18973 METAL6_2424600_2364000 METAL6_2422600_2364000 0.004
R_VDD_111a_18974 METAL6_2422600_2364000 METAL6_2419100_2364000 0.007
R_VDD_111a_18975 METAL6_2419100_2364000 METAL6_2407100_2364000 0.024
R_VDD_111a_18976 METAL6_2407100_2364000 METAL6_2405600_2364000 0.003
R_VDD_111a_18977 METAL6_2405600_2364000 METAL6_2402100_2364000 0.007
R_VDD_111a_18978 METAL6_2402100_2364000 METAL6_2395100_2364000 0.014
R_VDD_111a_18979 METAL6_2395100_2364000 METAL6_2393600_2364000 0.003
R_VDD_111a_18980 METAL6_2393600_2364000 METAL6_2383100_2364000 0.021
R_VDD_111a_18981 METAL6_2383100_2364000 METAL6_2381600_2364000 0.003
R_VDD_111a_18982 METAL6_2381600_2364000 METAL6_2371100_2364000 0.021
R_VDD_111a_18983 METAL6_2371100_2364000 METAL6_2369600_2364000 0.003
R_VDD_111a_18984 METAL6_2369600_2364000 METAL6_2365900_2364000 0.0074
R_VDD_111a_18985 METAL6_2365900_2364000 METAL6_2357600_2364000 0.0166
R_VDD_111a_18986 METAL6_2357600_2364000 METAL6_2351900_2364000 0.0114
R_VDD_111a_18987 METAL6_2351900_2364000 METAL6_2343700_2364000 0.0164
R_VDD_111a_18988 METAL6_2343700_2364000 METAL6_2332600_2364000 0.0222
R_VDD_111a_18989 METAL6_2332600_2364000 METAL6_2322900_2364000 0.0194
R_VDD_111a_18990 METAL6_2322900_2364000 METAL6_2320600_2364000 0.0046
R_VDD_111a_18991 METAL6_2320600_2364000 METAL6_2310900_2364000 0.0194
R_VDD_111a_18992 METAL6_2310900_2364000 METAL6_2308600_2364000 0.0046
R_VDD_111a_18993 METAL6_2308600_2364000 METAL6_2298900_2364000 0.0194
R_VDD_111a_18994 METAL6_2298900_2364000 METAL6_2296600_2364000 0.0046
R_VDD_111a_18995 METAL6_2296600_2364000 METAL6_2286900_2364000 0.0194
R_VDD_111a_18996 METAL6_2286900_2364000 METAL6_2284600_2364000 0.0046
R_VDD_111a_18997 METAL6_2284600_2364000 METAL6_2284400_2364000 0.0004
R_VDD_111a_18998 METAL6_2284400_2364000 METAL6_2274900_2364000 0.019
R_VDD_111a_18999 METAL6_2274900_2364000 METAL6_2272600_2364000 0.0046
R_VDD_111a_19000 METAL6_2272600_2364000 METAL6_2272400_2364000 0.0004
R_VDD_111a_19001 METAL6_2272400_2364000 METAL5_2272400_2364000 0.1
R_VDD_111a_19002 METAL5_2272400_2364000 METAL5_2260600_2364000 0.0472
R_VDD_111a_19003 METAL5_2260600_2364000 METAL5_2260400_2364000 0.0008
R_VDD_111a_19004 METAL5_2260400_2364000 METAL5_2258600_2364000 0.0072
R_VDD_111a_19005 METAL5_2258600_2364000 METAL5_2248700_2364000 0.0396
R_VDD_111a_19006 METAL5_2248700_2364000 METAL5_2248600_2364000 0.0004
R_VDD_111a_19007 METAL5_2248600_2364000 METAL5_2248400_2364000 0.0008
R_VDD_111a_19008 METAL5_2248400_2364000 METAL6_2248400_2364000 0.1
R_VDD_111a_19009 METAL6_2248400_2364000 METAL6_2248400_2362000 0.004
R_VDD_111a_19010 METAL6_2248400_2362000 METAL6_2248400_2353000 0.018
R_VDD_111a_19011 METAL6_2248400_2353000 METAL6_2246600_2353000 0.0036
R_VDD_111a_19012 METAL6_2246600_2353000 METAL6_2246600_2352000 0.002
R_VDD_111a_19013 METAL6_2246600_2352000 METAL6_2246600_2350000 0.004
R_VDD_111a_19014 METAL6_2246600_2350000 METAL6_2246600_2341000 0.018
R_VDD_111a_19015 METAL6_2246600_2341000 METAL6_2246600_2340000 0.002
R_VDD_111a_19016 METAL6_2246600_2340000 METAL6_2246600_2338000 0.004
R_VDD_111a_19017 METAL6_2246600_2338000 METAL6_2246600_2336000 0.004
R_VDD_111a_19018 METAL6_2246600_2336000 METAL6_2246600_2329000 0.014
R_VDD_111a_19019 METAL6_2246600_2329000 METAL6_2246600_2328000 0.002
R_VDD_111a_19020 METAL6_2246600_2328000 METAL6_2246600_2326000 0.004
R_VDD_111a_19021 METAL6_2246600_2326000 METAL6_2246600_2324000 0.004
R_VDD_111a_19022 METAL6_2246600_2324000 METAL6_2246600_2317000 0.014
R_VDD_111a_19023 METAL6_2246600_2317000 METAL6_2246600_2316000 0.002
R_VDD_111a_19024 METAL6_2246600_2316000 METAL6_2246600_2314000 0.004
R_VDD_111a_19025 METAL6_2246600_2314000 METAL6_2246600_2312000 0.004
R_VDD_111a_19026 METAL6_2246600_2312000 METAL6_2246600_2305000 0.014
R_VDD_111a_19027 METAL6_2246600_2305000 METAL6_2246600_2304000 0.002
R_VDD_111a_19028 METAL6_2246600_2304000 METAL6_2246600_2300000 0.008
R_VDD_111a_19029 METAL6_2246600_2300000 METAL6_2246600_2292000 0.016
R_VDD_111a_19030 METAL6_2246600_2292000 METAL6_2246600_2288000 0.008
R_VDD_111a_19031 METAL6_2246600_2288000 METAL6_2246600_2282500 0.011
R_VDD_111a_19032 METAL6_2246600_2282500 METAL6_2246600_2280500 0.004
R_VDD_111a_19033 METAL6_2246600_2280500 METAL6_2246600_2276000 0.009
R_VDD_111a_19034 METAL6_2246600_2276000 METAL6_2246600_2270500 0.011
R_VDD_111a_19035 METAL6_2246600_2270500 METAL6_2246600_2268500 0.004
R_VDD_111a_19036 METAL6_2246600_2268500 METAL6_2246600_2258500 0.02
R_VDD_111a_19037 METAL6_2246600_2258500 METAL6_2246600_2256500 0.004
R_VDD_111a_19038 METAL6_2246600_2256500 METAL6_2246600_2246500 0.02
R_VDD_111a_19039 METAL6_2246600_2246500 METAL6_2246600_2244500 0.004
R_VDD_111a_19040 METAL6_2246600_2244500 METAL6_2246600_2234500 0.02
R_VDD_111a_19041 METAL6_2246600_2234500 METAL6_2246600_2222500 0.024
R_VDD_111a_19042 METAL6_2246600_2222500 METAL6_2246600_2211000 0.023
R_VDD_111a_19043 METAL6_2246600_2211000 METAL6_2246600_2202300 0.0174
R_VDD_111a_19044 METAL6_2246600_2202300 METAL6_2245900_2202300 0.0014
R_VDD_111a_19045 METAL6_2245900_2202300 METAL6_2236700_2202300 0.0184
R_VDD_111a_19046 METAL6_2236700_2202300 METAL5_2236700_2202300 0.1
R_VDD_111a_19047 METAL5_2236700_2202300 METAL5_2236600_2202300 0.0004
R_VDD_111a_19048 METAL5_2236600_2202300 METAL5_2234600_2202300 0.008
R_VDD_111a_19049 METAL5_2234600_2202300 METAL5_2233900_2202300 0.0028
R_VDD_111a_19050 METAL5_2233900_2202300 METAL5_2224700_2202300 0.0368
R_VDD_111a_19051 METAL5_2224700_2202300 METAL5_2224600_2202300 0.0004
R_VDD_111a_19052 METAL5_2224600_2202300 METAL5_2222600_2202300 0.008
R_VDD_111a_19053 METAL5_2222600_2202300 METAL5_2221900_2202300 0.0028
R_VDD_111a_19054 METAL5_2221900_2202300 METAL5_2212700_2202300 0.0368
R_VDD_111a_19055 METAL5_2212700_2202300 METAL5_2212600_2202300 0.0004
R_VDD_111a_19056 METAL5_2212600_2202300 METAL5_2210600_2202300 0.008
R_VDD_111a_19057 METAL5_2210600_2202300 METAL5_2209900_2202300 0.0028
R_VDD_111a_19058 METAL5_2209900_2202300 METAL5_2200700_2202300 0.0368
R_VDD_111a_19059 METAL5_2200700_2202300 METAL5_2189900_2202300 0.0432
R_VDD_111a_19060 METAL5_2189900_2202300 METAL5_2188700_2202300 0.0048
R_VDD_111a_19061 METAL5_2188700_2202300 METAL5_2177900_2202300 0.0432
R_VDD_111a_19062 METAL5_2177900_2202300 METAL5_2176700_2202300 0.0048
R_VDD_111a_19063 METAL5_2176700_2202300 METAL5_2165900_2202300 0.0432
R_VDD_111a_19064 METAL5_2165900_2202300 METAL5_2165400_2202300 0.002
R_VDD_111a_19065 METAL5_2165400_2202300 METAL5_2153900_2202300 0.046
R_VDD_111a_19066 METAL5_2153900_2202300 METAL5_2153400_2202300 0.002
R_VDD_111a_19067 METAL5_2153400_2202300 METAL5_2151900_2202300 0.006
R_VDD_111a_19068 METAL5_2151900_2202300 METAL5_2141900_2202300 0.04
R_VDD_111a_19069 METAL5_2141900_2202300 METAL5_2141400_2202300 0.002
R_VDD_111a_19070 METAL5_2141400_2202300 METAL5_2129900_2202300 0.046
R_VDD_111a_19071 METAL5_2129900_2202300 METAL5_2129700_2202300 0.0008
R_VDD_111a_19072 METAL5_2129700_2202300 METAL5_2125600_2202300 0.0164
R_VDD_111a_19073 METAL5_2125600_2202300 METAL5_2121400_2202300 0.0168
R_VDD_111a_19074 METAL5_2121400_2202300 METAL5_2117900_2202300 0.014
R_VDD_111a_19075 METAL5_2117900_2202300 METAL6_2117900_2202300 0.1
R_VDD_111a_19076 METAL6_2117900_2202300 METAL6_2113900_2202300 0.008
R_VDD_111a_19077 METAL6_2113900_2202300 METAL6_2113900_2199000 0.0066
R_VDD_111a_19078 METAL6_2113900_2199000 METAL6_2113900_2190300 0.0174
R_VDD_111a_19079 METAL6_2113900_2190300 METAL6_2113900_2187000 0.0066
R_VDD_111a_19080 METAL6_2113900_2187000 METAL6_2113900_2178300 0.0174
R_VDD_111a_19081 METAL6_2113900_2178300 METAL6_2113600_2178300 0.0006
R_VDD_111a_19082 METAL6_2113600_2178300 METAL6_2105900_2178300 0.0154
R_VDD_111a_19083 METAL6_2105900_2178300 METAL6_2101900_2178300 0.008
R_VDD_111a_19084 METAL6_2101900_2178300 METAL6_2101600_2178300 0.0006
R_VDD_111a_19085 METAL6_2101600_2178300 METAL6_2091700_2178300 0.0198
R_VDD_111a_19086 METAL6_2091700_2178300 METAL6_2089900_2178300 0.0036
R_VDD_111a_19087 METAL6_2089900_2178300 METAL6_2079700_2178300 0.0204
R_VDD_111a_19088 METAL6_2079700_2178300 METAL6_2077900_2178300 0.0036
R_VDD_111a_19089 METAL6_2077900_2178300 METAL6_2067700_2178300 0.0204
R_VDD_111a_19090 METAL6_2067700_2178300 METAL6_2060600_2178300 0.0142
R_VDD_111a_19091 METAL6_2060600_2178300 METAL6_2058800_2178300 0.0036
R_VDD_111a_19092 METAL6_2058800_2178300 METAL6_2055700_2178300 0.0062
R_VDD_111a_19093 METAL6_2055700_2178300 METAL6_2046800_2178300 0.0178
R_VDD_111a_19094 METAL6_2046800_2178300 METAL6_2046600_2178300 0.0004
R_VDD_111a_19095 METAL6_2046600_2178300 METAL6_2046400_2178300 0.0004
R_VDD_111a_19096 METAL6_2046400_2178300 METAL6_2043700_2178300 0.0054
R_VDD_111a_19097 METAL6_2043700_2178300 METAL6_2034800_2178300 0.0178
R_VDD_111a_19098 METAL6_2034800_2178300 METAL6_2031700_2178300 0.0062
R_VDD_111a_19099 METAL6_2031700_2178300 METAL6_2030900_2178300 0.0016
R_VDD_111a_19100 METAL6_2030900_2178300 METAL6_2026400_2178300 0.009
R_VDD_111a_19101 METAL6_2026400_2178300 METAL6_2021200_2178300 0.0104
R_VDD_111a_19102 METAL6_2021200_2178300 METAL6_2019700_2178300 0.003
R_VDD_111a_19103 METAL6_2019700_2178300 METAL6_2018900_2178300 0.0016
R_VDD_111a_19104 METAL6_2018900_2178300 METAL6_2014400_2178300 0.009
R_VDD_111a_19105 METAL6_2014400_2178300 METAL6_2012000_2178300 0.0048
R_VDD_111a_19106 METAL6_2012000_2178300 METAL6_2007700_2178300 0.0086
R_VDD_111a_19107 METAL6_2007700_2178300 METAL6_2006900_2178300 0.0016
R_VDD_111a_19108 METAL6_2006900_2178300 METAL6_2002400_2178300 0.009
R_VDD_111a_19109 METAL6_2002400_2178300 METAL6_2000000_2178300 0.0048
R_VDD_111a_19110 METAL6_2000000_2178300 METAL6_1988000_2178300 0.024
R_VDD_111a_19111 METAL6_1988000_2178300 METAL6_1975900_2178300 0.0242
R_VDD_111a_19112 METAL6_1975900_2178300 METAL6_1963900_2178300 0.024
R_VDD_111a_19113 METAL6_1963900_2178300 METAL6_1963800_2178300 0.0002
R_VDD_111a_19114 METAL6_1963800_2178300 METAL6_1951900_2178300 0.0238
R_VDD_111a_19115 METAL6_1951900_2178300 METAL6_1951800_2178300 0.0002
R_VDD_111a_19116 METAL6_1951800_2178300 METAL6_1939900_2178300 0.0238
R_VDD_111a_19117 METAL6_1939900_2178300 METAL6_1939800_2178300 0.0002
R_VDD_111a_19118 METAL6_1939800_2178300 METAL6_1937600_2178300 0.0044
R_VDD_111a_19119 METAL6_1937600_2178300 METAL6_1931200_2178300 0.0128
R_VDD_111a_19120 METAL6_1931200_2178300 METAL6_1927800_2178300 0.0068
R_VDD_111a_19121 METAL6_1927800_2178300 METAL6_1926200_2178300 0.0032
R_VDD_111a_19122 METAL6_1926200_2178300 METAL6_1925600_2178300 0.0012
R_VDD_111a_19123 METAL6_1925600_2178300 METAL6_1919200_2178300 0.0128
R_VDD_111a_19124 METAL6_1919200_2178300 METAL6_1913600_2178300 0.0112
R_VDD_111a_19125 METAL6_1913600_2178300 METAL6_1907400_2178300 0.0124
R_VDD_111a_19126 METAL6_1907400_2178300 METAL6_1907200_2178300 0.0004
R_VDD_111a_19127 METAL6_1907200_2178300 METAL6_1901600_2178300 0.0112
R_VDD_111a_19128 METAL6_1901600_2178300 METAL6_1901400_2178300 0.0004
R_VDD_111a_19129 METAL6_1901400_2178300 METAL6_1900700_2178300 0.0014
R_VDD_111a_19130 METAL6_1900700_2178300 METAL6_1895200_2178300 0.011
R_VDD_111a_19131 METAL6_1895200_2178300 METAL6_1889600_2178300 0.0112
R_VDD_111a_19132 METAL6_1889600_2178300 METAL6_1889400_2178300 0.0004
R_VDD_111a_19133 METAL6_1889400_2178300 METAL6_1888700_2178300 0.0014
R_VDD_111a_19134 METAL6_1888700_2178300 METAL6_1883200_2178300 0.011
R_VDD_111a_19135 METAL6_1883200_2178300 METAL6_1877600_2178300 0.0112
R_VDD_111a_19136 METAL6_1877600_2178300 METAL6_1877400_2178300 0.0004
R_VDD_111a_19137 METAL6_1877400_2178300 METAL6_1876700_2178300 0.0014
R_VDD_111a_19138 METAL6_1876700_2178300 METAL6_1874700_2178300 0.004
R_VDD_111a_19139 METAL6_1874700_2178300 METAL6_1871200_2178300 0.007
R_VDD_111a_19140 METAL6_1871200_2178300 METAL6_1870600_2178300 0.0012
R_VDD_111a_19141 METAL6_1870600_2178300 METAL6_1865600_2178300 0.01
R_VDD_111a_19142 METAL6_1865600_2178300 METAL6_1865400_2178300 0.0004
R_VDD_111a_19143 METAL6_1865400_2178300 METAL6_1864700_2178300 0.0014
R_VDD_111a_19144 METAL6_1864700_2178300 METAL6_1859200_2178300 0.011
R_VDD_111a_19145 METAL6_1859200_2178300 METAL6_1858600_2178300 0.0012
R_VDD_111a_19146 METAL6_1858600_2178300 METAL6_1858400_2178300 0.0004
R_VDD_111a_19147 METAL6_1858400_2178300 METAL6_1853400_2178300 0.01
R_VDD_111a_19148 METAL6_1853400_2178300 METAL6_1852700_2178300 0.0014
R_VDD_111a_19149 METAL6_1852700_2178300 METAL6_1847200_2178300 0.011
R_VDD_111a_19150 METAL6_1847200_2178300 METAL6_1846800_2178300 0.0008
R_VDD_111a_19151 METAL6_1846800_2178300 METAL6_1846600_2178300 0.0004
R_VDD_111a_19152 METAL6_1846600_2178300 METAL6_1846400_2178300 0.0004
R_VDD_111a_19153 METAL6_1846400_2178300 METAL6_1844800_2178300 0.0032
R_VDD_111a_19154 METAL6_1844800_2178300 METAL6_1841400_2178300 0.0068
R_VDD_111a_19155 METAL6_1841400_2178300 METAL6_1834600_2178300 0.0136
R_VDD_111a_19156 METAL6_1834600_2178300 METAL6_1834400_2178300 0.0004
R_VDD_111a_19157 METAL6_1834400_2178300 METAL6_1832800_2178300 0.0032
R_VDD_111a_19158 METAL6_1832800_2178300 METAL6_1822600_2178300 0.0204
R_VDD_111a_19159 METAL6_1822600_2178300 METAL6_1822400_2178300 0.0004
R_VDD_111a_19160 METAL6_1822400_2178300 METAL6_1820800_2178300 0.0032
R_VDD_111a_19161 METAL6_1820800_2178300 METAL6_1812000_2178300 0.0176
R_VDD_111a_19162 METAL6_1812000_2178300 METAL6_1810600_2178300 0.0028
R_VDD_111a_19163 METAL6_1810600_2178300 METAL6_1800000_2178300 0.0212
R_VDD_111a_19164 METAL6_1800000_2178300 METAL6_1788000_2178300 0.024
R_VDD_111a_19165 METAL6_1788000_2178300 METAL6_1787400_2178300 0.0012
R_VDD_111a_19166 METAL6_1787400_2178300 METAL6_1775400_2178300 0.024
R_VDD_111a_19167 METAL6_1775400_2178300 METAL6_1768000_2178300 0.0148
R_VDD_111a_19168 METAL6_1768000_2178300 METAL6_1767700_2178300 0.0006
R_VDD_111a_19169 METAL6_1767700_2178300 METAL6_1763800_2178300 0.0078
R_VDD_111a_19170 METAL6_1763800_2178300 METAL6_1763400_2178300 0.0008
R_VDD_111a_19171 METAL6_1763400_2178300 METAL6_1756000_2178300 0.0148
R_VDD_111a_19172 METAL6_1756000_2178300 METAL6_1755700_2178300 0.0006
R_VDD_111a_19173 METAL6_1755700_2178300 METAL6_1753800_2178300 0.0038
R_VDD_111a_19174 METAL6_1753800_2178300 METAL6_1751800_2178300 0.004
R_VDD_111a_19175 METAL6_1751800_2178300 METAL6_1751400_2178300 0.0008
R_VDD_111a_19176 METAL6_1751400_2178300 METAL6_1744000_2178300 0.0148
R_VDD_111a_19177 METAL6_1744000_2178300 METAL6_1743700_2178300 0.0006
R_VDD_111a_19178 METAL6_1743700_2178300 METAL6_1741800_2178300 0.0038
R_VDD_111a_19179 METAL6_1741800_2178300 METAL6_1739800_2178300 0.004
R_VDD_111a_19180 METAL6_1739800_2178300 METAL6_1739400_2178300 0.0008
R_VDD_111a_19181 METAL6_1739400_2178300 METAL6_1732000_2178300 0.0148
R_VDD_111a_19182 METAL6_1732000_2178300 METAL6_1731700_2178300 0.0006
R_VDD_111a_19183 METAL6_1731700_2178300 METAL6_1729800_2178300 0.0038
R_VDD_111a_19184 METAL6_1729800_2178300 METAL6_1727800_2178300 0.004
R_VDD_111a_19185 METAL6_1727800_2178300 METAL6_1719700_2178300 0.0162
R_VDD_111a_19186 METAL6_1719700_2178300 METAL6_1719700_2175000 0.0066
R_VDD_111a_19187 METAL6_1719700_2175000 METAL6_1719700_2166300 0.0174
R_VDD_111a_19188 METAL6_1719700_2166300 METAL6_1717800_2166300 0.0038
R_VDD_111a_19189 METAL6_1717800_2166300 METAL6_1710800_2166300 0.014
R_VDD_111a_19190 METAL6_1710800_2166300 METAL6_1707700_2166300 0.0062
R_VDD_111a_19191 METAL6_1707700_2166300 METAL6_1699000_2166300 0.0174
R_VDD_111a_19192 METAL6_1699000_2166300 METAL6_1692000_2166300 0.014
R_VDD_111a_19193 METAL6_1692000_2166300 METAL6_1682800_2166300 0.0184
R_VDD_111a_19194 METAL6_1682800_2166300 METAL6_1680000_2166300 0.0056
R_VDD_111a_19195 METAL6_1680000_2166300 METAL6_1670800_2166300 0.0184
R_VDD_111a_19196 METAL6_1670800_2166300 METAL6_1668000_2166300 0.0056
R_VDD_111a_19197 METAL6_1668000_2166300 METAL6_1660700_2166300 0.0146
R_VDD_111a_19198 METAL6_1660700_2166300 METAL6_1658800_2166300 0.0038
R_VDD_111a_19199 METAL6_1658800_2166300 METAL6_1648700_2166300 0.0202
R_VDD_111a_19200 METAL6_1648700_2166300 METAL6_1648000_2166300 0.0014
R_VDD_111a_19201 METAL6_1648000_2166300 METAL6_1646800_2166300 0.0024
R_VDD_111a_19202 METAL6_1646800_2166300 METAL6_1636700_2166300 0.0202
R_VDD_111a_19203 METAL6_1636700_2166300 METAL6_1636000_2166300 0.0014
R_VDD_111a_19204 METAL6_1636000_2166300 METAL6_1634800_2166300 0.0024
R_VDD_111a_19205 METAL6_1634800_2166300 METAL6_1632800_2166300 0.004
R_VDD_111a_19206 METAL6_1632800_2166300 METAL6_1627800_2166300 0.01
R_VDD_111a_19207 METAL6_1627800_2166300 METAL6_1624700_2166300 0.0062
R_VDD_111a_19208 METAL6_1624700_2166300 METAL6_1624000_2166300 0.0014
R_VDD_111a_19209 METAL6_1624000_2166300 METAL6_1615800_2166300 0.0164
R_VDD_111a_19210 METAL6_1615800_2166300 METAL6_1612700_2166300 0.0062
R_VDD_111a_19211 METAL6_1612700_2166300 METAL6_1612000_2166300 0.0014
R_VDD_111a_19212 METAL6_1612000_2166300 METAL6_1607900_2166300 0.0082
R_VDD_111a_19213 METAL6_1607900_2166300 METAL6_1603800_2166300 0.0082
R_VDD_111a_19214 METAL6_1603800_2166300 METAL6_1600700_2166300 0.0062
R_VDD_111a_19215 METAL6_1600700_2166300 METAL6_1600000_2166300 0.0014
R_VDD_111a_19216 METAL6_1600000_2166300 METAL6_1591800_2166300 0.0164
R_VDD_111a_19217 METAL6_1591800_2166300 METAL6_1588700_2166300 0.0062
R_VDD_111a_19218 METAL6_1588700_2166300 METAL6_1588000_2166300 0.0014
R_VDD_111a_19219 METAL6_1588000_2166300 METAL6_1579800_2166300 0.0164
R_VDD_111a_19220 METAL6_1579800_2166300 METAL6_1576700_2166300 0.0062
R_VDD_111a_19221 METAL6_1576700_2166300 METAL6_1576000_2166300 0.0014
R_VDD_111a_19222 METAL6_1576000_2166300 METAL6_1574700_2166300 0.0026
R_VDD_111a_19223 METAL6_1574700_2166300 METAL6_1569000_2166300 0.0114
R_VDD_111a_19224 METAL6_1569000_2166300 METAL6_1567800_2166300 0.0024
R_VDD_111a_19225 METAL6_1567800_2166300 METAL6_1564000_2166300 0.0076
R_VDD_111a_19226 METAL6_1564000_2166300 METAL6_1557000_2166300 0.014
R_VDD_111a_19227 METAL6_1557000_2166300 METAL6_1555400_2166300 0.0032
R_VDD_111a_19228 METAL6_1555400_2166300 METAL6_1552000_2166300 0.0068
R_VDD_111a_19229 METAL6_1552000_2166300 METAL6_1551800_2166300 0.0004
R_VDD_111a_19230 METAL6_1551800_2166300 METAL6_1545000_2166300 0.0136
R_VDD_111a_19231 METAL6_1545000_2166300 METAL6_1540000_2166300 0.01
R_VDD_111a_19232 METAL6_1540000_2166300 METAL6_1539800_2166300 0.0004
R_VDD_111a_19233 METAL6_1539800_2166300 METAL6_1528000_2166300 0.0236
R_VDD_111a_19234 METAL6_1528000_2166300 METAL6_1527800_2166300 0.0004
R_VDD_111a_19235 METAL6_1527800_2166300 METAL6_1512000_2166300 0.0316
R_VDD_111a_19236 METAL6_1512000_2166300 METAL6_1510400_2166300 0.0032
R_VDD_111a_19237 METAL6_1510400_2166300 METAL6_1503400_2166300 0.014
R_VDD_111a_19238 METAL6_1503400_2166300 METAL6_1500000_2166300 0.0068
R_VDD_111a_19239 METAL6_1500000_2166300 METAL6_1498300_2166300 0.0034
R_VDD_111a_19240 METAL6_1498300_2166300 METAL6_1491400_2166300 0.0138
R_VDD_111a_19241 METAL6_1491400_2166300 METAL6_1488000_2166300 0.0068
R_VDD_111a_19242 METAL6_1488000_2166300 METAL6_1479400_2166300 0.0172
R_VDD_111a_19243 METAL6_1479400_2166300 METAL6_1444800_2166300 0.0692
R_VDD_111a_19244 METAL6_1444800_2166300 METAL6_1443700_2166300 0.0022
R_VDD_111a_19245 METAL6_1443700_2166300 METAL6_1432800_2166300 0.0218
R_VDD_111a_19246 METAL6_1432800_2166300 METAL6_1431700_2166300 0.0022
R_VDD_111a_19247 METAL6_1431700_2154300 METAL6_1431700_2166300 0.024
R_VDD_111a_19248 METAL5_0_1250000 METAL5_9500_1250000 0.038
R_VDD_111a_19249 METAL6_1431700_2166300 METAL6_1424000_2166300 0.0154
R_VDD_111a_19250 METAL6_1424000_2166300 METAL6_1420800_2166300 0.0064
R_VDD_111a_19251 METAL6_1420800_2166300 METAL6_1419700_2166300 0.0022
R_VDD_111a_19252 METAL6_1419700_2166300 METAL6_1412000_2166300 0.0154
R_VDD_111a_19253 METAL6_1412000_2166300 METAL6_1408800_2166300 0.0064
R_VDD_111a_19254 METAL6_1408800_2166300 METAL6_1400000_2166300 0.0176
R_VDD_111a_19255 METAL6_1400000_2166300 METAL6_1396800_2166300 0.0064
R_VDD_111a_19256 METAL6_1396800_2166300 METAL6_1388000_2166300 0.0176
R_VDD_111a_19257 METAL6_1388000_2166300 METAL6_1349000_2166300 0.078
R_VDD_111a_19258 METAL6_1349000_2166300 METAL6_1348000_2166300 0.002
R_VDD_111a_19259 METAL6_1348000_2166300 METAL6_1337000_2166300 0.022
R_VDD_111a_19260 METAL6_1337000_2166300 METAL6_1336000_2166300 0.002
R_VDD_111a_19261 METAL6_1336000_2166300 METAL6_1325000_2166300 0.022
R_VDD_111a_19262 METAL6_1325000_2166300 METAL6_1324000_2166300 0.002
R_VDD_111a_19263 METAL6_1324000_2166300 METAL6_1323800_2166300 0.0004
R_VDD_111a_19264 METAL6_1323800_2166300 METAL6_1313000_2166300 0.0216
R_VDD_111a_19265 METAL6_1313000_2166300 METAL6_1312000_2166300 0.002
R_VDD_111a_19266 METAL6_1312000_2166300 METAL6_1311800_2166300 0.0004
R_VDD_111a_19267 METAL6_1311800_2166300 METAL5_1311800_2166300 0.1
R_VDD_111a_19268 METAL5_1311800_2166300 METAL5_1301000_2166300 0.0432
R_VDD_111a_19269 METAL5_1301000_2166300 METAL5_1300000_2166300 0.004
R_VDD_111a_19270 METAL5_1300000_2166300 METAL5_1299800_2166300 0.0008
R_VDD_111a_19271 METAL5_1299800_2166300 METAL5_1294300_2166300 0.022
R_VDD_111a_19272 METAL5_1294300_2166300 METAL5_1289000_2166300 0.0212
R_VDD_111a_19273 METAL5_1289000_2166300 METAL5_1288000_2166300 0.004
R_VDD_111a_19274 METAL5_1288000_2166300 METAL5_1287800_2166300 0.0008
R_VDD_111a_19275 METAL5_1287800_2166300 METAL5_1286700_2166300 0.0044
R_VDD_111a_19276 METAL5_1286700_2166300 METAL5_1282300_2166300 0.0176
R_VDD_111a_19277 METAL5_1282300_2166300 METAL5_1276000_2166300 0.0252
R_VDD_111a_19278 METAL5_1276000_2166300 METAL5_1274700_2166300 0.0052
R_VDD_111a_19279 METAL5_1274700_2166300 METAL5_1270300_2166300 0.0176
R_VDD_111a_19280 METAL5_1270300_2166300 METAL5_1266800_2166300 0.014
R_VDD_111a_19281 METAL5_1266800_2166300 METAL5_1262700_2166300 0.0164
R_VDD_111a_19282 METAL5_1262700_2166300 METAL5_1259800_2166300 0.0116
R_VDD_111a_19283 METAL5_1259800_2166300 METAL5_1258300_2166300 0.006
R_VDD_111a_19284 METAL5_1258300_2166300 METAL5_1254700_2166300 0.0144
R_VDD_111a_19285 METAL5_1254700_2166300 METAL5_1253300_2166300 0.0056
R_VDD_111a_19286 METAL5_1253300_2166300 METAL5_1248000_2166300 0.0212
R_VDD_111a_19287 METAL5_1248000_2166300 METAL5_1247800_2166300 0.0008
R_VDD_111a_19288 METAL5_1247800_2166300 METAL5_1246300_2166300 0.006
R_VDD_111a_19289 METAL5_1246300_2166300 METAL5_1242700_2166300 0.0144
R_VDD_111a_19290 METAL5_1242700_2166300 METAL5_1236000_2166300 0.0268
R_VDD_111a_19291 METAL5_1236000_2166300 METAL5_1235800_2166300 0.0008
R_VDD_111a_19292 METAL5_1235800_2166300 METAL5_1234300_2166300 0.006
R_VDD_111a_19293 METAL5_1234300_2166300 METAL5_1230700_2166300 0.0144
R_VDD_111a_19294 METAL5_1230700_2166300 METAL5_1224000_2166300 0.0268
R_VDD_111a_19295 METAL5_1224000_2166300 METAL5_1223800_2166300 0.0008
R_VDD_111a_19296 METAL5_1223800_2166300 METAL5_1222300_2166300 0.006
R_VDD_111a_19297 METAL5_1222300_2166300 METAL5_1218700_2166300 0.0144
R_VDD_111a_19298 METAL5_1218700_2166300 METAL5_1216400_2166300 0.0092
R_VDD_111a_19299 METAL5_1216400_2166300 METAL5_1212000_2166300 0.0176
R_VDD_111a_19300 METAL5_1212000_2166300 METAL5_1211800_2166300 0.0008
R_VDD_111a_19301 METAL5_1211800_2166300 METAL5_1210300_2166300 0.006
R_VDD_111a_19302 METAL5_1210300_2166300 METAL5_1206700_2166300 0.0144
R_VDD_111a_19303 METAL5_1206700_2166300 METAL5_1204400_2166300 0.0092
R_VDD_111a_19304 METAL5_1204400_2166300 METAL5_1200000_2166300 0.0176
R_VDD_111a_19305 METAL5_1200000_2166300 METAL5_1199800_2166300 0.0008
R_VDD_111a_19306 METAL5_1199800_2166300 METAL5_1198300_2166300 0.006
R_VDD_111a_19307 METAL5_1198300_2166300 METAL6_1198300_2166300 0.1
R_VDD_111a_19308 METAL6_1198300_2166300 METAL6_1194700_2166300 0.0072
R_VDD_111a_19309 METAL6_1194700_2166300 METAL6_1194700_2163000 0.0066
R_VDD_111a_19310 METAL6_1194700_2163000 METAL6_1194700_2154300 0.0174
R_VDD_111a_19311 METAL6_1194700_2154300 METAL6_1194700_2150500 0.0076
R_VDD_111a_19312 METAL6_1194700_2150500 METAL6_1194700_2147300 0.0064
R_VDD_111a_19313 METAL6_1194700_2147300 METAL6_1194700_2138500 0.0176
R_VDD_111a_19314 METAL6_1194700_2138500 METAL6_1194700_2126500 0.024
R_VDD_111a_19315 METAL6_1194700_2126500 METAL6_1194700_2114500 0.024
R_VDD_111a_19316 METAL6_1194700_2114500 METAL6_1194700_2038500 0.152
R_VDD_111a_19317 METAL6_1194700_2038500 METAL6_1194700_2026500 0.024
R_VDD_111a_19318 METAL6_1194700_2026500 METAL6_1194700_2014500 0.024
R_VDD_111a_19319 METAL6_1194700_2014500 METAL6_1194700_2000500 0.028
R_VDD_111a_19320 METAL6_1194700_2000500 METAL6_1192400_2000500 0.0046
R_VDD_111a_19321 METAL6_1192400_2000500 METAL6_1192400_1999000 0.003
R_VDD_111a_19322 METAL6_1192400_1999000 METAL6_1192400_1988500 0.021
R_VDD_111a_19323 METAL6_1192400_1988500 METAL6_1192400_1987000 0.003
R_VDD_111a_19324 METAL6_1192400_1987000 METAL6_1192400_1976500 0.021
R_VDD_111a_19325 METAL6_1192400_1976500 METAL6_1192400_1975000 0.003
R_VDD_111a_19326 METAL6_1192400_1975000 METAL6_1192400_1974500 0.001
R_VDD_111a_19327 METAL6_1192400_1974500 METAL6_1192400_1964500 0.02
R_VDD_111a_19328 METAL6_1192400_1964500 METAL6_1192400_1963000 0.003
R_VDD_111a_19329 METAL6_1192400_1963000 METAL6_1192400_1962500 0.001
R_VDD_111a_19330 METAL6_1192400_1962500 METAL6_1192400_1952500 0.02
R_VDD_111a_19331 METAL6_1192400_1952500 METAL6_1192400_1951000 0.003
R_VDD_111a_19332 METAL6_1192400_1951000 METAL6_1192400_1950500 0.001
R_VDD_111a_19333 METAL6_1192400_1950500 METAL6_1192400_1940500 0.02
R_VDD_111a_19334 METAL6_1192400_1940500 METAL6_1192400_1939000 0.003
R_VDD_111a_19335 METAL6_1192400_1939000 METAL6_1192400_1938500 0.001
R_VDD_111a_19336 METAL6_1192400_1938500 METAL6_1192400_1928500 0.02
R_VDD_111a_19337 METAL6_1192400_1928500 METAL6_1192400_1926500 0.004
R_VDD_111a_19338 METAL6_1192400_1926500 METAL6_1192400_1914500 0.024
R_VDD_111a_19339 METAL6_1192400_1914500 METAL6_1192400_1902500 0.024
R_VDD_111a_19340 METAL6_1192400_1902500 METAL6_1192400_1890500 0.024
R_VDD_111a_19341 METAL6_1192400_1890500 METAL6_1192400_1878300 0.0244
R_VDD_111a_19342 METAL6_1192400_1878300 METAL6_1192400_1866300 0.024
R_VDD_111a_19343 METAL6_1192400_1866300 METAL6_1192400_1854300 0.024
R_VDD_111a_19344 METAL6_1192400_1854300 METAL6_1192400_1852300 0.004
R_VDD_111a_19345 METAL6_1192400_1852300 METAL6_1192400_1838500 0.0276
R_VDD_111a_19346 METAL6_1192400_1838500 METAL6_1192400_1826500 0.024
R_VDD_111a_19347 METAL6_1192400_1826500 METAL6_1192400_1814500 0.024
R_VDD_111a_19348 METAL6_1192400_1814500 METAL6_1192400_1802500 0.024
R_VDD_111a_19349 METAL6_1192400_1802500 METAL6_1192400_1774500 0.056
R_VDD_111a_19350 METAL6_1192400_1774500 METAL6_1192400_1762500 0.024
R_VDD_111a_19351 METAL6_1192400_1762500 METAL6_1192400_1750500 0.024
R_VDD_111a_19352 METAL6_1192400_1750500 METAL6_1192400_1738500 0.024
R_VDD_111a_19353 METAL6_1192400_1738500 METAL6_1192400_1731700 0.0136
R_VDD_111a_19354 METAL6_1192400_1731700 METAL6_1192400_1726500 0.0104
R_VDD_111a_19355 METAL6_1192400_1726500 METAL6_1192400_1720500 0.012
R_VDD_111a_19356 METAL6_1192400_1720500 METAL6_1192400_1714500 0.012
R_VDD_111a_19357 METAL6_1192400_1714500 METAL6_1192400_1576300 0.2764
R_VDD_111a_19358 METAL6_1192400_1576300 METAL6_1192400_1571300 0.01
R_VDD_111a_19359 METAL6_1192400_1571300 METAL6_1192400_1564300 0.014
R_VDD_111a_19360 METAL6_1192400_1564300 METAL5_1192400_1564300 0.1
R_VDD_111a_19361 METAL5_1192400_1564300 METAL5_1192400_1554500 0.0392
R_VDD_111a_19362 METAL5_1192400_1554500 METAL5_1188000_1554500 0.0176
R_VDD_111a_19363 METAL5_1188000_1554500 METAL5_1188000_1552300 0.0088
R_VDD_111a_19364 METAL5_1188000_1552300 METAL5_1188000_1540300 0.048
R_VDD_111a_19365 METAL5_1188000_1540300 METAL5_1187800_1540300 0.0008
R_VDD_111a_19366 METAL5_1187800_1540300 METAL5_1186300_1540300 0.006
R_VDD_111a_19367 METAL5_1186300_1540300 METAL5_1182700_1540300 0.0144
R_VDD_111a_19368 METAL5_1182700_1540300 METAL5_1180400_1540300 0.0092
R_VDD_111a_19369 METAL5_1180400_1540300 METAL6_1180400_1540300 0.1
R_VDD_111a_19370 METAL6_1180400_1540300 METAL6_1180400_1528300 0.024
R_VDD_111a_19371 METAL6_1180400_1528300 METAL6_1180400_1516300 0.024
R_VDD_111a_19372 METAL6_1180400_1516300 METAL6_1180400_1504300 0.024
R_VDD_111a_19373 METAL6_1180400_1504300 METAL6_1180400_1492300 0.024
R_VDD_111a_19374 METAL6_1180400_1492300 METAL6_1180400_1473700 0.0372
R_VDD_111a_19375 METAL6_1180400_1473700 METAL6_1180400_1461700 0.024
R_VDD_111a_19376 METAL6_1180400_1461700 METAL6_1180400_1449700 0.024
R_VDD_111a_19377 METAL6_1180400_1449700 METAL6_1180400_1437700 0.024
R_VDD_111a_19378 METAL6_1180400_1437700 METAL6_1180400_1417000 0.0414
R_VDD_111a_19379 METAL6_1180400_1417000 METAL6_1180400_1405000 0.024
R_VDD_111a_19380 METAL6_1180400_1405000 METAL6_1180400_1393000 0.024
R_VDD_111a_19381 METAL6_1180400_1393000 METAL6_1176000_1393000 0.0088
R_VDD_111a_19382 METAL6_1176000_1393000 METAL6_1174300_1393000 0.0034
R_VDD_111a_19383 METAL6_1174300_1393000 METAL6_1173700_1393000 0.0012
R_VDD_111a_19384 METAL6_1173700_1393000 METAL6_1166700_1393000 0.014
R_VDD_111a_19385 METAL6_1166700_1393000 METAL6_1162300_1393000 0.0088
R_VDD_111a_19386 METAL6_1162300_1393000 METAL6_1154700_1393000 0.0152
R_VDD_111a_19387 METAL6_1154700_1393000 METAL6_1150300_1393000 0.0088
R_VDD_111a_19388 METAL6_1150300_1393000 METAL6_1142700_1393000 0.0152
R_VDD_111a_19389 METAL6_1142700_1393000 METAL6_1137000_1393000 0.0114
R_VDD_111a_19390 METAL6_1137000_1393000 METAL6_1130700_1393000 0.0126
R_VDD_111a_19391 METAL6_1130700_1393000 METAL6_1125000_1393000 0.0114
R_VDD_111a_19392 METAL6_1125000_1393000 METAL6_1118700_1393000 0.0126
R_VDD_111a_19393 METAL6_1118700_1393000 METAL6_1113000_1393000 0.0114
R_VDD_111a_19394 METAL6_1113000_1393000 METAL6_1019000_1393000 0.188
R_VDD_111a_19395 METAL6_1019000_1393000 METAL6_1007000_1393000 0.024
R_VDD_111a_19396 METAL6_1007000_1393000 METAL6_995000_1393000 0.024
R_VDD_111a_19397 METAL6_995000_1393000 METAL6_988000_1393000 0.014
R_VDD_111a_19398 METAL6_988000_1393000 METAL6_964400_1393000 0.0472
R_VDD_111a_19399 METAL6_964400_1393000 METAL6_952400_1393000 0.024
R_VDD_111a_19400 METAL6_952400_1393000 METAL6_947400_1393000 0.01
R_VDD_111a_19401 METAL6_947400_1393000 METAL6_940400_1393000 0.014
R_VDD_111a_19402 METAL6_940400_1393000 METAL5_940400_1393000 0.1
R_VDD_111a_19403 METAL5_940400_1393000 METAL5_928400_1393000 0.048
R_VDD_111a_19404 METAL5_928400_1393000 METAL5_916400_1393000 0.048
R_VDD_111a_19405 METAL5_916400_1393000 METAL5_916400_1386600 0.0256
R_VDD_111a_19406 METAL5_916400_1386600 METAL5_916400_1386000 0.0024
R_VDD_111a_19407 METAL5_916400_1386000 METAL5_916400_1381000 0.02
R_VDD_111a_19408 METAL5_916400_1381000 METAL5_916400_1374000 0.028
R_VDD_111a_19409 METAL5_916400_1374000 METAL5_916400_1369000 0.02
R_VDD_111a_19410 METAL5_916400_1369000 METAL5_916400_1362000 0.028
R_VDD_111a_19411 METAL5_916400_1362000 METAL5_916400_1357000 0.02
R_VDD_111a_19412 METAL5_916400_1357000 METAL5_916400_1350000 0.028
R_VDD_111a_19413 METAL5_916400_1350000 METAL5_916400_1338000 0.048
R_VDD_111a_19414 METAL5_916400_1338000 METAL5_916400_1326000 0.048
R_VDD_111a_19415 METAL5_916400_1326000 METAL6_916400_1326000 0.1
R_VDD_111a_19416 METAL6_916400_1326000 METAL6_904400_1326000 0.024
R_VDD_111a_19417 METAL6_904400_1326000 METAL6_892400_1326000 0.024
R_VDD_111a_19418 METAL6_892400_1326000 METAL6_880400_1326000 0.024
R_VDD_111a_19419 METAL6_880400_1326000 METAL6_868400_1326000 0.024
R_VDD_111a_19420 METAL6_868400_1326000 METAL6_743000_1326000 0.2508
R_VDD_111a_19421 METAL6_743000_1326000 METAL6_736000_1326000 0.014
R_VDD_111a_19422 METAL6_736000_1326000 METAL6_736000_1319700 0.0126
R_VDD_111a_19423 METAL6_736000_1319700 METAL6_736000_1314000 0.0114
R_VDD_111a_19424 METAL6_736000_1314000 METAL6_736000_1309000 0.01
R_VDD_111a_19425 METAL6_736000_1309000 METAL6_731000_1309000 0.01
R_VDD_111a_19426 METAL6_731000_1309000 METAL6_731000_1307700 0.0026
R_VDD_111a_19427 METAL6_731000_1307700 METAL6_731000_1302000 0.0114
R_VDD_111a_19428 METAL6_731000_1302000 METAL6_731000_1297000 0.01
R_VDD_111a_19429 METAL6_731000_1297000 METAL6_731000_1295700 0.0026
R_VDD_111a_19430 METAL6_731000_1295700 METAL6_731000_1290000 0.0114
R_VDD_111a_19431 METAL6_731000_1290000 METAL6_731000_1285000 0.01
R_VDD_111a_19432 METAL6_731000_1285000 METAL6_731000_1283700 0.0026
R_VDD_111a_19433 METAL6_731000_1283700 METAL6_731000_1273000 0.0214
R_VDD_111a_19434 METAL6_731000_1273000 METAL6_731000_1271700 0.0026
R_VDD_111a_19435 METAL6_731000_1271700 METAL6_731000_1262000 0.0194
R_VDD_111a_19436 METAL6_731000_1262000 METAL6_731000_1261000 0.002
R_VDD_111a_19437 METAL6_731000_1261000 METAL6_731000_1259700 0.0026
R_VDD_111a_19438 METAL6_731000_1259700 METAL6_731000_1250000 0.0194
R_VDD_111a_19439 METAL6_731000_1250000 METAL6_731000_1247700 0.0046
R_VDD_111a_19440 METAL6_731000_1247700 METAL6_731000_1238000 0.0194
R_VDD_111a_19441 METAL6_731000_1238000 METAL6_731000_1235700 0.0046
R_VDD_111a_19442 METAL6_731000_1235700 METAL6_731000_1229700 0.012
R_VDD_111a_19443 METAL6_731000_1229700 METAL6_731000_1223700 0.012
R_VDD_111a_19444 METAL6_731000_1223700 METAL6_731000_1217700 0.012
R_VDD_111a_19445 METAL6_731000_1217700 METAL6_731000_1211700 0.012
R_VDD_111a_19446 METAL6_731000_1211700 METAL6_731000_1205800 0.0118
R_VDD_111a_19447 METAL6_731000_1205800 METAL6_731000_1205700 0.0002
R_VDD_111a_19448 METAL6_731000_1205700 METAL5_731000_1205700 0.1
R_VDD_111a_19449 METAL5_731000_1205700 METAL5_724000_1205700 0.028
R_VDD_111a_19450 METAL5_724000_1205700 METAL5_719000_1205700 0.02
R_VDD_111a_19451 METAL5_719000_1205700 METAL5_712000_1205700 0.028
R_VDD_111a_19452 METAL5_712000_1205700 METAL5_707000_1205700 0.02
R_VDD_111a_19453 METAL5_707000_1205700 METAL5_700000_1205700 0.028
R_VDD_111a_19454 METAL5_700000_1205700 METAL5_695000_1205700 0.02
R_VDD_111a_19455 METAL5_695000_1205700 METAL5_688000_1205700 0.028
R_VDD_111a_19456 METAL5_688000_1205700 METAL6_688000_1205700 0.1
R_VDD_111a_19457 METAL6_688000_1205700 METAL6_676000_1205700 0.024
R_VDD_111a_19458 METAL6_676000_1205700 METAL6_593000_1205700 0.166
R_VDD_111a_19459 METAL6_593000_1205700 METAL6_581000_1205700 0.024
R_VDD_111a_19460 METAL6_581000_1205700 METAL6_569000_1205700 0.024
R_VDD_111a_19461 METAL6_569000_1205700 METAL6_557000_1205700 0.024
R_VDD_111a_19462 METAL6_557000_1205700 METAL6_545000_1205700 0.024
R_VDD_111a_19463 METAL6_545000_1205700 METAL6_543000_1205700 0.004
R_VDD_111a_19464 METAL6_543000_1205700 METAL6_538000_1205700 0.01
R_VDD_111a_19465 METAL6_538000_1205700 METAL6_533000_1205700 0.01
R_VDD_111a_19466 METAL6_533000_1205700 METAL6_521000_1205700 0.024
R_VDD_111a_19467 METAL6_521000_1205700 METAL6_343000_1205700 0.356
R_VDD_111a_19468 METAL6_343000_1205700 METAL6_243000_1205700 0.2
R_VDD_111a_19469 METAL6_243000_1205700 METAL6_231000_1205700 0.024
R_VDD_111a_19470 METAL6_231000_1205700 METAL6_219000_1205700 0.024
R_VDD_111a_19471 METAL6_219000_1205700 METAL6_207000_1205700 0.024
R_VDD_111a_19472 METAL6_207000_1205700 METAL6_200000_1205700 0.014
R_VDD_111a_19473 METAL6_200000_1205700 METAL6_195000_1205700 0.01
R_VDD_111a_19474 METAL6_195000_1205700 METAL6_188000_1205700 0.014
R_VDD_111a_19475 METAL6_188000_1205700 METAL6_176000_1205700 0.024
R_VDD_111a_19476 METAL6_176000_1205700 METAL6_21500_1205700 0.309
R_VDD_111a_19477 METAL6_21500_1205700 METAL6_9500_1205700 0.024
R_VDD_111a_19478 METAL6_9500_1205700 METAL6_9500_1205800 0.0002
R_VDD_111a_19479 METAL6_9500_1205800 METAL6_9500_1211700 0.0118
R_VDD_111a_19480 METAL6_9500_1211700 METAL6_9500_1217700 0.012
R_VDD_111a_19481 METAL6_9500_1217700 METAL6_9500_1223700 0.012
R_VDD_111a_19482 METAL6_9500_1223700 METAL6_9500_1229700 0.012
R_VDD_111a_19483 METAL6_9500_1229700 METAL6_9500_1235700 0.012
R_VDD_111a_19484 METAL6_9500_1235700 METAL6_9500_1238000 0.0046
R_VDD_111a_19485 METAL6_9500_1238000 METAL6_9500_1247700 0.0194
R_VDD_111a_19486 METAL6_9500_1247700 METAL6_9500_1250000 0.0046
R_VDD_111a_19487 METAL6_9500_1250000 METAL5_9500_1250000 0.1
R_VDD_111a_19488 METAL6_1731700_2154300 METAL6_1731700_2166300 0.024
R_VDD_111a_19489 METAL6_1763400_2178300 METAL6_1763400_2175000 0.0066
R_VDD_111a_19490 METAL6_1763400_2175000 METAL6_1763400_2166300 0.0174
R_VDD_111a_19491 METAL6_1763400_2166300 METAL6_1756000_2166300 0.0148
R_VDD_111a_19492 METAL6_1756000_2166300 METAL6_1755700_2166300 0.0006
R_VDD_111a_19493 METAL6_1755700_2166300 METAL6_1753800_2166300 0.0038
R_VDD_111a_19494 METAL6_1753800_2166300 METAL6_1751800_2166300 0.004
R_VDD_111a_19495 METAL6_1751800_2166300 METAL6_1751400_2166300 0.0008
R_VDD_111a_19496 METAL6_1751400_2166300 METAL6_1744000_2166300 0.0148
R_VDD_111a_19497 METAL6_1744000_2166300 METAL6_1743700_2166300 0.0006
R_VDD_111a_19498 METAL6_1743700_2166300 METAL6_1741800_2166300 0.0038
R_VDD_111a_19499 METAL6_1741800_2166300 METAL6_1739800_2166300 0.004
R_VDD_111a_19500 METAL6_1739800_2166300 METAL6_1739400_2166300 0.0008
R_VDD_111a_19501 METAL6_1739400_2166300 METAL6_1732000_2166300 0.0148
R_VDD_111a_19502 METAL6_1732000_2166300 METAL6_1731700_2166300 0.0006
R_VDD_111a_19503 METAL6_176000_1205700 METAL6_176000_1205800 0.0002
R_VDD_111a_19504 METAL6_176000_1205800 METAL6_176000_1211700 0.0118
R_VDD_111a_19505 METAL6_176000_1211700 METAL6_176000_1217700 0.012
R_VDD_111a_19506 METAL6_176000_1217700 METAL6_21500_1217700 0.309
R_VDD_111a_19507 METAL6_21500_1217700 METAL6_21500_1223700 0.012
R_VDD_111a_19508 METAL6_21500_1223700 METAL6_21500_1229700 0.012
R_VDD_111a_19509 METAL6_21500_1229700 METAL6_21500_1235700 0.012
R_VDD_111a_19510 METAL6_21500_1235700 METAL6_21500_1238000 0.0046
R_VDD_111a_19511 METAL6_21500_1238000 METAL6_21500_1247700 0.0194
R_VDD_111a_19512 METAL6_21500_1247700 METAL6_21500_1250000 0.0046
R_VDD_111a_19513 METAL6_21500_1250000 METAL6_9500_1250000 0.024
R_VDD_111a_19514 METAL6_2031700_2154300 METAL6_2031700_2166300 0.024
R_VDD_111a_19515 METAL6_1988000_2178300 METAL6_1988000_2175000 0.0066
R_VDD_111a_19516 METAL6_1988000_2175000 METAL6_1988000_2166300 0.0174
R_VDD_111a_19517 METAL6_1988000_2166300 METAL6_2000000_2166300 0.024
R_VDD_111a_19518 METAL6_2000000_2166300 METAL6_2002400_2166300 0.0048
R_VDD_111a_19519 METAL6_2002400_2166300 METAL6_2006900_2166300 0.009
R_VDD_111a_19520 METAL6_2006900_2166300 METAL6_2007700_2166300 0.0016
R_VDD_111a_19521 METAL6_2007700_2166300 METAL6_2012000_2166300 0.0086
R_VDD_111a_19522 METAL6_2012000_2166300 METAL6_2014400_2166300 0.0048
R_VDD_111a_19523 METAL6_2014400_2166300 METAL6_2018900_2166300 0.009
R_VDD_111a_19524 METAL6_2018900_2166300 METAL6_2019700_2166300 0.0016
R_VDD_111a_19525 METAL6_2019700_2166300 METAL6_2021200_2166300 0.003
R_VDD_111a_19526 METAL6_2021200_2166300 METAL6_2026400_2166300 0.0104
R_VDD_111a_19527 METAL6_2026400_2166300 METAL6_2030900_2166300 0.009
R_VDD_111a_19528 METAL6_2030900_2166300 METAL6_2031700_2166300 0.0016
R_VDD_111a_19529 METAL6_21500_1229700 METAL5_21500_1229700 0.1
R_VDD_111a_19530 METAL5_21500_1229700 METAL5_9500_1229700 0.048
R_VDD_111a_19531 METAL5_9500_1229700 METAL5_9500_1235700 0.024
R_VDD_111a_19532 METAL5_9500_1235700 METAL5_9500_1238000 0.0092
R_VDD_111a_19533 METAL5_9500_1238000 METAL5_9500_1247700 0.0388
R_VDD_111a_19534 METAL5_9500_1247700 METAL5_9500_1250000 0.0092
I_VDD_111a_67 METAL6_1431700_2154300 gnd 0.03
I_VDD_111a_68 METAL6_1731700_2154300 gnd 0.03
I_VDD_111a_69 METAL6_2031700_2154300 gnd 0.03

V_VDD_111b_29 METAL5_3500000_2450000 gnd 5
V_VDD_111b_30 METAL5_0_1350000 gnd 5
R_VDD_111b_19535 METAL5_3500000_2450000 METAL5_3490500_2450000 0.038
R_VDD_111b_19536 METAL5_3490500_2450000 METAL6_3490500_2450000 0.1
R_VDD_111b_19537 METAL6_3490500_2450000 METAL6_3478500_2450000 0.024
R_VDD_111b_19538 METAL6_3478500_2450000 METAL6_3478500_2444000 0.012
R_VDD_111b_19539 METAL6_3478500_2444000 METAL6_3478500_2438000 0.012
R_VDD_111b_19540 METAL6_3478500_2438000 METAL6_3478500_2412000 0.052
R_VDD_111b_19541 METAL6_3478500_2412000 METAL6_3478500_2407000 0.01
R_VDD_111b_19542 METAL6_3478500_2407000 METAL6_3478500_2400000 0.014
R_VDD_111b_19543 METAL6_3478500_2400000 METAL6_3478500_2389000 0.022
R_VDD_111b_19544 METAL6_3478500_2389000 METAL6_3477000_2389000 0.003
R_VDD_111b_19545 METAL6_3477000_2389000 METAL6_3465000_2389000 0.024
R_VDD_111b_19546 METAL6_3465000_2389000 METAL6_3453000_2389000 0.024
R_VDD_111b_19547 METAL6_3453000_2389000 METAL6_3336400_2389000 0.2332
R_VDD_111b_19548 METAL6_3336400_2389000 METAL6_3324400_2389000 0.024
R_VDD_111b_19549 METAL6_3324400_2389000 METAL6_3312400_2389000 0.024
R_VDD_111b_19550 METAL6_3312400_2389000 METAL6_3312400_2388000 0.002
R_VDD_111b_19551 METAL6_3312400_2388000 METAL6_3312400_2362000 0.052
R_VDD_111b_19552 METAL6_3312400_2362000 METAL6_3312400_2350000 0.024
R_VDD_111b_19553 METAL6_3312400_2350000 METAL6_3312400_2338000 0.024
R_VDD_111b_19554 METAL6_3312400_2338000 METAL6_3312400_2312000 0.052
R_VDD_111b_19555 METAL6_3312400_2312000 METAL6_3312400_2300000 0.024
R_VDD_111b_19556 METAL6_3312400_2300000 METAL6_3312400_2288000 0.024
R_VDD_111b_19557 METAL6_3312400_2288000 METAL6_3312400_2268500 0.039
R_VDD_111b_19558 METAL6_3312400_2268500 METAL6_3312400_2234500 0.068
R_VDD_111b_19559 METAL6_3312400_2234500 METAL6_3312000_2234500 0.0008
R_VDD_111b_19560 METAL6_3312000_2234500 METAL6_3305400_2234500 0.0132
R_VDD_111b_19561 METAL6_3305400_2234500 METAL6_3300000_2234500 0.0108
R_VDD_111b_19562 METAL6_3300000_2234500 METAL6_3288000_2234500 0.024
R_VDD_111b_19563 METAL6_3288000_2234500 METAL6_3287000_2234500 0.002
R_VDD_111b_19564 METAL6_3287000_2234500 METAL6_3275000_2234500 0.024
R_VDD_111b_19565 METAL6_3275000_2234500 METAL6_3263000_2234500 0.024
R_VDD_111b_19566 METAL6_3263000_2234500 METAL6_3260400_2234500 0.0052
R_VDD_111b_19567 METAL6_3260400_2234500 METAL6_3243500_2234500 0.0338
R_VDD_111b_19568 METAL6_3243500_2234500 METAL6_3231500_2234500 0.024
R_VDD_111b_19569 METAL6_3231500_2234500 METAL6_3219500_2234500 0.024
R_VDD_111b_19570 METAL6_3219500_2234500 METAL6_3212500_2234500 0.014
R_VDD_111b_19571 METAL6_3212500_2234500 METAL6_3212000_2234500 0.001
R_VDD_111b_19572 METAL6_3212000_2234500 METAL6_3200000_2234500 0.024
R_VDD_111b_19573 METAL6_3200000_2234500 METAL6_3188000_2234500 0.024
R_VDD_111b_19574 METAL6_3188000_2234500 METAL6_3167500_2234500 0.041
R_VDD_111b_19575 METAL6_3167500_2234500 METAL6_3165900_2234500 0.0032
R_VDD_111b_19576 METAL6_3165900_2234500 METAL6_3112000_2234500 0.1078
R_VDD_111b_19577 METAL6_3112000_2234500 METAL6_3110900_2234500 0.0022
R_VDD_111b_19578 METAL6_3110900_2234500 METAL6_3100000_2234500 0.0218
R_VDD_111b_19579 METAL6_3100000_2234500 METAL6_3099200_2234500 0.0016
R_VDD_111b_19580 METAL6_3099200_2234500 METAL6_3098900_2234500 0.0006
R_VDD_111b_19581 METAL6_3098900_2234500 METAL6_3088000_2234500 0.0218
R_VDD_111b_19582 METAL6_3088000_2234500 METAL6_3087200_2234500 0.0016
R_VDD_111b_19583 METAL6_3087200_2234500 METAL6_3086900_2234500 0.0006
R_VDD_111b_19584 METAL6_3086900_2234500 METAL6_3075200_2234500 0.0234
R_VDD_111b_19585 METAL6_3075200_2234500 METAL6_3068200_2234500 0.014
R_VDD_111b_19586 METAL6_3068200_2234500 METAL6_3060600_2234500 0.0152
R_VDD_111b_19587 METAL6_3060600_2234500 METAL6_3023200_2234500 0.0748
R_VDD_111b_19588 METAL6_3023200_2234500 METAL6_3012000_2234500 0.0224
R_VDD_111b_19589 METAL6_3012000_2234500 METAL6_3006200_2234500 0.0116
R_VDD_111b_19590 METAL6_3006200_2234500 METAL6_3000000_2234500 0.0124
R_VDD_111b_19591 METAL6_3000000_2234500 METAL6_2994200_2234500 0.0116
R_VDD_111b_19592 METAL6_2994200_2234500 METAL6_2993000_2234500 0.0024
R_VDD_111b_19593 METAL6_2993000_2234500 METAL6_2988000_2234500 0.01
R_VDD_111b_19594 METAL6_2988000_2234500 METAL6_2982200_2234500 0.0116
R_VDD_111b_19595 METAL6_2982200_2234500 METAL6_2975200_2234500 0.014
R_VDD_111b_19596 METAL6_2975200_2234500 METAL6_2965900_2234500 0.0186
R_VDD_111b_19597 METAL6_2965900_2234500 METAL6_2951900_2234500 0.028
R_VDD_111b_19598 METAL6_2951900_2234500 METAL6_2930200_2234500 0.0434
R_VDD_111b_19599 METAL6_2930200_2234500 METAL6_2925600_2234500 0.0092
R_VDD_111b_19600 METAL6_2925600_2234500 METAL6_2913600_2234500 0.024
R_VDD_111b_19601 METAL6_2913600_2234500 METAL6_2910900_2234500 0.0054
R_VDD_111b_19602 METAL6_2910900_2234500 METAL6_2901600_2234500 0.0186
R_VDD_111b_19603 METAL6_2901600_2234500 METAL6_2898900_2234500 0.0054
R_VDD_111b_19604 METAL6_2898900_2234500 METAL6_2897100_2234500 0.0036
R_VDD_111b_19605 METAL6_2897100_2234500 METAL6_2886900_2234500 0.0204
R_VDD_111b_19606 METAL6_2886900_2234500 METAL6_2874800_2234500 0.0242
R_VDD_111b_19607 METAL6_2874800_2234500 METAL6_2862800_2234500 0.024
R_VDD_111b_19608 METAL6_2862800_2234500 METAL6_2860600_2234500 0.0044
R_VDD_111b_19609 METAL6_2860600_2234500 METAL6_2850800_2234500 0.0196
R_VDD_111b_19610 METAL6_2850800_2234500 METAL6_2846600_2234500 0.0084
R_VDD_111b_19611 METAL6_2846600_2234500 METAL6_2843800_2234500 0.0056
R_VDD_111b_19612 METAL6_2843800_2234500 METAL6_2812000_2234500 0.0636
R_VDD_111b_19613 METAL6_2812000_2234500 METAL6_2805600_2234500 0.0128
R_VDD_111b_19614 METAL6_2805600_2234500 METAL6_2800000_2234500 0.0112
R_VDD_111b_19615 METAL6_2800000_2234500 METAL6_2798800_2234500 0.0024
R_VDD_111b_19616 METAL6_2798800_2234500 METAL6_2793600_2234500 0.0104
R_VDD_111b_19617 METAL6_2793600_2234500 METAL6_2788000_2234500 0.0112
R_VDD_111b_19618 METAL6_2788000_2234500 METAL6_2781600_2234500 0.0128
R_VDD_111b_19619 METAL6_2781600_2234500 METAL6_2765900_2234500 0.0314
R_VDD_111b_19620 METAL6_2765900_2234500 METAL6_2751900_2234500 0.028
R_VDD_111b_19621 METAL6_2751900_2234500 METAL6_2728200_2234500 0.0474
R_VDD_111b_19622 METAL6_2728200_2234500 METAL6_2710900_2234500 0.0346
R_VDD_111b_19623 METAL6_2710900_2234500 METAL6_2698900_2234500 0.024
R_VDD_111b_19624 METAL6_2698900_2234500 METAL6_2686900_2234500 0.024
R_VDD_111b_19625 METAL6_2686900_2234500 METAL6_2683200_2234500 0.0074
R_VDD_111b_19626 METAL6_2683200_2234500 METAL6_2676200_2234500 0.014
R_VDD_111b_19627 METAL6_2676200_2234500 METAL6_2664200_2234500 0.024
R_VDD_111b_19628 METAL6_2664200_2234500 METAL6_2660600_2234500 0.0072
R_VDD_111b_19629 METAL6_2660600_2234500 METAL6_2652200_2234500 0.0168
R_VDD_111b_19630 METAL6_2652200_2234500 METAL6_2646600_2234500 0.0112
R_VDD_111b_19631 METAL6_2646600_2234500 METAL6_2580400_2234500 0.1324
R_VDD_111b_19632 METAL6_2580400_2234500 METAL6_2565900_2234500 0.029
R_VDD_111b_19633 METAL6_2565900_2234500 METAL6_2551900_2234500 0.028
R_VDD_111b_19634 METAL6_2551900_2234500 METAL6_2535400_2234500 0.033
R_VDD_111b_19635 METAL6_2535400_2234500 METAL6_2528400_2234500 0.014
R_VDD_111b_19636 METAL6_2528400_2234500 METAL6_2525600_2234500 0.0056
R_VDD_111b_19637 METAL6_2525600_2234500 METAL6_2516400_2234500 0.0184
R_VDD_111b_19638 METAL6_2516400_2234500 METAL6_2513600_2234500 0.0056
R_VDD_111b_19639 METAL6_2513600_2234500 METAL6_2512000_2234500 0.0032
R_VDD_111b_19640 METAL6_2512000_2234500 METAL6_2510900_2234500 0.0022
R_VDD_111b_19641 METAL6_2510900_2234500 METAL6_2505000_2234500 0.0118
R_VDD_111b_19642 METAL6_2505000_2234500 METAL6_2504400_2234500 0.0012
R_VDD_111b_19643 METAL6_2504400_2234500 METAL6_2501600_2234500 0.0056
R_VDD_111b_19644 METAL6_2501600_2234500 METAL6_2500000_2234500 0.0032
R_VDD_111b_19645 METAL6_2500000_2234500 METAL6_2498900_2234500 0.0022
R_VDD_111b_19646 METAL6_2498900_2234500 METAL6_2493000_2234500 0.0118
R_VDD_111b_19647 METAL6_2493000_2234500 METAL6_2493000_2187000 0.095
R_VDD_111b_19648 METAL6_2493000_2187000 METAL6_2493000_2178300 0.0174
R_VDD_111b_19649 METAL6_2493000_2178300 METAL6_2488000_2178300 0.01
R_VDD_111b_19650 METAL6_2488000_2178300 METAL6_2488000_2175000 0.0066
R_VDD_111b_19651 METAL6_2488000_2175000 METAL6_2488000_2166300 0.0174
R_VDD_111b_19652 METAL6_2488000_2166300 METAL6_2488000_2163000 0.0066
R_VDD_111b_19653 METAL6_2488000_2163000 METAL6_2488000_2154300 0.0174
R_VDD_111b_19654 METAL6_2488000_2154300 METAL6_2488000_2147300 0.014
R_VDD_111b_19655 METAL6_2488000_2147300 METAL6_2488000_2138500 0.0176
R_VDD_111b_19656 METAL6_2488000_2138500 METAL6_2488000_2126500 0.024
R_VDD_111b_19657 METAL6_2488000_2126500 METAL6_2488000_2114500 0.024
R_VDD_111b_19658 METAL6_2488000_2114500 METAL6_2488000_2038500 0.152
R_VDD_111b_19659 METAL6_2488000_2038500 METAL6_2488000_2026500 0.024
R_VDD_111b_19660 METAL6_2488000_2026500 METAL6_2488000_2014500 0.024
R_VDD_111b_19661 METAL6_2488000_2014500 METAL6_2488000_1987000 0.055
R_VDD_111b_19662 METAL6_2488000_1987000 METAL6_2488000_1975000 0.024
R_VDD_111b_19663 METAL6_2488000_1975000 METAL6_2488000_1964500 0.021
R_VDD_111b_19664 METAL6_2488000_1964500 METAL6_2486900_1964500 0.0022
R_VDD_111b_19665 METAL6_2486900_1964500 METAL6_2481000_1964500 0.0118
R_VDD_111b_19666 METAL6_2481000_1964500 METAL6_2460600_1964500 0.0408
R_VDD_111b_19667 METAL6_2460600_1964500 METAL6_2446600_1964500 0.028
R_VDD_111b_19668 METAL6_2446600_1964500 METAL6_2405600_1964500 0.082
R_VDD_111b_19669 METAL6_2405600_1964500 METAL6_2402100_1964500 0.007
R_VDD_111b_19670 METAL6_2402100_1964500 METAL6_2395100_1964500 0.014
R_VDD_111b_19671 METAL6_2395100_1964500 METAL6_2395100_1963000 0.003
R_VDD_111b_19672 METAL6_2395100_1963000 METAL6_2395100_1952500 0.021
R_VDD_111b_19673 METAL6_2395100_1952500 METAL6_2395100_1940500 0.024
R_VDD_111b_19674 METAL6_2395100_1940500 METAL6_2395100_1938500 0.004
R_VDD_111b_19675 METAL6_2395100_1938500 METAL6_2395100_1926500 0.024
R_VDD_111b_19676 METAL6_2395100_1926500 METAL6_2395100_1914500 0.024
R_VDD_111b_19677 METAL6_2395100_1914500 METAL6_2395100_1866300 0.0964
R_VDD_111b_19678 METAL6_2395100_1866300 METAL6_2395100_1852300 0.028
R_VDD_111b_19679 METAL6_2395100_1852300 METAL6_2395100_1838500 0.0276
R_VDD_111b_19680 METAL6_2395100_1838500 METAL6_2395100_1826500 0.024
R_VDD_111b_19681 METAL6_2395100_1826500 METAL6_2395100_1814500 0.024
R_VDD_111b_19682 METAL6_2395100_1814500 METAL6_2395100_1774500 0.08
R_VDD_111b_19683 METAL6_2395100_1774500 METAL6_2395100_1762500 0.024
R_VDD_111b_19684 METAL6_2395100_1762500 METAL6_2395100_1750500 0.024
R_VDD_111b_19685 METAL6_2395100_1750500 METAL6_2395100_1738500 0.024
R_VDD_111b_19686 METAL6_2395100_1738500 METAL6_2395100_1731700 0.0136
R_VDD_111b_19687 METAL6_2395100_1731700 METAL6_2395100_1726500 0.0104
R_VDD_111b_19688 METAL6_2395100_1726500 METAL6_2395100_1720500 0.012
R_VDD_111b_19689 METAL6_2395100_1720500 METAL6_2395100_1714500 0.012
R_VDD_111b_19690 METAL6_2395100_1714500 METAL6_2395100_1571300 0.2864
R_VDD_111b_19691 METAL6_2395100_1571300 METAL6_2395100_1564300 0.014
R_VDD_111b_19692 METAL6_2395100_1564300 METAL6_2395100_1554500 0.0196
R_VDD_111b_19693 METAL6_2395100_1554500 METAL6_2395100_1552300 0.0044
R_VDD_111b_19694 METAL6_2395100_1552300 METAL6_2395100_1540300 0.024
R_VDD_111b_19695 METAL6_2395100_1540300 METAL6_2393600_1540300 0.003
R_VDD_111b_19696 METAL6_2393600_1540300 METAL6_2383100_1540300 0.021
R_VDD_111b_19697 METAL6_2383100_1540300 METAL6_2381600_1540300 0.003
R_VDD_111b_19698 METAL6_2381600_1540300 METAL6_2371100_1540300 0.021
R_VDD_111b_19699 METAL6_2371100_1540300 METAL6_2365900_1540300 0.0104
R_VDD_111b_19700 METAL6_2365900_1540300 METAL6_2351900_1540300 0.028
R_VDD_111b_19701 METAL6_2351900_1540300 METAL6_2343700_1540300 0.0164
R_VDD_111b_19702 METAL6_2343700_1540300 METAL6_2310900_1540300 0.0656
R_VDD_111b_19703 METAL6_2310900_1540300 METAL6_2298900_1540300 0.024
R_VDD_111b_19704 METAL6_2298900_1540300 METAL6_2286900_1540300 0.024
R_VDD_111b_19705 METAL6_2286900_1540300 METAL6_2260600_1540300 0.0526
R_VDD_111b_19706 METAL6_2260600_1540300 METAL6_2260400_1540300 0.0004
R_VDD_111b_19707 METAL6_2260400_1540300 METAL6_2248700_1540300 0.0234
R_VDD_111b_19708 METAL6_2248700_1540300 METAL6_2246600_1540300 0.0042
R_VDD_111b_19709 METAL6_2246600_1540300 METAL6_2236700_1540300 0.0198
R_VDD_111b_19710 METAL6_2236700_1540300 METAL6_2224700_1540300 0.024
R_VDD_111b_19711 METAL6_2224700_1540300 METAL6_2221900_1540300 0.0056
R_VDD_111b_19712 METAL6_2221900_1540300 METAL6_2188700_1540300 0.0664
R_VDD_111b_19713 METAL6_2188700_1540300 METAL6_2165900_1540300 0.0456
R_VDD_111b_19714 METAL6_2165900_1540300 METAL6_2165400_1540300 0.001
R_VDD_111b_19715 METAL6_2165400_1540300 METAL6_2153400_1540300 0.024
R_VDD_111b_19716 METAL6_2153400_1540300 METAL6_2151900_1540300 0.003
R_VDD_111b_19717 METAL6_2151900_1540300 METAL6_2141400_1540300 0.021
R_VDD_111b_19718 METAL6_2141400_1540300 METAL6_2129700_1540300 0.0234
R_VDD_111b_19719 METAL6_2129700_1540300 METAL6_2125600_1540300 0.0082
R_VDD_111b_19720 METAL6_2125600_1540300 METAL6_2121400_1540300 0.0084
R_VDD_111b_19721 METAL6_2121400_1540300 METAL6_2113600_1540300 0.0156
R_VDD_111b_19722 METAL6_2113600_1540300 METAL6_2101900_1540300 0.0234
R_VDD_111b_19723 METAL6_2101900_1540300 METAL6_2101600_1540300 0.0006
R_VDD_111b_19724 METAL6_2101600_1540300 METAL6_2089900_1540300 0.0234
R_VDD_111b_19725 METAL6_2089900_1540300 METAL6_2077900_1540300 0.024
R_VDD_111b_19726 METAL6_2077900_1540300 METAL6_2060600_1540300 0.0346
R_VDD_111b_19727 METAL6_2060600_1540300 METAL6_2046800_1540300 0.0276
R_VDD_111b_19728 METAL6_2046800_1540300 METAL6_2046600_1540300 0.0004
R_VDD_111b_19729 METAL6_2046600_1540300 METAL6_2046400_1540300 0.0004
R_VDD_111b_19730 METAL6_2046400_1540300 METAL6_2043700_1540300 0.0054
R_VDD_111b_19731 METAL6_2043700_1540300 METAL6_2031700_1540300 0.024
R_VDD_111b_19732 METAL6_2031700_1540300 METAL6_2030900_1540300 0.0016
R_VDD_111b_19733 METAL6_2030900_1540300 METAL6_2026400_1540300 0.009
R_VDD_111b_19734 METAL6_2026400_1540300 METAL6_2021200_1540300 0.0104
R_VDD_111b_19735 METAL6_2021200_1540300 METAL6_2019700_1540300 0.003
R_VDD_111b_19736 METAL6_2019700_1540300 METAL6_2018900_1540300 0.0016
R_VDD_111b_19737 METAL6_2018900_1540300 METAL6_2014400_1540300 0.009
R_VDD_111b_19738 METAL6_2014400_1540300 METAL6_2012000_1540300 0.0048
R_VDD_111b_19739 METAL6_2012000_1540300 METAL6_2006900_1540300 0.0102
R_VDD_111b_19740 METAL6_2006900_1540300 METAL6_2002400_1540300 0.009
R_VDD_111b_19741 METAL6_2002400_1540300 METAL6_2000000_1540300 0.0048
R_VDD_111b_19742 METAL6_2000000_1540300 METAL6_1988000_1540300 0.024
R_VDD_111b_19743 METAL6_1988000_1540300 METAL6_1951900_1540300 0.0722
R_VDD_111b_19744 METAL6_1951900_1540300 METAL6_1951800_1540300 0.0002
R_VDD_111b_19745 METAL6_1951800_1540300 METAL6_1939800_1540300 0.024
R_VDD_111b_19746 METAL6_1939800_1540300 METAL6_1927800_1540300 0.024
R_VDD_111b_19747 METAL6_1927800_1540300 METAL6_1926200_1540300 0.0032
R_VDD_111b_19748 METAL6_1926200_1540300 METAL6_1925600_1540300 0.0012
R_VDD_111b_19749 METAL6_1925600_1540300 METAL6_1919200_1540300 0.0128
R_VDD_111b_19750 METAL6_1919200_1540300 METAL6_1913600_1540300 0.0112
R_VDD_111b_19751 METAL6_1913600_1540300 METAL6_1907400_1540300 0.0124
R_VDD_111b_19752 METAL6_1907400_1540300 METAL6_1907200_1540300 0.0004
R_VDD_111b_19753 METAL6_1907200_1540300 METAL6_1901600_1540300 0.0112
R_VDD_111b_19754 METAL6_1901600_1540300 METAL6_1895200_1540300 0.0128
R_VDD_111b_19755 METAL6_1895200_1540300 METAL6_1888700_1540300 0.013
R_VDD_111b_19756 METAL6_1888700_1540300 METAL6_1877400_1540300 0.0226
R_VDD_111b_19757 METAL6_1877400_1540300 METAL6_1874700_1540300 0.0054
R_VDD_111b_19758 METAL6_1874700_1540300 METAL6_1865400_1540300 0.0186
R_VDD_111b_19759 METAL6_1865400_1540300 METAL6_1853400_1540300 0.024
R_VDD_111b_19760 METAL6_1853400_1540300 METAL6_1846800_1540300 0.0132
R_VDD_111b_19761 METAL6_1846800_1540300 METAL6_1846600_1540300 0.0004
R_VDD_111b_19762 METAL6_1846600_1540300 METAL6_1846400_1540300 0.0004
R_VDD_111b_19763 METAL6_1846400_1540300 METAL6_1832800_1540300 0.0272
R_VDD_111b_19764 METAL6_1832800_1540300 METAL6_1812000_1540300 0.0416
R_VDD_111b_19765 METAL6_1812000_1540300 METAL6_1800000_1540300 0.024
R_VDD_111b_19766 METAL6_1800000_1540300 METAL6_1788000_1540300 0.024
R_VDD_111b_19767 METAL6_1788000_1540300 METAL6_1751800_1540300 0.0724
R_VDD_111b_19768 METAL6_1751800_1540300 METAL6_1751400_1540300 0.0008
R_VDD_111b_19769 METAL6_1751400_1540300 METAL6_1744000_1540300 0.0148
R_VDD_111b_19770 METAL6_1744000_1540300 METAL6_1743700_1540300 0.0006
R_VDD_111b_19771 METAL6_1743700_1540300 METAL6_1741800_1540300 0.0038
R_VDD_111b_19772 METAL6_1741800_1540300 METAL6_1739800_1540300 0.004
R_VDD_111b_19773 METAL6_1739800_1540300 METAL6_1731700_1540300 0.0162
R_VDD_111b_19774 METAL6_1731700_1540300 METAL6_1729800_1540300 0.0038
R_VDD_111b_19775 METAL6_1729800_1540300 METAL6_1727800_1540300 0.004
R_VDD_111b_19776 METAL6_1727800_1540300 METAL6_1719700_1540300 0.0162
R_VDD_111b_19777 METAL6_1719700_1540300 METAL6_1719700_1552300 0.024
R_VDD_111b_19778 METAL6_1719700_1552300 METAL6_1717800_1552300 0.0038
R_VDD_111b_19779 METAL6_1717800_1552300 METAL6_1710800_1552300 0.014
R_VDD_111b_19780 METAL6_1710800_1552300 METAL6_1699000_1552300 0.0236
R_VDD_111b_19781 METAL6_1699000_1552300 METAL6_1692000_1552300 0.014
R_VDD_111b_19782 METAL6_1692000_1552300 METAL6_1680000_1552300 0.024
R_VDD_111b_19783 METAL6_1680000_1552300 METAL6_1668000_1552300 0.024
R_VDD_111b_19784 METAL6_1668000_1552300 METAL6_1646800_1552300 0.0424
R_VDD_111b_19785 METAL6_1646800_1552300 METAL6_1632800_1552300 0.028
R_VDD_111b_19786 METAL6_1632800_1552300 METAL6_1615800_1552300 0.034
R_VDD_111b_19787 METAL6_1615800_1552300 METAL6_1612000_1552300 0.0076
R_VDD_111b_19788 METAL6_1612000_1552300 METAL6_1607900_1552300 0.0082
R_VDD_111b_19789 METAL6_1607900_1552300 METAL6_1600000_1552300 0.0158
R_VDD_111b_19790 METAL6_1600000_1552300 METAL6_1588700_1552300 0.0226
R_VDD_111b_19791 METAL6_1588700_1552300 METAL6_1588000_1552300 0.0014
R_VDD_111b_19792 METAL6_1588000_1552300 METAL6_1574700_1552300 0.0266
R_VDD_111b_19793 METAL6_1574700_1552300 METAL6_1557000_1552300 0.0354
R_VDD_111b_19794 METAL6_1557000_1552300 METAL6_1555400_1552300 0.0032
R_VDD_111b_19795 METAL6_1555400_1552300 METAL6_1551800_1552300 0.0072
R_VDD_111b_19796 METAL6_1551800_1552300 METAL6_1539800_1552300 0.024
R_VDD_111b_19797 METAL6_1539800_1552300 METAL6_1527800_1552300 0.024
R_VDD_111b_19798 METAL6_1527800_1552300 METAL6_1512000_1552300 0.0316
R_VDD_111b_19799 METAL6_1512000_1552300 METAL6_1510400_1552300 0.0032
R_VDD_111b_19800 METAL6_1510400_1552300 METAL6_1503400_1552300 0.014
R_VDD_111b_19801 METAL6_1503400_1552300 METAL6_1500000_1552300 0.0068
R_VDD_111b_19802 METAL6_1500000_1552300 METAL6_1498300_1552300 0.0034
R_VDD_111b_19803 METAL6_1498300_1552300 METAL6_1491400_1552300 0.0138
R_VDD_111b_19804 METAL6_1491400_1552300 METAL6_1488000_1552300 0.0068
R_VDD_111b_19805 METAL6_1488000_1552300 METAL6_1479400_1552300 0.0172
R_VDD_111b_19806 METAL6_1479400_1552300 METAL6_1443700_1552300 0.0714
R_VDD_111b_19807 METAL6_1443700_1552300 METAL6_1432800_1552300 0.0218
R_VDD_111b_19808 METAL6_1432800_1552300 METAL6_1431700_1552300 0.0022
R_VDD_111b_19809 METAL6_1431700_1564300 METAL6_1431700_1554500 0.0196
R_VDD_111b_19810 METAL6_1431700_1554500 METAL6_1431700_1552300 0.0044
R_VDD_111b_19811 METAL5_0_1350000 METAL5_9500_1350000 0.038
R_VDD_111b_19812 METAL6_1431700_1552300 METAL6_1431700_1540300 0.024
R_VDD_111b_19813 METAL6_1431700_1540300 METAL6_1431700_1528300 0.024
R_VDD_111b_19814 METAL6_1431700_1528300 METAL6_1431700_1461700 0.1332
R_VDD_111b_19815 METAL6_1431700_1461700 METAL6_1431700_1449700 0.024
R_VDD_111b_19816 METAL6_1431700_1449700 METAL6_1431700_1437700 0.024
R_VDD_111b_19817 METAL6_1431700_1437700 METAL6_1431700_1393000 0.0894
R_VDD_111b_19818 METAL6_1431700_1393000 METAL6_1419700_1393000 0.024
R_VDD_111b_19819 METAL6_1419700_1393000 METAL6_1412000_1393000 0.0154
R_VDD_111b_19820 METAL6_1412000_1393000 METAL6_1400000_1393000 0.024
R_VDD_111b_19821 METAL6_1400000_1393000 METAL6_1388000_1393000 0.024
R_VDD_111b_19822 METAL6_1388000_1393000 METAL6_1337000_1393000 0.102
R_VDD_111b_19823 METAL6_1337000_1393000 METAL6_1325000_1393000 0.024
R_VDD_111b_19824 METAL6_1325000_1393000 METAL6_1313000_1393000 0.024
R_VDD_111b_19825 METAL6_1313000_1393000 METAL6_1313000_1386600 0.0128
R_VDD_111b_19826 METAL6_1313000_1386600 METAL6_1313000_1362000 0.0492
R_VDD_111b_19827 METAL6_1313000_1362000 METAL6_1313000_1350000 0.024
R_VDD_111b_19828 METAL6_1313000_1350000 METAL6_1312000_1350000 0.002
R_VDD_111b_19829 METAL6_1312000_1350000 METAL6_1311800_1350000 0.0004
R_VDD_111b_19830 METAL6_1311800_1350000 METAL6_1300000_1350000 0.0236
R_VDD_111b_19831 METAL6_1300000_1350000 METAL6_1288000_1350000 0.024
R_VDD_111b_19832 METAL6_1288000_1350000 METAL6_1274700_1350000 0.0266
R_VDD_111b_19833 METAL6_1274700_1350000 METAL6_1266800_1350000 0.0158
R_VDD_111b_19834 METAL6_1266800_1350000 METAL6_1259800_1350000 0.014
R_VDD_111b_19835 METAL6_1259800_1350000 METAL6_1253300_1350000 0.013
R_VDD_111b_19836 METAL6_1253300_1350000 METAL6_1247800_1350000 0.011
R_VDD_111b_19837 METAL6_1247800_1350000 METAL6_1246300_1350000 0.003
R_VDD_111b_19838 METAL6_1246300_1350000 METAL6_1235800_1350000 0.021
R_VDD_111b_19839 METAL6_1235800_1350000 METAL6_1234300_1350000 0.003
R_VDD_111b_19840 METAL6_1234300_1350000 METAL6_1222300_1350000 0.024
R_VDD_111b_19841 METAL6_1222300_1350000 METAL6_1218700_1350000 0.0072
R_VDD_111b_19842 METAL6_1218700_1350000 METAL6_1212000_1350000 0.0134
R_VDD_111b_19843 METAL6_1212000_1350000 METAL6_1200000_1350000 0.024
R_VDD_111b_19844 METAL6_1200000_1350000 METAL6_1192400_1350000 0.0152
R_VDD_111b_19845 METAL6_1192400_1350000 METAL6_1188000_1350000 0.0088
R_VDD_111b_19846 METAL6_1188000_1350000 METAL6_1173700_1350000 0.0286
R_VDD_111b_19847 METAL6_1173700_1350000 METAL6_1166700_1350000 0.014
R_VDD_111b_19848 METAL6_1166700_1350000 METAL6_1154700_1350000 0.024
R_VDD_111b_19849 METAL6_1154700_1350000 METAL6_1142700_1350000 0.024
R_VDD_111b_19850 METAL6_1142700_1350000 METAL6_1137000_1350000 0.0114
R_VDD_111b_19851 METAL6_1137000_1350000 METAL6_1125000_1350000 0.024
R_VDD_111b_19852 METAL6_1125000_1350000 METAL6_1113000_1350000 0.024
R_VDD_111b_19853 METAL6_1113000_1350000 METAL6_1019000_1350000 0.188
R_VDD_111b_19854 METAL6_1019000_1350000 METAL6_1007000_1350000 0.024
R_VDD_111b_19855 METAL6_1007000_1350000 METAL6_995000_1350000 0.024
R_VDD_111b_19856 METAL6_995000_1350000 METAL6_988000_1350000 0.014
R_VDD_111b_19857 METAL6_988000_1350000 METAL6_947400_1350000 0.0812
R_VDD_111b_19858 METAL6_947400_1350000 METAL6_940400_1350000 0.014
R_VDD_111b_19859 METAL6_940400_1350000 METAL6_928400_1350000 0.024
R_VDD_111b_19860 METAL6_928400_1350000 METAL6_916400_1350000 0.024
R_VDD_111b_19861 METAL6_916400_1350000 METAL6_719000_1350000 0.3948
R_VDD_111b_19862 METAL6_719000_1350000 METAL6_707000_1350000 0.024
R_VDD_111b_19863 METAL6_707000_1350000 METAL6_695000_1350000 0.024
R_VDD_111b_19864 METAL6_695000_1350000 METAL6_688000_1350000 0.014
R_VDD_111b_19865 METAL6_688000_1350000 METAL6_569000_1350000 0.238
R_VDD_111b_19866 METAL6_569000_1350000 METAL6_557000_1350000 0.024
R_VDD_111b_19867 METAL6_557000_1350000 METAL6_545000_1350000 0.024
R_VDD_111b_19868 METAL6_545000_1350000 METAL6_543000_1350000 0.004
R_VDD_111b_19869 METAL6_543000_1350000 METAL6_538000_1350000 0.01
R_VDD_111b_19870 METAL6_538000_1350000 METAL6_343000_1350000 0.39
R_VDD_111b_19871 METAL6_343000_1350000 METAL6_219000_1350000 0.248
R_VDD_111b_19872 METAL6_219000_1350000 METAL6_207000_1350000 0.024
R_VDD_111b_19873 METAL6_207000_1350000 METAL6_195000_1350000 0.024
R_VDD_111b_19874 METAL6_195000_1350000 METAL6_188000_1350000 0.014
R_VDD_111b_19875 METAL6_188000_1350000 METAL6_21500_1350000 0.333
R_VDD_111b_19876 METAL6_21500_1350000 METAL6_9500_1350000 0.024
R_VDD_111b_19877 METAL6_9500_1350000 METAL5_9500_1350000 0.1
R_VDD_111b_19878 METAL6_1731700_1564300 METAL6_1731700_1554500 0.0196
R_VDD_111b_19879 METAL6_1731700_1554500 METAL6_1731700_1552300 0.0044
R_VDD_111b_19880 METAL6_1888700_1540300 METAL6_1888700_1552300 0.024
R_VDD_111b_19881 METAL6_1888700_1552300 METAL6_1877400_1552300 0.0226
R_VDD_111b_19882 METAL6_1877400_1552300 METAL6_1874700_1552300 0.0054
R_VDD_111b_19883 METAL6_1874700_1552300 METAL6_1865400_1552300 0.0186
R_VDD_111b_19884 METAL6_1865400_1552300 METAL6_1853400_1552300 0.024
R_VDD_111b_19885 METAL6_1853400_1552300 METAL6_1846800_1552300 0.0132
R_VDD_111b_19886 METAL6_1846800_1552300 METAL6_1846600_1552300 0.0004
R_VDD_111b_19887 METAL6_1846600_1552300 METAL6_1846400_1552300 0.0004
R_VDD_111b_19888 METAL6_1846400_1552300 METAL6_1832800_1552300 0.0272
R_VDD_111b_19889 METAL6_1832800_1552300 METAL6_1812000_1552300 0.0416
R_VDD_111b_19890 METAL6_1812000_1552300 METAL6_1800000_1552300 0.024
R_VDD_111b_19891 METAL6_1800000_1552300 METAL6_1788000_1552300 0.024
R_VDD_111b_19892 METAL6_1788000_1552300 METAL6_1751800_1552300 0.0724
R_VDD_111b_19893 METAL6_1751800_1552300 METAL6_1751400_1552300 0.0008
R_VDD_111b_19894 METAL6_1751400_1552300 METAL6_1744000_1552300 0.0148
R_VDD_111b_19895 METAL6_1744000_1552300 METAL6_1743700_1552300 0.0006
R_VDD_111b_19896 METAL6_1743700_1552300 METAL6_1741800_1552300 0.0038
R_VDD_111b_19897 METAL6_1741800_1552300 METAL6_1739800_1552300 0.004
R_VDD_111b_19898 METAL6_1739800_1552300 METAL6_1731700_1552300 0.0162
R_VDD_111b_19899 METAL6_188000_1350000 METAL6_188000_1362000 0.024
R_VDD_111b_19900 METAL6_188000_1362000 METAL6_21500_1362000 0.333
R_VDD_111b_19901 METAL6_21500_1362000 METAL6_9500_1362000 0.024
R_VDD_111b_19902 METAL6_9500_1362000 METAL6_9500_1350000 0.024
R_VDD_111b_19903 METAL6_2031700_1564300 METAL6_2031700_1554500 0.0196
R_VDD_111b_19904 METAL6_2031700_1554500 METAL6_2031700_1552300 0.0044
R_VDD_111b_19905 METAL6_1888700_1552300 METAL6_1895200_1552300 0.013
R_VDD_111b_19906 METAL6_1895200_1552300 METAL6_1900700_1552300 0.011
R_VDD_111b_19907 METAL6_1900700_1552300 METAL6_1901600_1552300 0.0018
R_VDD_111b_19908 METAL6_1901600_1552300 METAL6_1907200_1552300 0.0112
R_VDD_111b_19909 METAL6_1907200_1552300 METAL6_1907400_1552300 0.0004
R_VDD_111b_19910 METAL6_1907400_1552300 METAL6_1913600_1552300 0.0124
R_VDD_111b_19911 METAL6_1913600_1552300 METAL6_1919200_1552300 0.0112
R_VDD_111b_19912 METAL6_1919200_1552300 METAL6_1925600_1552300 0.0128
R_VDD_111b_19913 METAL6_1925600_1552300 METAL6_1926200_1552300 0.0012
R_VDD_111b_19914 METAL6_1926200_1552300 METAL6_1927800_1552300 0.0032
R_VDD_111b_19915 METAL6_1927800_1552300 METAL6_1939800_1552300 0.024
R_VDD_111b_19916 METAL6_1939800_1552300 METAL6_1951800_1552300 0.024
R_VDD_111b_19917 METAL6_1951800_1552300 METAL6_1951900_1552300 0.0002
R_VDD_111b_19918 METAL6_1951900_1552300 METAL6_1988000_1552300 0.0722
R_VDD_111b_19919 METAL6_1988000_1552300 METAL6_2000000_1552300 0.024
R_VDD_111b_19920 METAL6_2000000_1552300 METAL6_2002400_1552300 0.0048
R_VDD_111b_19921 METAL6_2002400_1552300 METAL6_2006900_1552300 0.009
R_VDD_111b_19922 METAL6_2006900_1552300 METAL6_2012000_1552300 0.0102
R_VDD_111b_19923 METAL6_2012000_1552300 METAL6_2014400_1552300 0.0048
R_VDD_111b_19924 METAL6_2014400_1552300 METAL6_2018900_1552300 0.009
R_VDD_111b_19925 METAL6_2018900_1552300 METAL6_2019700_1552300 0.0016
R_VDD_111b_19926 METAL6_2019700_1552300 METAL6_2021200_1552300 0.003
R_VDD_111b_19927 METAL6_2021200_1552300 METAL6_2026400_1552300 0.0104
R_VDD_111b_19928 METAL6_2026400_1552300 METAL6_2030900_1552300 0.009
R_VDD_111b_19929 METAL6_2030900_1552300 METAL6_2031700_1552300 0.0016
R_VDD_111b_19930 METAL6_688000_1350000 METAL6_688000_1338000 0.024
R_VDD_111b_19931 METAL6_688000_1338000 METAL6_569000_1338000 0.238
R_VDD_111b_19932 METAL6_569000_1338000 METAL6_557000_1338000 0.024
R_VDD_111b_19933 METAL6_557000_1338000 METAL6_545000_1338000 0.024
R_VDD_111b_19934 METAL6_545000_1338000 METAL6_543000_1338000 0.004
R_VDD_111b_19935 METAL6_543000_1338000 METAL6_538000_1338000 0.01
R_VDD_111b_19936 METAL6_538000_1338000 METAL6_343000_1338000 0.39
R_VDD_111b_19937 METAL6_343000_1338000 METAL6_219000_1338000 0.248
R_VDD_111b_19938 METAL6_219000_1338000 METAL6_207000_1338000 0.024
R_VDD_111b_19939 METAL6_207000_1338000 METAL6_200000_1338000 0.014
R_VDD_111b_19940 METAL6_200000_1338000 METAL6_195000_1338000 0.01
R_VDD_111b_19941 METAL6_195000_1338000 METAL6_188000_1338000 0.014
R_VDD_111b_19942 METAL6_188000_1338000 METAL6_176000_1338000 0.024
R_VDD_111b_19943 METAL6_176000_1338000 METAL6_21500_1338000 0.309
R_VDD_111b_19944 METAL6_21500_1338000 METAL6_9500_1338000 0.024
R_VDD_111b_19945 METAL6_9500_1338000 METAL6_9500_1350000 0.024
I_VDD_111b_70 METAL6_1431700_1564300 gnd 0.04
I_VDD_111b_71 METAL6_1731700_1564300 gnd 0.04
I_VDD_111b_72 METAL6_2031700_1564300 gnd 0.04

.tran 1ns 1ns
.end
.control
set noaskquit
run
quit
.enddc
