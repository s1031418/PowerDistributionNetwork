#Comments
V_VDD1_1 METAL6_200000_0 gnd 1
R_VDD1_1 METAL6_200000_0 METAL6_200000_8000 0.016
R_VDD1_2 METAL6_200000_8000 METAL6_212000_8000 0.024
R_VDD1_3 METAL6_212000_8000 METAL6_367000_8000 0.31
R_VDD1_4 METAL6_367000_8000 METAL6_367000_20000 0.024
R_VDD1_5 METAL6_367000_20000 METAL6_367000_238000 0.436
R_VDD1_6 METAL6_367000_238000 METAL6_367000_308000 0.14
R_VDD1_7 METAL6_367000_308000 METAL6_379000_308000 0.024
R_VDD1_8 METAL6_379000_308000 METAL6_391000_308000 0.024
R_VDD1_9 METAL6_391000_308000 METAL6_398000_308000 0.014
R_VDD1_10 METAL6_398000_308000 METAL6_893000_308000 0.99
R_VDD1_11 METAL6_893000_308000 METAL6_1519000_308000 1.252
R_VDD1_12 METAL6_1519000_308000 METAL6_1531000_308000 0.024
R_VDD1_13 METAL6_1531000_308000 METAL6_1543000_308000 0.024
R_VDD1_14 METAL6_1543000_308000 METAL6_1550000_308000 0.014
R_VDD1_15 METAL6_1550000_308000 METAL6_1677000_308000 0.254
R_VDD1_16 METAL6_1677000_308000 METAL6_1689000_308000 0.024
R_VDD1_17 METAL6_1689000_308000 METAL6_1689000_312000 0.008
R_VDD1_18 METAL6_1689000_312000 METAL6_1689000_320000 0.016
R_VDD1_19 METAL6_1689000_320000 METAL6_1689000_332000 0.024
R_VDD1_20 METAL6_1689000_332000 METAL6_1689000_342000 0.02
R_VDD1_21 METAL6_1689000_342000 METAL6_1689000_354000 0.024
R_VDD1_22 METAL6_1701000_354000 METAL6_1689000_354000 0.024
R_VDD1_23 METAL6_1677000_308000 METAL6_1677000_296000 0.024
R_VDD1_24 METAL6_1677000_296000 METAL6_1550000_296000 0.254
R_VDD1_25 METAL6_1550000_296000 METAL6_1550000_238000 0.116
R_VDD1_26 METAL6_1550000_238000 METAL6_1550000_20000 0.436
R_VDD1_27 METAL6_1550000_20000 METAL6_1543000_20000 0.014
R_VDD1_28 METAL6_1543000_20000 METAL6_1531000_20000 0.024
R_VDD1_29 METAL6_1531000_20000 METAL6_1519000_20000 0.024
R_VDD1_30 METAL6_1519000_20000 METAL6_893000_20000 1.252
R_VDD1_31 METAL6_893000_20000 METAL6_403000_20000 0.98
R_VDD1_32 METAL6_403000_20000 METAL6_398000_20000 0.01
R_VDD1_33 METAL6_398000_20000 METAL6_391000_20000 0.014
R_VDD1_34 METAL6_391000_20000 METAL6_379000_20000 0.024
R_VDD1_35 METAL6_379000_20000 METAL5_379000_20000 0.1
R_VDD1_36 METAL5_379000_20000 METAL5_367000_20000 0.048
R_VDD1_37 METAL5_367000_20000 METAL5_355000_20000 0.048
R_VDD1_38 METAL5_355000_20000 METAL6_355000_20000 0.1
R_VDD1_39 METAL6_355000_20000 METAL6_343000_20000 0.024
R_VDD1_40 METAL6_343000_20000 METAL6_331000_20000 0.024
R_VDD1_41 METAL6_331000_20000 METAL6_224000_20000 0.214
R_VDD1_42 METAL6_224000_20000 METAL6_212000_20000 0.024
R_VDD1_43 METAL6_212000_20000 METAL6_200000_20000 0.024
R_VDD1_44 METAL6_200000_20000 METAL6_200000_8000 0.024
I_VDD1_1 METAL6_1701000_354000 gnd 0.005

V_VDD2_2 METAL5_0_500000 gnd 1
R_VDD2_45 METAL5_0_500000 METAL5_8000_500000 0.032
R_VDD2_46 METAL5_8000_500000 METAL6_8000_500000 0.1
R_VDD2_47 METAL6_8000_500000 METAL6_8000_512000 0.024
R_VDD2_48 METAL6_8000_512000 METAL6_20000_512000 0.024
R_VDD2_49 METAL6_20000_512000 METAL6_164000_512000 0.288
R_VDD2_50 METAL6_164000_512000 METAL6_176000_512000 0.024
R_VDD2_51 METAL6_176000_512000 METAL6_188000_512000 0.024
R_VDD2_52 METAL6_188000_512000 METAL6_188000_524000 0.024
R_VDD2_53 METAL6_188000_524000 METAL5_188000_524000 0.1
R_VDD2_54 METAL5_188000_524000 METAL5_200000_524000 0.048
R_VDD2_55 METAL5_200000_524000 METAL5_212000_524000 0.048
R_VDD2_56 METAL5_212000_524000 METAL6_212000_524000 0.1
R_VDD2_57 METAL6_212000_524000 METAL6_331000_524000 0.238
R_VDD2_58 METAL6_331000_524000 METAL6_343000_524000 0.024
R_VDD2_59 METAL6_343000_524000 METAL6_355000_524000 0.024
R_VDD2_60 METAL6_355000_524000 METAL6_367000_524000 0.024
R_VDD2_61 METAL6_367000_524000 METAL6_379000_524000 0.024
R_VDD2_62 METAL6_379000_524000 METAL6_391000_524000 0.024
R_VDD2_63 METAL6_391000_524000 METAL6_391000_532000 0.016
R_VDD2_64 METAL6_391000_532000 METAL6_391000_544000 0.024
R_VDD2_65 METAL6_391000_544000 METAL6_398000_544000 0.014
R_VDD2_66 METAL6_398000_544000 METAL6_893000_544000 0.99
R_VDD2_67 METAL6_893000_544000 METAL6_1519000_544000 1.252
R_VDD2_68 METAL6_1519000_544000 METAL6_1531000_544000 0.024
R_VDD2_69 METAL6_1531000_544000 METAL6_1543000_544000 0.024
R_VDD2_70 METAL6_1543000_544000 METAL6_1550000_544000 0.014
R_VDD2_71 METAL6_1550000_544000 METAL6_1677000_544000 0.254
R_VDD2_72 METAL6_1677000_544000 METAL6_1689000_544000 0.024
R_VDD2_73 METAL6_1701000_544000 METAL6_1689000_544000 0.024
I_VDD2_2 METAL6_1701000_544000 gnd 0.002

V_VDD3_3 METAL5_0_1000000 gnd 1
R_VDD3_74 METAL5_0_1000000 METAL5_8000_1000000 0.032
R_VDD3_75 METAL5_8000_1000000 METAL6_8000_1000000 0.1
R_VDD3_76 METAL6_8000_1000000 METAL6_8000_988000 0.024
R_VDD3_77 METAL6_8000_988000 METAL6_8000_826000 0.324
R_VDD3_78 METAL6_8000_826000 METAL6_8000_752000 0.148
R_VDD3_79 METAL6_8000_752000 METAL6_8000_556000 0.392
R_VDD3_80 METAL6_8000_556000 METAL6_20000_556000 0.024
R_VDD3_81 METAL6_20000_556000 METAL6_188000_556000 0.336
R_VDD3_82 METAL6_188000_556000 METAL6_188000_544000 0.024
R_VDD3_83 METAL6_188000_544000 METAL6_200000_544000 0.024
R_VDD3_84 METAL6_200000_544000 METAL6_200000_532000 0.024
R_VDD3_85 METAL6_200000_532000 METAL6_200000_512000 0.04
R_VDD3_86 METAL6_200000_512000 METAL6_212000_512000 0.024
R_VDD3_87 METAL6_212000_512000 METAL6_355000_512000 0.286
R_VDD3_88 METAL6_355000_512000 METAL6_355000_500000 0.024
R_VDD3_89 METAL6_355000_500000 METAL6_355000_488000 0.024
R_VDD3_90 METAL6_355000_488000 METAL6_355000_366000 0.244
R_VDD3_91 METAL6_355000_366000 METAL6_355000_354000 0.024
R_VDD3_92 METAL6_355000_354000 METAL6_355000_342000 0.024
R_VDD3_93 METAL6_355000_342000 METAL6_367000_342000 0.024
R_VDD3_94 METAL6_367000_342000 METAL6_379000_342000 0.024
R_VDD3_95 METAL6_379000_342000 METAL6_379000_332000 0.02
R_VDD3_96 METAL6_379000_332000 METAL6_379000_320000 0.024
R_VDD3_97 METAL6_379000_320000 METAL5_379000_320000 0.1
R_VDD3_98 METAL5_391000_320000 METAL5_379000_320000 0.048
R_VDD3_99 METAL6_1543000_1894000 METAL6_1531000_1894000 0.024
R_VDD3_100 METAL6_8000_1000000 METAL6_20000_1000000 0.024
R_VDD3_101 METAL6_20000_1000000 METAL6_176000_1000000 0.312
R_VDD3_102 METAL6_176000_1000000 METAL6_176000_1012000 0.024
R_VDD3_103 METAL6_176000_1012000 METAL6_176000_1762000 1.5
R_VDD3_104 METAL6_176000_1762000 METAL6_176000_1882000 0.24
R_VDD3_105 METAL6_176000_1882000 METAL6_188000_1882000 0.024
R_VDD3_106 METAL6_188000_1882000 METAL6_200000_1882000 0.024
R_VDD3_107 METAL6_200000_1882000 METAL6_212000_1882000 0.024
R_VDD3_108 METAL6_212000_1882000 METAL6_343000_1882000 0.262
R_VDD3_109 METAL6_343000_1882000 METAL6_343000_1894000 0.024
R_VDD3_110 METAL6_343000_1894000 METAL6_355000_1894000 0.024
R_VDD3_111 METAL6_355000_1894000 METAL6_367000_1894000 0.024
R_VDD3_112 METAL6_367000_1894000 METAL6_379000_1894000 0.024
R_VDD3_113 METAL6_379000_1894000 METAL6_391000_1894000 0.024
R_VDD3_114 METAL6_391000_1894000 METAL6_398000_1894000 0.014
R_VDD3_115 METAL6_398000_1894000 METAL6_893000_1894000 0.99
R_VDD3_116 METAL6_893000_1894000 METAL6_1519000_1894000 1.252
R_VDD3_117 METAL6_1519000_1894000 METAL6_1531000_1894000 0.024
I_VDD3_3 METAL5_391000_320000 gnd 0.002
I_VDD3_4 METAL6_1543000_1894000 gnd 0.003

.tran 1ns 1ns
.end
