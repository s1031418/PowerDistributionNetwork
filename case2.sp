#Comments
V_VDD1_1 METAL6_200000_0 gnd 1
R_VDD1_1 METAL6_200000_0 METAL6_200000_8000 0.016
R_VDD1_2 METAL6_200000_8000 METAL6_200000_20000 0.024
R_VDD1_3 METAL6_200000_20000 METAL6_200000_69500 0.099
R_VDD1_4 METAL6_200000_69500 METAL6_200000_162800 0.1866
R_VDD1_5 METAL6_200000_162800 METAL6_212000_162800 0.024
R_VDD1_6 METAL6_212000_162800 METAL6_488000_162800 0.552
R_VDD1_7 METAL6_488000_162800 METAL6_500000_162800 0.024
R_VDD1_8 METAL6_500000_162800 METAL6_500000_174800 0.024
R_VDD1_9 METAL6_500000_174800 METAL6_512000_174800 0.024
R_VDD1_10 METAL6_512000_174800 METAL6_624200_174800 0.2244
R_VDD1_11 METAL6_624200_174800 METAL6_624200_186800 0.024
R_VDD1_12 METAL6_624200_186800 METAL6_624200_193800 0.014
R_VDD1_13 METAL6_624200_193800 METAL6_624200_211300 0.035
R_VDD1_14 METAL6_624200_211300 METAL6_624200_223300 0.024
R_VDD1_15 METAL6_624200_223300 METAL6_624200_235300 0.024
R_VDD1_16 METAL6_624200_235300 METAL6_631200_235300 0.014
R_VDD1_17 METAL6_631200_235300 METAL6_643200_235300 0.024
R_VDD1_18 METAL6_643200_235300 METAL6_655200_235300 0.024
R_VDD1_19 METAL6_655200_235300 METAL6_688000_235300 0.0656
R_VDD1_20 METAL6_688000_235300 METAL6_688000_242300 0.014
R_VDD1_21 METAL6_688000_242300 METAL6_688000_388800 0.293
R_VDD1_22 METAL6_688000_388800 METAL6_688000_423700 0.0698
R_VDD1_23 METAL6_688000_423700 METAL6_688000_435700 0.024
R_VDD1_24 METAL6_688000_435700 METAL6_695000_435700 0.014
R_VDD1_25 METAL6_695000_435700 METAL6_707000_435700 0.024
R_VDD1_26 METAL6_707000_435700 METAL6_719000_435700 0.024
R_VDD1_27 METAL6_719000_435700 METAL6_755300_435700 0.0726
R_VDD1_28 METAL6_755300_435700 METAL6_762300_435700 0.014
R_VDD1_29 METAL6_762300_435700 METAL6_774300_435700 0.024
R_VDD1_30 METAL6_774300_435700 METAL6_786300_435700 0.024
R_VDD1_31 METAL6_786300_435700 METAL6_980500_435700 0.3884
R_VDD1_32 METAL6_980500_435700 METAL6_988000_435700 0.015
R_VDD1_33 METAL6_988000_435700 METAL6_1000000_435700 0.024
R_VDD1_34 METAL6_1000000_435700 METAL6_1005900_435700 0.0118
R_VDD1_35 METAL6_1005900_435700 METAL6_1012000_435700 0.0122
R_VDD1_36 METAL6_1012000_435700 METAL6_1032900_435700 0.0418
R_VDD1_37 METAL6_1032900_435700 METAL6_1049600_435700 0.0334
R_VDD1_38 METAL6_1049600_435700 METAL6_1079000_435700 0.0588
R_VDD1_39 METAL6_1079000_435700 METAL6_1079000_437300 0.0032
R_VDD1_40 METAL6_1079000_437300 METAL6_1079000_447200 0.0198
R_VDD1_41 METAL6_1079000_447200 METAL6_1079000_447700 0.001
R_VDD1_42 METAL6_1079000_447700 METAL6_1079000_454700 0.014
R_VDD1_43 METAL6_1079000_454700 METAL6_1079000_489500 0.0696
R_VDD1_44 METAL6_1079000_489500 METAL6_1079000_501500 0.024
R_VDD1_45 METAL6_1079000_501500 METAL6_1079000_510000 0.017
R_VDD1_46 METAL6_1079000_510000 METAL6_1079000_513500 0.007
R_VDD1_47 METAL6_1079000_513500 METAL6_1079000_522000 0.017
R_VDD1_48 METAL6_1079000_522000 METAL6_1079000_534000 0.024
R_VDD1_49 METAL6_1079000_534000 METAL6_1079000_541000 0.014
R_VDD1_50 METAL6_1079000_541000 METAL6_1079000_583500 0.085
R_VDD1_51 METAL6_1079000_583500 METAL6_1079000_642200 0.1174
R_VDD1_52 METAL6_1079000_642200 METAL6_1079000_649200 0.014
R_VDD1_53 METAL6_1079000_649200 METAL6_1079000_649700 0.001
R_VDD1_54 METAL6_1079000_649700 METAL6_1188000_649700 0.218
R_VDD1_55 METAL6_1188000_649700 METAL6_1200000_649700 0.024
R_VDD1_56 METAL6_1200000_649700 METAL6_1212000_649700 0.024
R_VDD1_57 METAL6_1212000_649700 METAL6_1299000_649700 0.174
R_VDD1_58 METAL6_1299000_649700 METAL6_1311000_649700 0.024
R_VDD1_59 METAL6_1311000_649700 METAL6_1323000_649700 0.024
R_VDD1_60 METAL6_1323000_649700 METAL6_1488000_649700 0.33
R_VDD1_61 METAL6_1488000_649700 METAL6_1499000_649700 0.022
R_VDD1_62 METAL6_1499000_649700 METAL6_1499000_658600 0.0178
R_VDD1_63 METAL6_1499000_658600 METAL6_1499000_661200 0.0052
R_VDD1_64 METAL6_1499000_661200 METAL6_1499000_673200 0.024
R_VDD1_65 METAL6_1499000_673200 METAL6_1499000_736000 0.1256
R_VDD1_66 METAL6_1499000_736000 METAL6_1499000_829400 0.1868
R_VDD1_67 METAL6_1499000_829400 METAL6_1500000_829400 0.002
R_VDD1_68 METAL6_1500000_829400 METAL6_1511000_829400 0.022
R_VDD1_69 METAL6_1511000_829400 METAL6_1512000_829400 0.002
R_VDD1_70 METAL6_1512000_829400 METAL6_1523000_829400 0.022
R_VDD1_71 METAL6_1523000_829400 METAL6_1550500_829400 0.055
R_VDD1_72 METAL6_1550500_829400 METAL6_1562500_829400 0.024
R_VDD1_73 METAL6_1562500_829400 METAL6_1574500_829400 0.024
R_VDD1_74 METAL6_1574500_829400 METAL6_1575900_829400 0.0028
R_VDD1_75 METAL6_1575900_829400 METAL6_1587900_829400 0.024
R_VDD1_76 METAL6_1587900_829400 METAL6_1599900_829400 0.024
R_VDD1_77 METAL6_1599900_829400 METAL6_1602900_829400 0.006
R_VDD1_78 METAL6_1602900_829400 METAL6_1614900_829400 0.024
R_VDD1_79 METAL6_1614900_829400 METAL6_1619600_829400 0.0094
R_VDD1_80 METAL6_1619600_829400 METAL6_1626900_829400 0.0146
R_VDD1_81 METAL6_1626900_829400 METAL6_1631600_829400 0.0094
R_VDD1_82 METAL6_1631600_829400 METAL6_1643600_829400 0.024
R_VDD1_83 METAL6_1643600_829400 METAL6_1750500_829400 0.2138
R_VDD1_84 METAL6_1750500_829400 METAL6_1762500_829400 0.024
R_VDD1_85 METAL6_1762500_829400 METAL6_1774500_829400 0.024
R_VDD1_86 METAL6_1774500_829400 METAL6_1775900_829400 0.0028
R_VDD1_87 METAL6_1775900_829400 METAL6_1787900_829400 0.024
R_VDD1_88 METAL6_1787900_829400 METAL6_1799900_829400 0.024
R_VDD1_89 METAL6_1799900_829400 METAL6_1802900_829400 0.006
R_VDD1_90 METAL6_1802900_829400 METAL6_1814900_829400 0.024
R_VDD1_91 METAL6_1814900_829400 METAL6_1819600_829400 0.0094
R_VDD1_92 METAL6_1819600_829400 METAL6_1826900_829400 0.0146
R_VDD1_93 METAL6_1826900_829400 METAL6_1826900_841300 0.0238
R_VDD1_94 METAL6_1826900_841300 METAL6_1831600_841300 0.0094
R_VDD1_95 METAL6_1831600_841300 METAL6_1843600_841300 0.024
R_VDD1_96 METAL6_1843600_841300 METAL6_1988000_841300 0.2888
R_VDD1_97 METAL6_1988000_841300 METAL6_1994500_841300 0.013
R_VDD1_98 METAL6_1994500_841300 METAL6_2000000_841300 0.011
R_VDD1_99 METAL6_2000000_841300 METAL6_2012000_841300 0.024
R_VDD1_100 METAL6_2012000_841300 METAL6_2019900_841300 0.0158
R_VDD1_101 METAL6_2019900_841300 METAL6_2046900_841300 0.054
R_VDD1_102 METAL6_2046900_841300 METAL6_2063600_841300 0.0334
R_VDD1_103 METAL6_2063600_841300 METAL6_2093000_841300 0.0588
R_VDD1_104 METAL6_2093000_841300 METAL6_2271000_841300 0.356
R_VDD1_105 METAL6_2271000_841300 METAL6_2283000_841300 0.024
R_VDD1_106 METAL6_2283000_841300 METAL6_2283000_841400 0.0002
R_VDD1_107 METAL6_2283000_841400 METAL6_2283000_853400 0.024
R_VDD1_108 METAL6_2283000_853400 METAL6_2283000_853700 0.0006
R_VDD1_109 METAL6_2283000_853700 METAL6_2283000_860400 0.0134
R_VDD1_110 METAL6_2283000_860400 METAL6_2283000_1036300 0.3518
R_VDD1_111 METAL6_2283000_1036300 METAL6_2283000_1041400 0.0102
R_VDD1_112 METAL6_2283000_1041400 METAL6_2283000_1043300 0.0038
R_VDD1_113 METAL6_2283000_1043300 METAL6_2283000_1048700 0.0108
R_VDD1_114 METAL6_2283000_1048700 METAL6_2283000_1055300 0.0132
R_VDD1_115 METAL6_2283000_1055300 METAL6_2283000_1055400 0.0002
R_VDD1_116 METAL6_2283000_1055400 METAL6_2283000_1055700 0.0006
R_VDD1_117 METAL6_2283000_1055700 METAL6_2283000_1067300 0.0232
R_VDD1_118 METAL6_2283000_1067300 METAL6_2283000_1067700 0.0008
R_VDD1_119 METAL6_2283000_1067700 METAL6_2283000_1079700 0.024
R_VDD1_120 METAL6_2283000_1079700 METAL6_2283000_1128600 0.0978
R_VDD1_121 METAL6_2283000_1128600 METAL6_2283000_1140600 0.024
R_VDD1_122 METAL6_2283000_1140600 METAL6_2283000_1152600 0.024
R_VDD1_123 METAL6_2283000_1152600 METAL6_2283000_1236400 0.1676
R_VDD1_124 METAL6_2283000_1236400 METAL6_2283000_1243400 0.014
R_VDD1_125 METAL6_2283000_1243400 METAL6_2283000_1255400 0.024
R_VDD1_126 METAL6_2283000_1255400 METAL6_2283000_1267400 0.024
R_VDD1_127 METAL6_2283000_1267400 METAL6_2283000_1272600 0.0104
R_VDD1_128 METAL6_2283000_1272600 METAL6_2283000_1306300 0.0674
R_VDD1_129 METAL6_2283000_1306300 METAL6_2283000_1318000 0.0234
R_VDD1_130 METAL6_2283000_1318000 METAL6_2283000_1336300 0.0366
R_VDD1_131 METAL6_2283000_1336300 METAL6_2283000_1348300 0.024
R_VDD1_132 METAL6_2295000_1348300 METAL6_2283000_1348300 0.024
I_VDD1_1 METAL6_2295000_1348300 gnd 0.005

V_VDD2_2 METAL6_500000_0 gnd 1.2
R_VDD2_133 METAL6_500000_0 METAL6_500000_8000 0.016
R_VDD2_134 METAL6_500000_8000 METAL6_512000_8000 0.024
R_VDD2_135 METAL6_512000_8000 METAL6_612200_8000 0.2004
R_VDD2_136 METAL6_612200_8000 METAL6_624200_8000 0.024
R_VDD2_137 METAL6_624200_8000 METAL6_624200_20000 0.024
R_VDD2_138 METAL6_624200_20000 METAL6_624200_69500 0.099
R_VDD2_139 METAL6_624200_69500 METAL6_624200_150800 0.1626
R_VDD2_140 METAL6_624200_150800 METAL6_624200_162800 0.024
R_VDD2_141 METAL6_624200_162800 METAL6_631200_162800 0.014
R_VDD2_142 METAL6_631200_162800 METAL6_636200_162800 0.01
R_VDD2_143 METAL6_636200_162800 METAL6_643200_162800 0.014
R_VDD2_144 METAL6_643200_162800 METAL6_655200_162800 0.024
R_VDD2_145 METAL6_655200_162800 METAL6_676000_162800 0.0416
R_VDD2_146 METAL6_676000_162800 METAL6_688000_162800 0.024
R_VDD2_147 METAL6_688000_162800 METAL6_695000_162800 0.014
R_VDD2_148 METAL6_695000_162800 METAL6_700000_162800 0.01
R_VDD2_149 METAL6_700000_162800 METAL6_707000_162800 0.014
R_VDD2_150 METAL6_707000_162800 METAL6_719000_162800 0.024
R_VDD2_151 METAL6_719000_162800 METAL6_755300_162800 0.0726
R_VDD2_152 METAL6_755300_162800 METAL6_762300_162800 0.014
R_VDD2_153 METAL6_762300_162800 METAL6_774300_162800 0.024
R_VDD2_154 METAL6_774300_162800 METAL6_786300_162800 0.024
R_VDD2_155 METAL6_786300_162800 METAL6_980500_162800 0.3884
R_VDD2_156 METAL6_980500_162800 METAL6_988000_162800 0.015
R_VDD2_157 METAL6_988000_162800 METAL6_1000000_162800 0.024
R_VDD2_158 METAL6_1000000_162800 METAL6_1005900_162800 0.0118
R_VDD2_159 METAL6_1005900_162800 METAL6_1012000_162800 0.0122
R_VDD2_160 METAL6_1012000_162800 METAL6_1032900_162800 0.0418
R_VDD2_161 METAL6_1032900_162800 METAL6_1049600_162800 0.0334
R_VDD2_162 METAL6_1049600_162800 METAL6_1067000_162800 0.0348
R_VDD2_163 METAL6_1067000_162800 METAL6_1079000_162800 0.024
R_VDD2_164 METAL6_1079000_162800 METAL6_1091000_162800 0.024
R_VDD2_165 METAL6_1091000_162800 METAL6_1188000_162800 0.194
R_VDD2_166 METAL6_1188000_162800 METAL6_1200000_162800 0.024
R_VDD2_167 METAL6_1200000_162800 METAL6_1212000_162800 0.024
R_VDD2_168 METAL6_1212000_162800 METAL6_1299000_162800 0.174
R_VDD2_169 METAL6_1299000_162800 METAL6_1311000_162800 0.024
R_VDD2_170 METAL6_1311000_162800 METAL6_1323000_162800 0.024
R_VDD2_171 METAL6_1323000_162800 METAL6_1487000_162800 0.328
R_VDD2_172 METAL6_1487000_162800 METAL6_1488000_162800 0.002
R_VDD2_173 METAL6_1488000_162800 METAL5_1488000_162800 0.1
R_VDD2_174 METAL5_1488000_162800 METAL5_1499000_162800 0.044
R_VDD2_175 METAL5_1499000_162800 METAL5_1500000_162800 0.004
R_VDD2_176 METAL5_1500000_162800 METAL5_1511000_162800 0.044
R_VDD2_177 METAL5_1511000_162800 METAL5_1512000_162800 0.004
R_VDD2_178 METAL5_1512000_162800 METAL5_1523000_162800 0.044
R_VDD2_179 METAL5_1523000_162800 METAL5_1524000_162800 0.004
R_VDD2_180 METAL5_1524000_162800 METAL6_1524000_162800 0.1
R_VDD2_181 METAL6_1524000_162800 METAL6_1535000_162800 0.022
R_VDD2_182 METAL6_1535000_162800 METAL6_1538500_162800 0.007
R_VDD2_183 METAL6_1538500_162800 METAL6_1550500_162800 0.024
R_VDD2_184 METAL6_1550500_162800 METAL6_1562500_162800 0.024
R_VDD2_185 METAL6_1562500_162800 METAL6_1574500_162800 0.024
R_VDD2_186 METAL6_1574500_162800 METAL6_1574500_174800 0.024
R_VDD2_187 METAL6_1574500_174800 METAL6_1575900_174800 0.0028
R_VDD2_188 METAL6_1575900_174800 METAL6_1586500_174800 0.0212
R_VDD2_189 METAL6_1586500_174800 METAL6_1586500_186800 0.024
R_VDD2_190 METAL6_1586500_186800 METAL6_1586500_193800 0.014
R_VDD2_191 METAL6_1586500_193800 METAL6_1586500_198800 0.01
R_VDD2_192 METAL6_1586500_198800 METAL6_1586500_211300 0.025
R_VDD2_193 METAL6_1586500_211300 METAL6_1586500_223300 0.024
R_VDD2_194 METAL6_1586500_223300 METAL6_1586500_235300 0.024
R_VDD2_195 METAL6_1586500_235300 METAL6_1586500_242300 0.014
R_VDD2_196 METAL6_1586500_242300 METAL6_1586500_247300 0.01
R_VDD2_197 METAL6_1586500_247300 METAL6_1586500_388800 0.283
R_VDD2_198 METAL6_1586500_388800 METAL6_1586500_399700 0.0218
R_VDD2_199 METAL6_1586500_399700 METAL6_1586500_411700 0.024
R_VDD2_200 METAL6_1586500_411700 METAL6_1587900_411700 0.0028
R_VDD2_201 METAL6_1587900_411700 METAL6_1599900_411700 0.024
R_VDD2_202 METAL6_1599900_411700 METAL6_1602900_411700 0.006
R_VDD2_203 METAL6_1602900_411700 METAL6_1614900_411700 0.024
R_VDD2_204 METAL6_1614900_411700 METAL6_1619600_411700 0.0094
R_VDD2_205 METAL6_1619600_411700 METAL6_1626900_411700 0.0146
R_VDD2_206 METAL6_1626900_411700 METAL6_1631600_411700 0.0094
R_VDD2_207 METAL6_1631600_411700 METAL6_1643600_411700 0.024
R_VDD2_208 METAL6_1643600_411700 METAL6_1750500_411700 0.2138
R_VDD2_209 METAL6_1750500_411700 METAL6_1762500_411700 0.024
R_VDD2_210 METAL6_1762500_411700 METAL6_1774500_411700 0.024
R_VDD2_211 METAL6_1774500_411700 METAL6_1775900_411700 0.0028
R_VDD2_212 METAL6_1775900_411700 METAL6_1787900_411700 0.024
R_VDD2_213 METAL6_1787900_411700 METAL6_1799900_411700 0.024
R_VDD2_214 METAL6_1799900_411700 METAL6_1802900_411700 0.006
R_VDD2_215 METAL6_1802900_411700 METAL6_1814900_411700 0.024
R_VDD2_216 METAL6_1814900_411700 METAL6_1819600_411700 0.0094
R_VDD2_217 METAL6_1819600_411700 METAL6_1826900_411700 0.0146
R_VDD2_218 METAL6_1826900_411700 METAL6_1831600_411700 0.0094
R_VDD2_219 METAL6_1831600_411700 METAL6_1838900_411700 0.0146
R_VDD2_220 METAL6_1838900_411700 METAL6_1843600_411700 0.0094
R_VDD2_221 METAL6_1843600_411700 METAL6_1988000_411700 0.2888
R_VDD2_222 METAL6_1988000_411700 METAL6_1994500_411700 0.013
R_VDD2_223 METAL6_1994500_411700 METAL6_1995900_411700 0.0028
R_VDD2_224 METAL6_1995900_411700 METAL6_2000000_411700 0.0082
R_VDD2_225 METAL6_2000000_411700 METAL6_2007900_411700 0.0158
R_VDD2_226 METAL6_2007900_411700 METAL6_2012000_411700 0.0082
R_VDD2_227 METAL6_2012000_411700 METAL6_2019900_411700 0.0158
R_VDD2_228 METAL6_2019900_411700 METAL6_2031900_411700 0.024
R_VDD2_229 METAL6_2031900_411700 METAL6_2039600_411700 0.0154
R_VDD2_230 METAL6_2039600_411700 METAL6_2043900_411700 0.0086
R_VDD2_231 METAL6_2043900_411700 METAL6_2046900_411700 0.006
R_VDD2_232 METAL6_2046900_411700 METAL6_2051600_411700 0.0094
R_VDD2_233 METAL6_2051600_411700 METAL6_2063600_411700 0.024
R_VDD2_234 METAL6_2063600_411700 METAL6_2075600_411700 0.024
R_VDD2_235 METAL6_2075600_411700 METAL6_2081000_411700 0.0108
R_VDD2_236 METAL6_2081000_411700 METAL6_2087600_411700 0.0132
R_VDD2_237 METAL6_2087600_411700 METAL6_2093000_411700 0.0108
R_VDD2_238 METAL6_2093000_411700 METAL6_2099600_411700 0.0132
R_VDD2_239 METAL6_2099600_411700 METAL6_2105000_411700 0.0108
R_VDD2_240 METAL6_2105000_411700 METAL6_2117000_411700 0.024
R_VDD2_241 METAL6_2117000_411700 METAL6_2271000_411700 0.308
R_VDD2_242 METAL6_2271000_411700 METAL6_2271000_423700 0.024
R_VDD2_243 METAL6_2271000_423700 METAL6_2271000_435700 0.024
R_VDD2_244 METAL6_2271000_435700 METAL6_2271000_437300 0.0032
R_VDD2_245 METAL6_2271000_437300 METAL6_2271000_447200 0.0198
R_VDD2_246 METAL6_2271000_447200 METAL6_2271000_447700 0.001
R_VDD2_247 METAL6_2271000_447700 METAL6_2271000_454700 0.014
R_VDD2_248 METAL6_2271000_454700 METAL6_2271000_489500 0.0696
R_VDD2_249 METAL6_2271000_489500 METAL6_2271000_501500 0.024
R_VDD2_250 METAL6_2271000_501500 METAL6_2271000_510000 0.017
R_VDD2_251 METAL6_2271000_510000 METAL6_2271000_513500 0.007
R_VDD2_252 METAL6_2271000_513500 METAL6_2271000_522000 0.017
R_VDD2_253 METAL6_2271000_522000 METAL6_2271000_534000 0.024
R_VDD2_254 METAL6_2271000_534000 METAL6_2271000_541000 0.014
R_VDD2_255 METAL6_2271000_541000 METAL6_2271000_583500 0.085
R_VDD2_256 METAL6_2271000_583500 METAL6_2271000_637700 0.1084
R_VDD2_257 METAL6_2271000_637700 METAL6_2271000_642200 0.009
R_VDD2_258 METAL6_2271000_642200 METAL6_2271000_649200 0.014
R_VDD2_259 METAL6_2271000_649200 METAL6_2271000_649700 0.001
R_VDD2_260 METAL6_2271000_649700 METAL6_2271000_658600 0.0178
R_VDD2_261 METAL6_2271000_658600 METAL6_2271000_661200 0.0052
R_VDD2_262 METAL6_2271000_661200 METAL6_2271000_661700 0.001
R_VDD2_263 METAL6_2271000_661700 METAL6_2271000_673200 0.023
R_VDD2_264 METAL6_2271000_673200 METAL6_2271000_673700 0.001
R_VDD2_265 METAL6_2271000_673700 METAL6_2271000_736000 0.1246
R_VDD2_266 METAL6_2271000_736000 METAL6_2271000_805300 0.1386
R_VDD2_267 METAL6_2271000_805300 METAL6_2271000_805400 0.0002
R_VDD2_268 METAL6_2271000_805400 METAL6_2271000_817300 0.0238
R_VDD2_269 METAL6_2271000_817300 METAL6_2271000_817400 0.0002
R_VDD2_270 METAL6_2271000_817400 METAL6_2271000_829300 0.0238
R_VDD2_271 METAL6_2271000_829300 METAL5_2271000_829300 0.1
R_VDD2_272 METAL5_2271000_829300 METAL5_2271000_829400 0.0004
R_VDD2_273 METAL5_2271000_829400 METAL5_2271000_841300 0.0476
R_VDD2_274 METAL5_2271000_841300 METAL5_2271000_841400 0.0004
R_VDD2_275 METAL5_2271000_841400 METAL5_2271000_853300 0.0476
R_VDD2_276 METAL5_2271000_853300 METAL6_2271000_853300 0.1
R_VDD2_277 METAL6_2271000_853300 METAL6_2271000_853400 0.0002
R_VDD2_278 METAL6_2271000_853400 METAL6_2271000_853700 0.0006
R_VDD2_279 METAL6_2271000_853700 METAL6_2271000_860400 0.0134
R_VDD2_280 METAL6_2271000_860400 METAL6_2271000_865300 0.0098
R_VDD2_281 METAL6_2271000_865300 METAL6_2271000_1036300 0.342
R_VDD2_282 METAL6_2271000_1036300 METAL6_2271000_1041400 0.0102
R_VDD2_283 METAL6_2271000_1041400 METAL6_2271000_1043300 0.0038
R_VDD2_284 METAL6_2271000_1043300 METAL6_2271000_1048700 0.0108
R_VDD2_285 METAL6_2271000_1048700 METAL6_2271000_1055300 0.0132
R_VDD2_286 METAL6_2271000_1055300 METAL6_2271000_1055400 0.0002
R_VDD2_287 METAL6_2271000_1055400 METAL6_2271000_1055700 0.0006
R_VDD2_288 METAL6_2271000_1055700 METAL6_2271000_1067300 0.0232
R_VDD2_289 METAL6_2271000_1067300 METAL6_2271000_1067700 0.0008
R_VDD2_290 METAL6_2271000_1067700 METAL6_2271000_1079700 0.024
R_VDD2_291 METAL6_2271000_1079700 METAL6_2271000_1128600 0.0978
R_VDD2_292 METAL6_2271000_1128600 METAL6_2271000_1140600 0.024
R_VDD2_293 METAL6_2271000_1140600 METAL6_2271000_1152600 0.024
R_VDD2_294 METAL6_2271000_1152600 METAL6_2271000_1164600 0.024
R_VDD2_295 METAL6_2271000_1164600 METAL6_2271000_1236400 0.1436
R_VDD2_296 METAL6_2271000_1236400 METAL6_2271000_1243400 0.014
R_VDD2_297 METAL6_2271000_1243400 METAL6_2271000_1255400 0.024
R_VDD2_298 METAL6_2271000_1255400 METAL6_2271000_1267400 0.024
R_VDD2_299 METAL6_2271000_1267400 METAL6_2271000_1272600 0.0104
R_VDD2_300 METAL6_2271000_1272600 METAL6_2271000_1279400 0.0136
R_VDD2_301 METAL6_2271000_1279400 METAL6_2271000_1306300 0.0538
R_VDD2_302 METAL6_2271000_1306300 METAL6_2271000_1318000 0.0234
R_VDD2_303 METAL6_2271000_1318000 METAL6_2271000_1336300 0.0366
R_VDD2_304 METAL6_2271000_1336300 METAL6_2271000_1347100 0.0216
R_VDD2_305 METAL6_2271000_1347100 METAL6_2271000_1348300 0.0024
R_VDD2_306 METAL6_2271000_1348300 METAL6_2271000_1359100 0.0216
R_VDD2_307 METAL6_2271000_1359100 METAL6_2271000_1360300 0.0024
R_VDD2_308 METAL6_2271000_1360300 METAL6_2283000_1360300 0.024
R_VDD2_309 METAL6_2283000_1360300 METAL6_2283000_1371100 0.0216
R_VDD2_310 METAL6_2283000_1371100 METAL6_2283000_1383100 0.024
R_VDD2_311 METAL6_2283000_1383100 METAL6_2283000_1390100 0.014
R_VDD2_312 METAL6_2283000_1390100 METAL6_2283000_1438000 0.0958
R_VDD2_313 METAL6_2283000_1438000 METAL6_2283000_1450000 0.024
R_VDD2_314 METAL6_2283000_1450000 METAL6_2283000_1462000 0.024
R_VDD2_315 METAL6_2283000_1462000 METAL6_2283000_1526300 0.1286
R_VDD2_316 METAL6_2283000_1526300 METAL6_2283000_1538300 0.024
R_VDD2_317 METAL6_2295000_1538300 METAL6_2283000_1538300 0.024
I_VDD2_2 METAL6_2295000_1538300 gnd 0.002

V_VDD3_3 METAL6_1000000_0 gnd 1
R_VDD3_318 METAL6_1000000_0 METAL6_1000000_8000 0.016
R_VDD3_319 METAL6_1000000_8000 METAL6_1000000_20000 0.024
R_VDD3_320 METAL6_1000000_20000 METAL6_1000000_69500 0.099
R_VDD3_321 METAL6_1000000_69500 METAL6_1000000_150800 0.1626
R_VDD3_322 METAL6_1000000_150800 METAL5_1000000_150800 0.1
R_VDD3_323 METAL5_1000000_150800 METAL5_1000000_162800 0.048
R_VDD3_324 METAL5_1000000_162800 METAL5_1000000_174800 0.048
R_VDD3_325 METAL5_1000000_174800 METAL6_1000000_174800 0.1
R_VDD3_326 METAL6_1000000_174800 METAL6_988000_174800 0.024
R_VDD3_327 METAL6_988000_174800 METAL6_988000_186800 0.024
R_VDD3_328 METAL6_988000_186800 METAL6_980500_186800 0.015
R_VDD3_329 METAL6_980500_186800 METAL6_786300_186800 0.3884
R_VDD3_330 METAL6_786300_186800 METAL6_774300_186800 0.024
R_VDD3_331 METAL6_774300_186800 METAL6_774300_193800 0.014
R_VDD3_332 METAL6_774300_193800 METAL6_774300_198800 0.01
R_VDD3_333 METAL6_774300_198800 METAL6_774300_211300 0.025
R_VDD3_334 METAL6_774300_211300 METAL6_774300_223300 0.024
R_VDD3_335 METAL6_774300_223300 METAL6_774300_235300 0.024
R_VDD3_336 METAL6_774300_235300 METAL6_774300_242300 0.014
R_VDD3_337 METAL6_774300_242300 METAL6_774300_247300 0.01
R_VDD3_338 METAL6_774300_247300 METAL6_774300_388800 0.283
R_VDD3_339 METAL6_774300_388800 METAL6_774300_399700 0.0218
R_VDD3_340 METAL6_774300_399700 METAL6_774300_411700 0.024
R_VDD3_341 METAL6_774300_411700 METAL6_774300_423700 0.024
R_VDD3_342 METAL6_774300_423700 METAL5_774300_423700 0.1
R_VDD3_343 METAL5_774300_423700 METAL5_774300_435700 0.048
R_VDD3_344 METAL5_774300_435700 METAL5_774300_437300 0.0064
R_VDD3_345 METAL5_774300_437300 METAL5_774300_447200 0.0396
R_VDD3_346 METAL5_774300_447200 METAL5_774300_447700 0.002
R_VDD3_347 METAL5_774300_447700 METAL6_774300_447700 0.1
R_VDD3_348 METAL6_774300_447700 METAL6_774300_454700 0.014
R_VDD3_349 METAL6_774300_454700 METAL6_774300_489500 0.0696
R_VDD3_350 METAL6_774300_489500 METAL6_774300_501500 0.024
R_VDD3_351 METAL6_774300_501500 METAL6_774300_510000 0.017
R_VDD3_352 METAL6_774300_510000 METAL6_774300_513500 0.007
R_VDD3_353 METAL6_774300_513500 METAL6_774300_522000 0.017
R_VDD3_354 METAL6_774300_522000 METAL6_774300_534000 0.024
R_VDD3_355 METAL6_774300_534000 METAL6_774300_541000 0.014
R_VDD3_356 METAL6_774300_541000 METAL6_774300_583500 0.085
R_VDD3_357 METAL6_774300_583500 METAL6_774300_637700 0.1084
R_VDD3_358 METAL6_774300_637700 METAL6_774300_642200 0.009
R_VDD3_359 METAL6_774300_642200 METAL6_774300_649200 0.014
R_VDD3_360 METAL6_774300_649200 METAL6_774300_649700 0.001
R_VDD3_361 METAL6_774300_649700 METAL6_774300_658600 0.0178
R_VDD3_362 METAL6_774300_658600 METAL6_774300_661200 0.0052
R_VDD3_363 METAL6_774300_661200 METAL6_774300_661700 0.001
R_VDD3_364 METAL6_774300_661700 METAL6_774300_673200 0.023
R_VDD3_365 METAL6_774300_673200 METAL6_774300_673700 0.001
R_VDD3_366 METAL6_774300_673700 METAL6_774300_736000 0.1246
R_VDD3_367 METAL6_774300_736000 METAL6_774300_805300 0.1386
R_VDD3_368 METAL6_774300_805300 METAL6_774300_805400 0.0002
R_VDD3_369 METAL6_774300_805400 METAL6_774300_817300 0.0238
R_VDD3_370 METAL6_774300_817300 METAL6_774300_817400 0.0002
R_VDD3_371 METAL6_774300_817400 METAL6_774300_829300 0.0238
R_VDD3_372 METAL6_774300_829300 METAL6_774300_829400 0.0002
R_VDD3_373 METAL6_774300_829400 METAL6_774300_841300 0.0238
R_VDD3_374 METAL6_774300_841300 METAL6_774300_841400 0.0002
R_VDD3_375 METAL6_774300_841400 METAL6_774300_853300 0.0238
R_VDD3_376 METAL6_774300_853300 METAL6_774300_853400 0.0002
R_VDD3_377 METAL6_774300_853400 METAL6_774300_853700 0.0006
R_VDD3_378 METAL6_774300_853700 METAL6_774300_860400 0.0134
R_VDD3_379 METAL6_774300_860400 METAL6_774300_865300 0.0098
R_VDD3_380 METAL6_774300_865300 METAL6_774300_1036300 0.342
R_VDD3_381 METAL6_774300_1036300 METAL6_774300_1041400 0.0102
R_VDD3_382 METAL6_774300_1041400 METAL6_774300_1043300 0.0038
R_VDD3_383 METAL6_774300_1043300 METAL6_774300_1048700 0.0108
R_VDD3_384 METAL6_774300_1048700 METAL6_774300_1055300 0.0132
R_VDD3_385 METAL6_774300_1055300 METAL6_774300_1055400 0.0002
R_VDD3_386 METAL6_774300_1055400 METAL6_774300_1055700 0.0006
R_VDD3_387 METAL6_774300_1055700 METAL6_774300_1067300 0.0232
R_VDD3_388 METAL6_774300_1067300 METAL6_774300_1067700 0.0008
R_VDD3_389 METAL6_774300_1067700 METAL6_774300_1079700 0.024
R_VDD3_390 METAL6_774300_1079700 METAL6_774300_1128600 0.0978
R_VDD3_391 METAL6_774300_1128600 METAL6_774300_1140600 0.024
R_VDD3_392 METAL6_774300_1140600 METAL6_774300_1152600 0.024
R_VDD3_393 METAL6_774300_1152600 METAL6_774300_1164600 0.024
R_VDD3_394 METAL6_774300_1164600 METAL6_774300_1236400 0.1436
R_VDD3_395 METAL6_774300_1236400 METAL6_774300_1243400 0.014
R_VDD3_396 METAL6_774300_1243400 METAL6_774300_1255400 0.024
R_VDD3_397 METAL6_774300_1255400 METAL6_774300_1267400 0.024
R_VDD3_398 METAL6_774300_1267400 METAL6_774300_1272600 0.0104
R_VDD3_399 METAL6_774300_1272600 METAL6_774300_1279400 0.0136
R_VDD3_400 METAL6_774300_1279400 METAL6_774300_1306300 0.0538
R_VDD3_401 METAL6_774300_1306300 METAL6_774300_1318000 0.0234
R_VDD3_402 METAL6_774300_1318000 METAL6_774300_1336300 0.0366
R_VDD3_403 METAL6_774300_1336300 METAL6_774300_1347100 0.0216
R_VDD3_404 METAL6_774300_1347100 METAL6_774300_1348300 0.0024
R_VDD3_405 METAL6_774300_1348300 METAL6_774300_1359100 0.0216
R_VDD3_406 METAL6_774300_1359100 METAL6_774300_1360300 0.0024
R_VDD3_407 METAL6_774300_1360300 METAL6_774300_1371100 0.0216
R_VDD3_408 METAL6_774300_1371100 METAL6_774300_1372300 0.0024
R_VDD3_409 METAL6_774300_1372300 METAL6_774300_1383100 0.0216
R_VDD3_410 METAL6_774300_1383100 METAL6_774300_1390100 0.014
R_VDD3_411 METAL6_774300_1390100 METAL6_774300_1438000 0.0958
R_VDD3_412 METAL6_774300_1438000 METAL6_774300_1450000 0.024
R_VDD3_413 METAL6_762300_1450000 METAL6_774300_1450000 0.024
R_VDD3_414 METAL6_695000_1140600 METAL6_707000_1140600 0.024
R_VDD3_415 METAL6_774300_1164600 METAL6_762300_1164600 0.024
R_VDD3_416 METAL6_762300_1164600 METAL6_762300_1152600 0.024
R_VDD3_417 METAL6_762300_1152600 METAL6_762300_1140600 0.024
R_VDD3_418 METAL6_762300_1140600 METAL6_755300_1140600 0.014
R_VDD3_419 METAL6_755300_1140600 METAL6_719000_1140600 0.0726
R_VDD3_420 METAL6_719000_1140600 METAL6_707000_1140600 0.024
R_VDD3_421 METAL5_631200_501500 METAL5_643200_501500 0.048
R_VDD3_422 METAL5_1000000_174800 METAL5_988000_174800 0.048
R_VDD3_423 METAL5_988000_174800 METAL5_980500_174800 0.03
R_VDD3_424 METAL5_980500_174800 METAL5_976000_174800 0.018
R_VDD3_425 METAL5_976000_174800 METAL6_976000_174800 0.1
R_VDD3_426 METAL6_976000_174800 METAL6_786300_174800 0.3794
R_VDD3_427 METAL6_786300_174800 METAL6_774300_174800 0.024
R_VDD3_428 METAL6_774300_174800 METAL6_762300_174800 0.024
R_VDD3_429 METAL6_762300_174800 METAL6_762300_186800 0.024
R_VDD3_430 METAL6_762300_186800 METAL6_755300_186800 0.014
R_VDD3_431 METAL6_755300_186800 METAL6_755300_193800 0.014
R_VDD3_432 METAL6_755300_193800 METAL6_750300_193800 0.01
R_VDD3_433 METAL6_750300_193800 METAL6_719000_193800 0.0626
R_VDD3_434 METAL6_719000_193800 METAL6_707000_193800 0.024
R_VDD3_435 METAL6_707000_193800 METAL6_700000_193800 0.014
R_VDD3_436 METAL6_700000_193800 METAL6_700000_198800 0.01
R_VDD3_437 METAL6_700000_198800 METAL6_700000_211300 0.025
R_VDD3_438 METAL6_700000_211300 METAL6_700000_223300 0.024
R_VDD3_439 METAL6_700000_223300 METAL6_700000_235300 0.024
R_VDD3_440 METAL6_700000_235300 METAL6_700000_242300 0.014
R_VDD3_441 METAL6_700000_242300 METAL6_700000_247300 0.01
R_VDD3_442 METAL6_700000_247300 METAL6_700000_388800 0.283
R_VDD3_443 METAL6_700000_388800 METAL5_700000_388800 0.1
R_VDD3_444 METAL5_700000_388800 METAL5_695000_388800 0.02
R_VDD3_445 METAL5_695000_388800 METAL5_688000_388800 0.028
R_VDD3_446 METAL5_688000_388800 METAL5_676000_388800 0.048
R_VDD3_447 METAL5_676000_388800 METAL6_676000_388800 0.1
R_VDD3_448 METAL6_676000_388800 METAL6_655200_388800 0.0416
R_VDD3_449 METAL6_655200_388800 METAL6_643200_388800 0.024
R_VDD3_450 METAL6_643200_388800 METAL6_643200_399700 0.0218
R_VDD3_451 METAL6_643200_399700 METAL6_643200_411700 0.024
R_VDD3_452 METAL6_643200_411700 METAL6_643200_423700 0.024
R_VDD3_453 METAL6_643200_423700 METAL6_643200_435700 0.024
R_VDD3_454 METAL6_643200_435700 METAL6_643200_437300 0.0032
R_VDD3_455 METAL6_643200_437300 METAL6_643200_447200 0.0198
R_VDD3_456 METAL6_643200_447200 METAL6_643200_447700 0.001
R_VDD3_457 METAL6_643200_447700 METAL6_643200_454700 0.014
R_VDD3_458 METAL6_643200_454700 METAL6_643200_459700 0.01
R_VDD3_459 METAL6_643200_459700 METAL6_643200_489500 0.0596
R_VDD3_460 METAL6_643200_489500 METAL6_643200_501500 0.024
R_VDD3_461 METAL6_643200_501500 METAL5_643200_501500 0.1
I_VDD3_3 METAL6_762300_1450000 gnd 0.004
I_VDD3_4 METAL6_695000_1140600 gnd 0.004
I_VDD3_5 METAL5_631200_501500 gnd 0.01

V_VDD4_4 METAL6_1200000_0 gnd 1.4
R_VDD4_462 METAL6_1200000_0 METAL6_1200000_8000 0.016
R_VDD4_463 METAL6_1200000_8000 METAL6_1212000_8000 0.024
R_VDD4_464 METAL6_1212000_8000 METAL6_1299000_8000 0.174
R_VDD4_465 METAL6_1299000_8000 METAL6_1311000_8000 0.024
R_VDD4_466 METAL6_1311000_8000 METAL6_1323000_8000 0.024
R_VDD4_467 METAL6_1323000_8000 METAL6_1476000_8000 0.306
R_VDD4_468 METAL6_1476000_8000 METAL6_1476000_20000 0.024
R_VDD4_469 METAL6_1476000_20000 METAL6_1476000_69500 0.099
R_VDD4_470 METAL6_1476000_69500 METAL6_1476000_138800 0.1386
R_VDD4_471 METAL6_1476000_138800 METAL6_1476000_150800 0.024
R_VDD4_472 METAL6_1476000_150800 METAL6_1487000_150800 0.022
R_VDD4_473 METAL6_1487000_150800 METAL6_1488000_150800 0.002
R_VDD4_474 METAL6_1488000_150800 METAL5_1488000_150800 0.1
R_VDD4_475 METAL5_1488000_150800 METAL5_1499000_150800 0.044
R_VDD4_476 METAL5_1499000_150800 METAL5_1500000_150800 0.004
R_VDD4_477 METAL5_1500000_150800 METAL5_1511000_150800 0.044
R_VDD4_478 METAL5_1511000_150800 METAL5_1512000_150800 0.004
R_VDD4_479 METAL5_1512000_150800 METAL5_1523000_150800 0.044
R_VDD4_480 METAL5_1523000_150800 METAL5_1524000_150800 0.004
R_VDD4_481 METAL5_1524000_150800 METAL6_1524000_150800 0.1
R_VDD4_482 METAL6_1524000_150800 METAL6_1535000_150800 0.022
R_VDD4_483 METAL6_1535000_150800 METAL6_1536000_150800 0.002
R_VDD4_484 METAL6_1536000_150800 METAL6_1538500_150800 0.005
R_VDD4_485 METAL6_1538500_150800 METAL6_1550500_150800 0.024
R_VDD4_486 METAL6_1550500_150800 METAL6_1562500_150800 0.024
R_VDD4_487 METAL6_1562500_150800 METAL6_1574500_150800 0.024
R_VDD4_488 METAL6_1574500_150800 METAL6_1575900_150800 0.0028
R_VDD4_489 METAL6_1575900_150800 METAL6_1586500_150800 0.0212
R_VDD4_490 METAL6_1586500_150800 METAL6_1586500_162800 0.024
R_VDD4_491 METAL6_1586500_162800 METAL6_1587900_162800 0.0028
R_VDD4_492 METAL6_1587900_162800 METAL6_1598500_162800 0.0212
R_VDD4_493 METAL6_1598500_162800 METAL6_1598500_174800 0.024
R_VDD4_494 METAL6_1598500_174800 METAL6_1598500_181800 0.014
R_VDD4_495 METAL6_1598500_181800 METAL6_1598500_186800 0.01
R_VDD4_496 METAL6_1598500_186800 METAL6_1598500_193800 0.014
R_VDD4_497 METAL6_1598500_193800 METAL6_1598500_198800 0.01
R_VDD4_498 METAL6_1598500_198800 METAL6_1598500_205800 0.014
R_VDD4_499 METAL6_1598500_205800 METAL6_1598500_211300 0.011
R_VDD4_500 METAL6_1598500_211300 METAL6_1598500_223300 0.024
R_VDD4_501 METAL6_1598500_223300 METAL6_1598500_235300 0.024
R_VDD4_502 METAL6_1598500_235300 METAL6_1598500_242300 0.014
R_VDD4_503 METAL6_1598500_242300 METAL6_1598500_247300 0.01
R_VDD4_504 METAL6_1598500_247300 METAL6_1598500_376800 0.259
R_VDD4_505 METAL6_1598500_376800 METAL6_1598500_388800 0.024
R_VDD4_506 METAL6_1598500_388800 METAL6_1598500_399700 0.0218
R_VDD4_507 METAL6_1598500_399700 METAL6_1599900_399700 0.0028
R_VDD4_508 METAL6_1599900_399700 METAL6_1602900_399700 0.006
R_VDD4_509 METAL6_1602900_399700 METAL6_1614900_399700 0.024
R_VDD4_510 METAL6_1614900_399700 METAL6_1619600_399700 0.0094
R_VDD4_511 METAL6_1619600_399700 METAL6_1626900_399700 0.0146
R_VDD4_512 METAL6_1626900_399700 METAL6_1631600_399700 0.0094
R_VDD4_513 METAL6_1631600_399700 METAL6_1643600_399700 0.024
R_VDD4_514 METAL6_1643600_399700 METAL6_1750500_399700 0.2138
R_VDD4_515 METAL6_1750500_399700 METAL6_1762500_399700 0.024
R_VDD4_516 METAL6_1762500_399700 METAL6_1774500_399700 0.024
R_VDD4_517 METAL6_1774500_399700 METAL6_1775900_399700 0.0028
R_VDD4_518 METAL6_1775900_399700 METAL6_1787900_399700 0.024
R_VDD4_519 METAL6_1787900_399700 METAL6_1799900_399700 0.024
R_VDD4_520 METAL6_1799900_399700 METAL6_1802900_399700 0.006
R_VDD4_521 METAL6_1802900_399700 METAL6_1814900_399700 0.024
R_VDD4_522 METAL6_1814900_399700 METAL6_1819600_399700 0.0094
R_VDD4_523 METAL6_1819600_399700 METAL6_1826900_399700 0.0146
R_VDD4_524 METAL6_1826900_399700 METAL6_1831600_399700 0.0094
R_VDD4_525 METAL6_1831600_399700 METAL6_1838900_399700 0.0146
R_VDD4_526 METAL6_1838900_399700 METAL6_1843600_399700 0.0094
R_VDD4_527 METAL6_1843600_399700 METAL6_1988000_399700 0.2888
R_VDD4_528 METAL6_1988000_399700 METAL6_1994500_399700 0.013
R_VDD4_529 METAL6_1994500_399700 METAL6_1995900_399700 0.0028
R_VDD4_530 METAL6_1995900_399700 METAL6_2000000_399700 0.0082
R_VDD4_531 METAL6_2000000_399700 METAL6_2007900_399700 0.0158
R_VDD4_532 METAL6_2007900_399700 METAL6_2012000_399700 0.0082
R_VDD4_533 METAL6_2012000_399700 METAL6_2019900_399700 0.0158
R_VDD4_534 METAL6_2019900_399700 METAL6_2031900_399700 0.024
R_VDD4_535 METAL6_2031900_399700 METAL6_2039600_399700 0.0154
R_VDD4_536 METAL6_2039600_399700 METAL6_2043900_399700 0.0086
R_VDD4_537 METAL6_2043900_399700 METAL6_2046900_399700 0.006
R_VDD4_538 METAL6_2046900_399700 METAL6_2051600_399700 0.0094
R_VDD4_539 METAL6_2051600_399700 METAL6_2063600_399700 0.024
R_VDD4_540 METAL6_2063600_399700 METAL6_2075600_399700 0.024
R_VDD4_541 METAL6_2075600_399700 METAL6_2081000_399700 0.0108
R_VDD4_542 METAL6_2081000_399700 METAL6_2087600_399700 0.0132
R_VDD4_543 METAL6_2087600_399700 METAL6_2093000_399700 0.0108
R_VDD4_544 METAL6_2093000_399700 METAL6_2099600_399700 0.0132
R_VDD4_545 METAL6_2099600_399700 METAL6_2105000_399700 0.0108
R_VDD4_546 METAL6_2105000_399700 METAL6_2117000_399700 0.024
R_VDD4_547 METAL6_2117000_399700 METAL6_2259000_399700 0.284
R_VDD4_548 METAL6_2259000_399700 METAL6_2271000_399700 0.024
R_VDD4_549 METAL6_2271000_399700 METAL6_2283000_399700 0.024
R_VDD4_550 METAL6_2283000_399700 METAL6_2295000_399700 0.024
R_VDD4_551 METAL6_2295000_399700 METAL6_2302000_399700 0.014
R_VDD4_552 METAL6_2302000_399700 METAL6_2313700_399700 0.0234
R_VDD4_553 METAL6_2313700_399700 METAL6_2350500_399700 0.0736
R_VDD4_554 METAL6_2350500_399700 METAL6_2408700_399700 0.1164
R_VDD4_555 METAL6_2408700_399700 METAL6_2420700_399700 0.024
R_VDD4_556 METAL6_2420700_399700 METAL6_2432700_399700 0.024
R_VDD4_557 METAL6_2432700_399700 METAL6_2445500_399700 0.0256
R_VDD4_558 METAL6_2445500_399700 METAL6_2457500_399700 0.024
R_VDD4_559 METAL6_2457500_399700 METAL6_2469500_399700 0.024
R_VDD4_560 METAL6_2469500_399700 METAL6_2527700_399700 0.1164
R_VDD4_561 METAL6_2527700_399700 METAL6_2564500_399700 0.0736
R_VDD4_562 METAL6_2564500_399700 METAL6_2577300_399700 0.0256
R_VDD4_563 METAL6_2577300_399700 METAL6_2672300_399700 0.19
R_VDD4_564 METAL6_2672300_399700 METAL6_2684300_399700 0.024
R_VDD4_565 METAL6_2684300_399700 METAL6_2696300_399700 0.024
R_VDD4_566 METAL6_2696300_399700 METAL6_2729800_399700 0.067
R_VDD4_567 METAL6_2729800_399700 METAL6_2791300_399700 0.123
R_VDD4_568 METAL6_2791300_399700 METAL6_2824800_399700 0.067
R_VDD4_569 METAL6_2824800_399700 METAL6_2836800_399700 0.024
R_VDD4_570 METAL6_2836800_399700 METAL6_2848800_399700 0.024
R_VDD4_571 METAL6_2848800_399700 METAL6_2899800_399700 0.102
R_VDD4_572 METAL6_2899800_399700 METAL6_2943800_399700 0.088
R_VDD4_573 METAL6_2943800_399700 METAL6_2994800_399700 0.102
R_VDD4_574 METAL6_2994800_399700 METAL6_3006800_399700 0.024
R_VDD4_575 METAL6_3006800_399700 METAL6_3018800_399700 0.024
R_VDD4_576 METAL6_3018800_399700 METAL6_3044300_399700 0.051
R_VDD4_577 METAL6_3044300_399700 METAL6_3113800_399700 0.139
R_VDD4_578 METAL6_3113800_399700 METAL6_3139300_399700 0.051
R_VDD4_579 METAL6_3139300_399700 METAL6_3151300_399700 0.024
R_VDD4_580 METAL6_3151300_399700 METAL6_3151300_400800 0.0022
R_VDD4_581 METAL6_3151300_400800 METAL6_3151300_411700 0.0218
R_VDD4_582 METAL6_3151300_411700 METAL6_3151300_423700 0.024
R_VDD4_583 METAL6_3151300_423700 METAL6_3151300_435700 0.024
R_VDD4_584 METAL6_3151300_435700 METAL6_3151300_437300 0.0032
R_VDD4_585 METAL6_3151300_437300 METAL6_3151300_447200 0.0198
R_VDD4_586 METAL6_3151300_447200 METAL6_3151300_447700 0.001
R_VDD4_587 METAL6_3151300_447700 METAL6_3151300_454700 0.014
R_VDD4_588 METAL6_3151300_454700 METAL6_3151300_459700 0.01
R_VDD4_589 METAL6_3151300_459700 METAL6_3151300_489500 0.0596
R_VDD4_590 METAL6_3151300_489500 METAL6_3151300_501500 0.024
R_VDD4_591 METAL6_3151300_501500 METAL6_3151300_510000 0.017
R_VDD4_592 METAL6_3151300_510000 METAL6_3151300_513500 0.007
R_VDD4_593 METAL6_3151300_513500 METAL6_3151300_522000 0.017
R_VDD4_594 METAL6_3151300_522000 METAL5_3151300_522000 0.1
R_VDD4_595 METAL5_3151300_522000 METAL4_3151300_522000 0.1
R_VDD4_596 METAL4_3151300_534000 METAL4_3151300_522000 0.096
R_VDD4_597 METAL4_3006800_235300 METAL4_3006800_223300 0.096
R_VDD4_598 METAL6_3018800_399700 METAL6_3018800_388800 0.0218
R_VDD4_599 METAL6_3018800_388800 METAL6_3018800_387700 0.0022
R_VDD4_600 METAL6_3018800_387700 METAL6_3018800_376800 0.0218
R_VDD4_601 METAL6_3018800_376800 METAL6_3018800_247300 0.259
R_VDD4_602 METAL6_3018800_247300 METAL6_3018800_242300 0.01
R_VDD4_603 METAL6_3018800_242300 METAL6_3018800_235300 0.014
R_VDD4_604 METAL6_3018800_235300 METAL6_3018800_223300 0.024
R_VDD4_605 METAL6_3018800_223300 METAL6_3006800_223300 0.024
R_VDD4_606 METAL6_3006800_223300 METAL5_3006800_223300 0.1
R_VDD4_607 METAL5_3006800_223300 METAL4_3006800_223300 0.1
R_VDD4_608 METAL4_2457500_1055700 METAL4_2457500_1067700 0.096
R_VDD4_609 METAL6_2408700_399700 METAL6_2408700_400800 0.0022
R_VDD4_610 METAL6_2408700_400800 METAL6_2408700_411700 0.0218
R_VDD4_611 METAL6_2408700_411700 METAL6_2420700_411700 0.024
R_VDD4_612 METAL6_2420700_411700 METAL6_2432700_411700 0.024
R_VDD4_613 METAL6_2432700_411700 METAL6_2445500_411700 0.0256
R_VDD4_614 METAL6_2445500_411700 METAL6_2445500_423700 0.024
R_VDD4_615 METAL6_2445500_423700 METAL6_2445500_435700 0.024
R_VDD4_616 METAL6_2445500_435700 METAL6_2445500_437300 0.0032
R_VDD4_617 METAL6_2445500_437300 METAL6_2445500_447200 0.0198
R_VDD4_618 METAL6_2445500_447200 METAL6_2445500_447700 0.001
R_VDD4_619 METAL6_2445500_447700 METAL6_2445500_454700 0.014
R_VDD4_620 METAL6_2445500_454700 METAL6_2445500_459700 0.01
R_VDD4_621 METAL6_2445500_459700 METAL6_2445500_489500 0.0596
R_VDD4_622 METAL6_2445500_489500 METAL6_2445500_501500 0.024
R_VDD4_623 METAL6_2445500_501500 METAL6_2445500_510000 0.017
R_VDD4_624 METAL6_2445500_510000 METAL6_2445500_513500 0.007
R_VDD4_625 METAL6_2445500_513500 METAL6_2445500_522000 0.017
R_VDD4_626 METAL6_2445500_522000 METAL6_2445500_534000 0.024
R_VDD4_627 METAL6_2445500_534000 METAL6_2445500_541000 0.014
R_VDD4_628 METAL6_2445500_541000 METAL6_2445500_583500 0.085
R_VDD4_629 METAL6_2445500_583500 METAL6_2445500_637700 0.1084
R_VDD4_630 METAL6_2445500_637700 METAL6_2445500_642200 0.009
R_VDD4_631 METAL6_2445500_642200 METAL6_2445500_649200 0.014
R_VDD4_632 METAL6_2445500_649200 METAL6_2445500_649700 0.001
R_VDD4_633 METAL6_2445500_649700 METAL6_2445500_658600 0.0178
R_VDD4_634 METAL6_2445500_658600 METAL6_2445500_661200 0.0052
R_VDD4_635 METAL6_2445500_661200 METAL6_2445500_661700 0.001
R_VDD4_636 METAL6_2445500_661700 METAL6_2445500_673200 0.023
R_VDD4_637 METAL6_2445500_673200 METAL6_2445500_673700 0.001
R_VDD4_638 METAL6_2445500_673700 METAL6_2445500_736000 0.1246
R_VDD4_639 METAL6_2445500_736000 METAL6_2445500_805300 0.1386
R_VDD4_640 METAL6_2445500_805300 METAL6_2445500_805400 0.0002
R_VDD4_641 METAL6_2445500_805400 METAL6_2445500_817300 0.0238
R_VDD4_642 METAL6_2445500_817300 METAL6_2445500_817400 0.0002
R_VDD4_643 METAL6_2445500_817400 METAL6_2445500_829300 0.0238
R_VDD4_644 METAL6_2445500_829300 METAL6_2445500_829400 0.0002
R_VDD4_645 METAL6_2445500_829400 METAL6_2445500_841300 0.0238
R_VDD4_646 METAL6_2445500_841300 METAL6_2445500_841400 0.0002
R_VDD4_647 METAL6_2445500_841400 METAL6_2445500_853300 0.0238
R_VDD4_648 METAL6_2445500_853300 METAL6_2445500_853400 0.0002
R_VDD4_649 METAL6_2445500_853400 METAL6_2445500_853700 0.0006
R_VDD4_650 METAL6_2445500_853700 METAL6_2445500_860400 0.0134
R_VDD4_651 METAL6_2445500_860400 METAL6_2445500_865300 0.0098
R_VDD4_652 METAL6_2445500_865300 METAL6_2445500_1036300 0.342
R_VDD4_653 METAL6_2445500_1036300 METAL6_2445500_1041400 0.0102
R_VDD4_654 METAL6_2445500_1041400 METAL6_2445500_1043300 0.0038
R_VDD4_655 METAL6_2445500_1043300 METAL6_2445500_1048700 0.0108
R_VDD4_656 METAL6_2445500_1048700 METAL6_2445500_1055300 0.0132
R_VDD4_657 METAL6_2445500_1055300 METAL6_2445500_1055400 0.0002
R_VDD4_658 METAL6_2445500_1055400 METAL6_2445500_1055700 0.0006
R_VDD4_659 METAL6_2445500_1055700 METAL6_2445500_1067300 0.0232
R_VDD4_660 METAL6_2445500_1067300 METAL6_2445500_1067700 0.0008
R_VDD4_661 METAL6_2445500_1067700 METAL6_2457500_1067700 0.024
R_VDD4_662 METAL6_2457500_1067700 METAL5_2457500_1067700 0.1
R_VDD4_663 METAL5_2457500_1067700 METAL4_2457500_1067700 0.1
R_VDD4_664 METAL4_2420700_649200 METAL4_2420700_649700 0.004
R_VDD4_665 METAL4_2420700_649700 METAL4_2420700_658600 0.0712
R_VDD4_666 METAL4_2420700_658600 METAL4_2420700_661200 0.0208
R_VDD4_667 METAL6_2445500_649700 METAL6_2433500_649700 0.024
R_VDD4_668 METAL6_2433500_649700 METAL6_2433500_658600 0.0178
R_VDD4_669 METAL6_2433500_658600 METAL6_2433500_661200 0.0052
R_VDD4_670 METAL6_2433500_661200 METAL6_2432700_661200 0.0016
R_VDD4_671 METAL6_2432700_661200 METAL6_2420700_661200 0.024
R_VDD4_672 METAL6_2420700_661200 METAL5_2420700_661200 0.1
R_VDD4_673 METAL5_2420700_661200 METAL4_2420700_661200 0.1
R_VDD4_674 METAL4_2836800_1043300 METAL4_2836800_1055300 0.096
R_VDD4_675 METAL6_1598500_223300 METAL6_1599900_223300 0.0028
R_VDD4_676 METAL6_1599900_223300 METAL6_1602900_223300 0.006
R_VDD4_677 METAL6_1602900_223300 METAL6_1610500_223300 0.0152
R_VDD4_678 METAL6_1610500_223300 METAL6_1610500_235300 0.024
R_VDD4_679 METAL6_1610500_235300 METAL6_1610500_242300 0.014
R_VDD4_680 METAL6_1610500_242300 METAL6_1610500_247300 0.01
R_VDD4_681 METAL6_1610500_247300 METAL6_1610500_376800 0.259
R_VDD4_682 METAL6_1610500_376800 METAL6_1610500_387700 0.0218
R_VDD4_683 METAL6_1610500_387700 METAL6_1614900_387700 0.0088
R_VDD4_684 METAL6_1614900_387700 METAL6_1619600_387700 0.0094
R_VDD4_685 METAL6_1619600_387700 METAL6_1626900_387700 0.0146
R_VDD4_686 METAL6_1626900_387700 METAL6_1631600_387700 0.0094
R_VDD4_687 METAL6_1631600_387700 METAL6_1643600_387700 0.024
R_VDD4_688 METAL6_1643600_387700 METAL6_1750500_387700 0.2138
R_VDD4_689 METAL6_1750500_387700 METAL6_1762500_387700 0.024
R_VDD4_690 METAL6_1762500_387700 METAL6_1774500_387700 0.024
R_VDD4_691 METAL6_1774500_387700 METAL6_1775900_387700 0.0028
R_VDD4_692 METAL6_1775900_387700 METAL6_1787900_387700 0.024
R_VDD4_693 METAL6_1787900_387700 METAL6_1799900_387700 0.024
R_VDD4_694 METAL6_1799900_387700 METAL6_1802900_387700 0.006
R_VDD4_695 METAL6_1802900_387700 METAL6_1814900_387700 0.024
R_VDD4_696 METAL6_1814900_387700 METAL6_1819600_387700 0.0094
R_VDD4_697 METAL6_1819600_387700 METAL6_1826900_387700 0.0146
R_VDD4_698 METAL6_1826900_387700 METAL6_1831600_387700 0.0094
R_VDD4_699 METAL6_1831600_387700 METAL6_1838900_387700 0.0146
R_VDD4_700 METAL6_1838900_387700 METAL6_1843600_387700 0.0094
R_VDD4_701 METAL6_1843600_387700 METAL6_1988000_387700 0.2888
R_VDD4_702 METAL6_1988000_387700 METAL6_1994500_387700 0.013
R_VDD4_703 METAL6_1994500_387700 METAL6_1995900_387700 0.0028
R_VDD4_704 METAL6_1995900_387700 METAL6_2000000_387700 0.0082
R_VDD4_705 METAL6_2000000_387700 METAL6_2007900_387700 0.0158
R_VDD4_706 METAL6_2007900_387700 METAL6_2012000_387700 0.0082
R_VDD4_707 METAL6_2012000_387700 METAL6_2019900_387700 0.0158
R_VDD4_708 METAL6_2019900_387700 METAL6_2031900_387700 0.024
R_VDD4_709 METAL6_2031900_387700 METAL6_2039600_387700 0.0154
R_VDD4_710 METAL6_2039600_387700 METAL6_2043900_387700 0.0086
R_VDD4_711 METAL6_2043900_387700 METAL6_2046900_387700 0.006
R_VDD4_712 METAL6_2046900_387700 METAL6_2051600_387700 0.0094
R_VDD4_713 METAL6_2051600_387700 METAL6_2063600_387700 0.024
R_VDD4_714 METAL6_2063600_387700 METAL6_2075600_387700 0.024
R_VDD4_715 METAL6_2075600_387700 METAL6_2081000_387700 0.0108
R_VDD4_716 METAL6_2081000_387700 METAL6_2087600_387700 0.0132
R_VDD4_717 METAL6_2087600_387700 METAL6_2093000_387700 0.0108
R_VDD4_718 METAL6_2093000_387700 METAL6_2099600_387700 0.0132
R_VDD4_719 METAL6_2099600_387700 METAL6_2105000_387700 0.0108
R_VDD4_720 METAL6_2105000_387700 METAL6_2117000_387700 0.024
R_VDD4_721 METAL6_2117000_387700 METAL6_2259000_387700 0.284
R_VDD4_722 METAL6_2259000_387700 METAL6_2271000_387700 0.024
R_VDD4_723 METAL6_2271000_387700 METAL6_2283000_387700 0.024
R_VDD4_724 METAL6_2283000_387700 METAL6_2295000_387700 0.024
R_VDD4_725 METAL6_2295000_387700 METAL6_2302000_387700 0.014
R_VDD4_726 METAL6_2302000_387700 METAL6_2313700_387700 0.0234
R_VDD4_727 METAL6_2313700_387700 METAL6_2350500_387700 0.0736
R_VDD4_728 METAL6_2350500_387700 METAL6_2396700_387700 0.0924
R_VDD4_729 METAL6_2396700_387700 METAL6_2408700_387700 0.024
R_VDD4_730 METAL6_2408700_387700 METAL6_2420700_387700 0.024
R_VDD4_731 METAL6_2420700_387700 METAL6_2421500_387700 0.0016
R_VDD4_732 METAL6_2421500_387700 METAL6_2432700_387700 0.0224
R_VDD4_733 METAL6_2432700_387700 METAL6_2433500_387700 0.0016
R_VDD4_734 METAL6_2433500_387700 METAL6_2445500_387700 0.024
R_VDD4_735 METAL6_2445500_387700 METAL6_2457500_387700 0.024
R_VDD4_736 METAL6_2457500_387700 METAL5_2457500_387700 0.1
R_VDD4_737 METAL5_2457500_387700 METAL5_2457500_388800 0.0044
R_VDD4_738 METAL5_2457500_388800 METAL5_2457500_399700 0.0436
R_VDD4_739 METAL5_2457500_399700 METAL5_2457500_400800 0.0044
R_VDD4_740 METAL5_2457500_400800 METAL5_2457500_411700 0.0436
R_VDD4_741 METAL5_2457500_411700 METAL6_2457500_411700 0.1
R_VDD4_742 METAL6_2457500_411700 METAL6_2469500_411700 0.024
R_VDD4_743 METAL6_2469500_411700 METAL6_2527700_411700 0.1164
R_VDD4_744 METAL6_2527700_411700 METAL6_2564500_411700 0.0736
R_VDD4_745 METAL6_2564500_411700 METAL6_2577300_411700 0.0256
R_VDD4_746 METAL6_2577300_411700 METAL6_2672300_411700 0.19
R_VDD4_747 METAL6_2672300_411700 METAL6_2684300_411700 0.024
R_VDD4_748 METAL6_2684300_411700 METAL6_2696300_411700 0.024
R_VDD4_749 METAL6_2696300_411700 METAL6_2729800_411700 0.067
R_VDD4_750 METAL6_2729800_411700 METAL6_2791300_411700 0.123
R_VDD4_751 METAL6_2791300_411700 METAL6_2824800_411700 0.067
R_VDD4_752 METAL6_2824800_411700 METAL6_2824800_423700 0.024
R_VDD4_753 METAL6_2824800_423700 METAL6_2824800_435700 0.024
R_VDD4_754 METAL6_2824800_435700 METAL6_2824800_437300 0.0032
R_VDD4_755 METAL6_2824800_437300 METAL6_2824800_447200 0.0198
R_VDD4_756 METAL6_2824800_447200 METAL6_2824800_447700 0.001
R_VDD4_757 METAL6_2824800_447700 METAL6_2824800_454700 0.014
R_VDD4_758 METAL6_2824800_454700 METAL6_2824800_459700 0.01
R_VDD4_759 METAL6_2824800_459700 METAL6_2824800_489500 0.0596
R_VDD4_760 METAL6_2824800_489500 METAL6_2824800_501500 0.024
R_VDD4_761 METAL6_2824800_501500 METAL6_2824800_510000 0.017
R_VDD4_762 METAL6_2824800_510000 METAL6_2824800_513500 0.007
R_VDD4_763 METAL6_2824800_513500 METAL6_2824800_522000 0.017
R_VDD4_764 METAL6_2824800_522000 METAL6_2824800_534000 0.024
R_VDD4_765 METAL6_2824800_534000 METAL6_2824800_541000 0.014
R_VDD4_766 METAL6_2824800_541000 METAL6_2824800_583500 0.085
R_VDD4_767 METAL6_2824800_583500 METAL6_2824800_637700 0.1084
R_VDD4_768 METAL6_2824800_637700 METAL6_2824800_642200 0.009
R_VDD4_769 METAL6_2824800_642200 METAL6_2824800_649200 0.014
R_VDD4_770 METAL6_2824800_649200 METAL6_2824800_649700 0.001
R_VDD4_771 METAL6_2824800_649700 METAL6_2824800_658600 0.0178
R_VDD4_772 METAL6_2824800_658600 METAL6_2824800_661200 0.0052
R_VDD4_773 METAL6_2824800_661200 METAL6_2824800_661700 0.001
R_VDD4_774 METAL6_2824800_661700 METAL6_2824800_673200 0.023
R_VDD4_775 METAL6_2824800_673200 METAL6_2824800_673700 0.001
R_VDD4_776 METAL6_2824800_673700 METAL6_2824800_736000 0.1246
R_VDD4_777 METAL6_2824800_736000 METAL6_2824800_805300 0.1386
R_VDD4_778 METAL6_2824800_805300 METAL6_2824800_805400 0.0002
R_VDD4_779 METAL6_2824800_805400 METAL6_2824800_817300 0.0238
R_VDD4_780 METAL6_2824800_817300 METAL6_2824800_817400 0.0002
R_VDD4_781 METAL6_2824800_817400 METAL6_2824800_829300 0.0238
R_VDD4_782 METAL6_2824800_829300 METAL6_2824800_829400 0.0002
R_VDD4_783 METAL6_2824800_829400 METAL6_2824800_841300 0.0238
R_VDD4_784 METAL6_2824800_841300 METAL6_2824800_841400 0.0002
R_VDD4_785 METAL6_2824800_841400 METAL6_2824800_853300 0.0238
R_VDD4_786 METAL6_2824800_853300 METAL6_2824800_853400 0.0002
R_VDD4_787 METAL6_2824800_853400 METAL6_2824800_853700 0.0006
R_VDD4_788 METAL6_2824800_853700 METAL6_2824800_860400 0.0134
R_VDD4_789 METAL6_2824800_860400 METAL6_2824800_865300 0.0098
R_VDD4_790 METAL6_2824800_865300 METAL6_2824800_1036300 0.342
R_VDD4_791 METAL6_2824800_1036300 METAL6_2824800_1041400 0.0102
R_VDD4_792 METAL6_2824800_1041400 METAL6_2824800_1043300 0.0038
R_VDD4_793 METAL6_2824800_1043300 METAL6_2824800_1048700 0.0108
R_VDD4_794 METAL6_2824800_1048700 METAL6_2824800_1055300 0.0132
R_VDD4_795 METAL6_2824800_1055300 METAL6_2836800_1055300 0.024
R_VDD4_796 METAL6_2836800_1055300 METAL5_2836800_1055300 0.1
R_VDD4_797 METAL5_2836800_1055300 METAL4_2836800_1055300 0.1
R_VDD4_798 METAL4_2684300_186800 METAL4_2684300_174800 0.096
R_VDD4_799 METAL6_1200000_8000 METAL6_1200000_20000 0.024
R_VDD4_800 METAL6_1200000_20000 METAL6_1200000_69500 0.099
R_VDD4_801 METAL6_1200000_69500 METAL6_1200000_138800 0.1386
R_VDD4_802 METAL6_1200000_138800 METAL6_1212000_138800 0.024
R_VDD4_803 METAL6_1212000_138800 METAL6_1299000_138800 0.174
R_VDD4_804 METAL6_1299000_138800 METAL6_1311000_138800 0.024
R_VDD4_805 METAL6_1311000_138800 METAL6_1323000_138800 0.024
R_VDD4_806 METAL6_1323000_138800 METAL6_1464000_138800 0.282
R_VDD4_807 METAL6_1464000_138800 METAL5_1464000_138800 0.1
R_VDD4_808 METAL5_1464000_138800 METAL5_1476000_138800 0.048
R_VDD4_809 METAL5_1476000_138800 METAL5_1487000_138800 0.044
R_VDD4_810 METAL5_1487000_138800 METAL5_1488000_138800 0.004
R_VDD4_811 METAL5_1488000_138800 METAL5_1499000_138800 0.044
R_VDD4_812 METAL5_1499000_138800 METAL5_1500000_138800 0.004
R_VDD4_813 METAL5_1500000_138800 METAL5_1511000_138800 0.044
R_VDD4_814 METAL5_1511000_138800 METAL5_1512000_138800 0.004
R_VDD4_815 METAL5_1512000_138800 METAL5_1523000_138800 0.044
R_VDD4_816 METAL5_1523000_138800 METAL5_1524000_138800 0.004
R_VDD4_817 METAL5_1524000_138800 METAL6_1524000_138800 0.1
R_VDD4_818 METAL6_1524000_138800 METAL6_1535000_138800 0.022
R_VDD4_819 METAL6_1535000_138800 METAL6_1536000_138800 0.002
R_VDD4_820 METAL6_1536000_138800 METAL6_1538500_138800 0.005
R_VDD4_821 METAL6_1538500_138800 METAL6_1550500_138800 0.024
R_VDD4_822 METAL6_1550500_138800 METAL6_1562500_138800 0.024
R_VDD4_823 METAL6_1562500_138800 METAL6_1574500_138800 0.024
R_VDD4_824 METAL6_1574500_138800 METAL6_1575900_138800 0.0028
R_VDD4_825 METAL6_1575900_138800 METAL6_1586500_138800 0.0212
R_VDD4_826 METAL6_1586500_138800 METAL6_1587900_138800 0.0028
R_VDD4_827 METAL6_1587900_138800 METAL6_1598500_138800 0.0212
R_VDD4_828 METAL6_1598500_138800 METAL6_1598500_150800 0.024
R_VDD4_829 METAL6_1598500_150800 METAL6_1599900_150800 0.0028
R_VDD4_830 METAL6_1599900_150800 METAL6_1602900_150800 0.006
R_VDD4_831 METAL6_1602900_150800 METAL6_1610500_150800 0.0152
R_VDD4_832 METAL6_1610500_150800 METAL6_1610500_162800 0.024
R_VDD4_833 METAL6_1610500_162800 METAL6_1610500_174800 0.024
R_VDD4_834 METAL6_1610500_174800 METAL6_1614900_174800 0.0088
R_VDD4_835 METAL6_1614900_174800 METAL6_1619600_174800 0.0094
R_VDD4_836 METAL6_1619600_174800 METAL6_1622500_174800 0.0058
R_VDD4_837 METAL6_1622500_174800 METAL6_1626900_174800 0.0088
R_VDD4_838 METAL6_1626900_174800 METAL6_1631600_174800 0.0094
R_VDD4_839 METAL6_1631600_174800 METAL6_1643600_174800 0.024
R_VDD4_840 METAL6_1643600_174800 METAL6_1750500_174800 0.2138
R_VDD4_841 METAL6_1750500_174800 METAL6_1762500_174800 0.024
R_VDD4_842 METAL6_1762500_174800 METAL6_1774500_174800 0.024
R_VDD4_843 METAL6_1774500_174800 METAL6_1775900_174800 0.0028
R_VDD4_844 METAL6_1775900_174800 METAL6_1787900_174800 0.024
R_VDD4_845 METAL6_1787900_174800 METAL6_1799900_174800 0.024
R_VDD4_846 METAL6_1799900_174800 METAL6_1802900_174800 0.006
R_VDD4_847 METAL6_1802900_174800 METAL6_1814900_174800 0.024
R_VDD4_848 METAL6_1814900_174800 METAL6_1819600_174800 0.0094
R_VDD4_849 METAL6_1819600_174800 METAL6_1826900_174800 0.0146
R_VDD4_850 METAL6_1826900_174800 METAL6_1831600_174800 0.0094
R_VDD4_851 METAL6_1831600_174800 METAL6_1838900_174800 0.0146
R_VDD4_852 METAL6_1838900_174800 METAL6_1843600_174800 0.0094
R_VDD4_853 METAL6_1843600_174800 METAL6_1988000_174800 0.2888
R_VDD4_854 METAL6_1988000_174800 METAL6_1994500_174800 0.013
R_VDD4_855 METAL6_1994500_174800 METAL6_1995900_174800 0.0028
R_VDD4_856 METAL6_1995900_174800 METAL6_2000000_174800 0.0082
R_VDD4_857 METAL6_2000000_174800 METAL6_2007900_174800 0.0158
R_VDD4_858 METAL6_2007900_174800 METAL6_2012000_174800 0.0082
R_VDD4_859 METAL6_2012000_174800 METAL6_2019900_174800 0.0158
R_VDD4_860 METAL6_2019900_174800 METAL6_2031900_174800 0.024
R_VDD4_861 METAL6_2031900_174800 METAL6_2039600_174800 0.0154
R_VDD4_862 METAL6_2039600_174800 METAL6_2043900_174800 0.0086
R_VDD4_863 METAL6_2043900_174800 METAL6_2046900_174800 0.006
R_VDD4_864 METAL6_2046900_174800 METAL6_2051600_174800 0.0094
R_VDD4_865 METAL6_2051600_174800 METAL6_2063600_174800 0.024
R_VDD4_866 METAL6_2063600_174800 METAL6_2075600_174800 0.024
R_VDD4_867 METAL6_2075600_174800 METAL6_2081000_174800 0.0108
R_VDD4_868 METAL6_2081000_174800 METAL6_2087600_174800 0.0132
R_VDD4_869 METAL6_2087600_174800 METAL6_2093000_174800 0.0108
R_VDD4_870 METAL6_2093000_174800 METAL6_2099600_174800 0.0132
R_VDD4_871 METAL6_2099600_174800 METAL6_2105000_174800 0.0108
R_VDD4_872 METAL6_2105000_174800 METAL6_2117000_174800 0.024
R_VDD4_873 METAL6_2117000_174800 METAL6_2259000_174800 0.284
R_VDD4_874 METAL6_2259000_174800 METAL6_2271000_174800 0.024
R_VDD4_875 METAL6_2271000_174800 METAL6_2283000_174800 0.024
R_VDD4_876 METAL6_2283000_174800 METAL6_2295000_174800 0.024
R_VDD4_877 METAL6_2295000_174800 METAL6_2302000_174800 0.014
R_VDD4_878 METAL6_2302000_174800 METAL6_2313700_174800 0.0234
R_VDD4_879 METAL6_2313700_174800 METAL6_2350500_174800 0.0736
R_VDD4_880 METAL6_2350500_174800 METAL6_2396700_174800 0.0924
R_VDD4_881 METAL6_2396700_174800 METAL6_2408700_174800 0.024
R_VDD4_882 METAL6_2408700_174800 METAL6_2420700_174800 0.024
R_VDD4_883 METAL6_2420700_174800 METAL6_2421500_174800 0.0016
R_VDD4_884 METAL6_2421500_174800 METAL6_2432700_174800 0.0224
R_VDD4_885 METAL6_2432700_174800 METAL6_2433500_174800 0.0016
R_VDD4_886 METAL6_2433500_174800 METAL6_2445500_174800 0.024
R_VDD4_887 METAL6_2445500_174800 METAL6_2457500_174800 0.024
R_VDD4_888 METAL6_2457500_174800 METAL6_2469500_174800 0.024
R_VDD4_889 METAL6_2469500_174800 METAL6_2527700_174800 0.1164
R_VDD4_890 METAL6_2527700_174800 METAL6_2564500_174800 0.0736
R_VDD4_891 METAL6_2564500_174800 METAL6_2577300_174800 0.0256
R_VDD4_892 METAL6_2577300_174800 METAL6_2672300_174800 0.19
R_VDD4_893 METAL6_2672300_174800 METAL6_2684300_174800 0.024
R_VDD4_894 METAL6_2684300_174800 METAL5_2684300_174800 0.1
R_VDD4_895 METAL5_2684300_174800 METAL4_2684300_174800 0.1
I_VDD4_6 METAL4_3151300_534000 gnd 0.003
I_VDD4_7 METAL4_3006800_235300 gnd 0.003
I_VDD4_8 METAL4_2457500_1055700 gnd 0.004
I_VDD4_9 METAL4_2420700_649200 gnd 0.004
I_VDD4_10 METAL4_2836800_1043300 gnd 0.005
I_VDD4_11 METAL4_2684300_186800 gnd 0.005

V_VDD5_5 METAL6_1500000_0 gnd 1
R_VDD5_896 METAL6_1500000_0 METAL6_1500000_8000 0.016
R_VDD5_897 METAL6_1500000_8000 METAL6_1500000_20000 0.024
R_VDD5_898 METAL6_1500000_20000 METAL6_1500000_69500 0.099
R_VDD5_899 METAL6_1500000_69500 METAL6_1500000_150800 0.1626
R_VDD5_900 METAL6_1500000_150800 METAL6_1500000_162800 0.024
R_VDD5_901 METAL6_1500000_162800 METAL6_1500000_174800 0.024
R_VDD5_902 METAL6_1500000_174800 METAL6_1500000_186800 0.024
R_VDD5_903 METAL6_1500000_186800 METAL6_1511000_186800 0.022
R_VDD5_904 METAL6_1511000_186800 METAL6_1511000_193800 0.014
R_VDD5_905 METAL6_1511000_193800 METAL6_1511000_211300 0.035
R_VDD5_906 METAL6_1511000_211300 METAL6_1511000_223300 0.024
R_VDD5_907 METAL6_1511000_223300 METAL6_1511000_235300 0.024
R_VDD5_908 METAL6_1511000_235300 METAL6_1511000_242300 0.014
R_VDD5_909 METAL6_1511000_242300 METAL6_1511000_247300 0.01
R_VDD5_910 METAL6_1511000_247300 METAL6_1511000_388800 0.283
R_VDD5_911 METAL6_1511000_388800 METAL6_1511000_423700 0.0698
R_VDD5_912 METAL6_1511000_423700 METAL6_1512000_423700 0.002
R_VDD5_913 METAL6_1512000_423700 METAL6_1523000_423700 0.022
R_VDD5_914 METAL6_1523000_423700 METAL6_1550500_423700 0.055
R_VDD5_915 METAL6_1550500_423700 METAL6_1550500_435700 0.024
R_VDD5_916 METAL6_1550500_435700 METAL6_1562500_435700 0.024
R_VDD5_917 METAL6_1562500_435700 METAL6_1574500_435700 0.024
R_VDD5_918 METAL6_1574500_435700 METAL6_1575900_435700 0.0028
R_VDD5_919 METAL6_1575900_435700 METAL6_1587900_435700 0.024
R_VDD5_920 METAL6_1587900_435700 METAL6_1599900_435700 0.024
R_VDD5_921 METAL6_1599900_435700 METAL6_1602900_435700 0.006
R_VDD5_922 METAL6_1602900_435700 METAL6_1614900_435700 0.024
R_VDD5_923 METAL6_1614900_435700 METAL6_1619600_435700 0.0094
R_VDD5_924 METAL6_1619600_435700 METAL6_1626900_435700 0.0146
R_VDD5_925 METAL6_1626900_435700 METAL6_1631600_435700 0.0094
R_VDD5_926 METAL6_1631600_435700 METAL6_1643600_435700 0.024
R_VDD5_927 METAL6_1643600_435700 METAL6_1750500_435700 0.2138
R_VDD5_928 METAL6_1750500_435700 METAL6_1762500_435700 0.024
R_VDD5_929 METAL6_1762500_435700 METAL6_1774500_435700 0.024
R_VDD5_930 METAL6_1774500_435700 METAL6_1775900_435700 0.0028
R_VDD5_931 METAL6_1775900_435700 METAL6_1787900_435700 0.024
R_VDD5_932 METAL6_1787900_435700 METAL6_1799900_435700 0.024
R_VDD5_933 METAL6_1799900_435700 METAL6_1802900_435700 0.006
R_VDD5_934 METAL6_1802900_435700 METAL6_1814900_435700 0.024
R_VDD5_935 METAL6_1814900_435700 METAL6_1819600_435700 0.0094
R_VDD5_936 METAL6_1819600_435700 METAL6_1826900_435700 0.0146
R_VDD5_937 METAL6_1826900_435700 METAL6_1831600_435700 0.0094
R_VDD5_938 METAL6_1831600_435700 METAL6_1838900_435700 0.0146
R_VDD5_939 METAL6_1838900_435700 METAL6_1843600_435700 0.0094
R_VDD5_940 METAL6_1843600_435700 METAL6_1988000_435700 0.2888
R_VDD5_941 METAL6_1988000_435700 METAL6_1994500_435700 0.013
R_VDD5_942 METAL6_1994500_435700 METAL6_2000000_435700 0.011
R_VDD5_943 METAL6_2000000_435700 METAL6_2012000_435700 0.024
R_VDD5_944 METAL6_2012000_435700 METAL6_2019900_435700 0.0158
R_VDD5_945 METAL6_2019900_435700 METAL6_2046900_435700 0.054
R_VDD5_946 METAL6_2046900_435700 METAL6_2063600_435700 0.0334
R_VDD5_947 METAL6_2063600_435700 METAL6_2093000_435700 0.0588
R_VDD5_948 METAL6_2093000_435700 METAL6_2093000_437300 0.0032
R_VDD5_949 METAL6_2093000_437300 METAL6_2093000_447200 0.0198
R_VDD5_950 METAL6_2093000_447200 METAL6_2093000_447700 0.001
R_VDD5_951 METAL6_2093000_447700 METAL6_2093000_454700 0.014
R_VDD5_952 METAL6_2093000_454700 METAL6_2093000_489500 0.0696
R_VDD5_953 METAL6_2093000_489500 METAL6_2093000_501500 0.024
R_VDD5_954 METAL6_2093000_501500 METAL6_2093000_510000 0.017
R_VDD5_955 METAL6_2093000_510000 METAL6_2093000_513500 0.007
R_VDD5_956 METAL6_2093000_513500 METAL6_2093000_522000 0.017
R_VDD5_957 METAL6_2093000_522000 METAL6_2093000_534000 0.024
R_VDD5_958 METAL6_2093000_534000 METAL6_2093000_541000 0.014
R_VDD5_959 METAL6_2093000_541000 METAL6_2093000_583500 0.085
R_VDD5_960 METAL6_2093000_583500 METAL6_2093000_637700 0.1084
R_VDD5_961 METAL6_2093000_637700 METAL6_2093000_642200 0.009
R_VDD5_962 METAL6_2093000_642200 METAL6_2093000_649200 0.014
R_VDD5_963 METAL6_2093000_649200 METAL6_2093000_649700 0.001
R_VDD5_964 METAL6_2093000_649700 METAL6_2063600_649700 0.0588
R_VDD5_965 METAL6_2063600_649700 METAL6_2063600_658600 0.0178
R_VDD5_966 METAL6_2063600_658600 METAL6_2063600_661200 0.0052
R_VDD5_967 METAL6_2063600_661200 METAL6_2063600_661700 0.001
R_VDD5_968 METAL6_2063600_661700 METAL6_2063600_673200 0.023
R_VDD5_969 METAL6_2063600_673200 METAL6_2063600_736000 0.1256
R_VDD5_970 METAL6_2063600_736000 METAL6_2063600_817400 0.1628
R_VDD5_971 METAL6_2063600_817400 METAL6_2063600_829300 0.0238
R_VDD5_972 METAL6_2063600_829300 METAL5_2063600_829300 0.1
R_VDD5_973 METAL5_2063600_829300 METAL5_2063600_829400 0.0004
R_VDD5_974 METAL5_2063600_829400 METAL5_2063600_841300 0.0476
R_VDD5_975 METAL5_2063600_841300 METAL5_2063600_841400 0.0004
R_VDD5_976 METAL5_2063600_841400 METAL5_2063600_853300 0.0476
R_VDD5_977 METAL5_2063600_853300 METAL6_2063600_853300 0.1
R_VDD5_978 METAL6_2063600_853300 METAL6_2063600_853400 0.0002
R_VDD5_979 METAL6_2063600_853400 METAL6_2063600_853700 0.0006
R_VDD5_980 METAL6_2063600_853700 METAL6_2063600_860400 0.0134
R_VDD5_981 METAL6_2063600_860400 METAL6_2063600_1036300 0.3518
R_VDD5_982 METAL6_2063600_1036300 METAL6_2063600_1041400 0.0102
R_VDD5_983 METAL6_2063600_1041400 METAL6_2063600_1043300 0.0038
R_VDD5_984 METAL6_2063600_1043300 METAL6_2063600_1048700 0.0108
R_VDD5_985 METAL6_2063600_1048700 METAL6_2063600_1055300 0.0132
R_VDD5_986 METAL6_2063600_1055300 METAL6_2063600_1055400 0.0002
R_VDD5_987 METAL6_2063600_1055400 METAL6_2063600_1055700 0.0006
R_VDD5_988 METAL6_2063600_1055700 METAL6_2063600_1067300 0.0232
R_VDD5_989 METAL6_2063600_1067300 METAL6_2063600_1067700 0.0008
R_VDD5_990 METAL6_2063600_1067700 METAL6_2063600_1079700 0.024
R_VDD5_991 METAL6_2063600_1079700 METAL6_2063600_1128600 0.0978
R_VDD5_992 METAL6_2063600_1128600 METAL6_2063600_1140600 0.024
R_VDD5_993 METAL6_2063600_1140600 METAL6_2063600_1152600 0.024
R_VDD5_994 METAL6_2063600_1152600 METAL6_2063600_1236400 0.1676
R_VDD5_995 METAL6_2063600_1236400 METAL6_2063600_1243400 0.014
R_VDD5_996 METAL6_2063600_1243400 METAL6_2063600_1255400 0.024
R_VDD5_997 METAL6_2063600_1255400 METAL6_2046900_1255400 0.0334
R_VDD5_998 METAL6_2046900_1255400 METAL6_2019900_1255400 0.054
R_VDD5_999 METAL6_2019900_1255400 METAL6_2019900_1267400 0.024
R_VDD5_1000 METAL6_2019900_1267400 METAL6_2019900_1272600 0.0104
R_VDD5_1001 METAL6_2019900_1272600 METAL6_2019900_1306300 0.0674
R_VDD5_1002 METAL6_2019900_1306300 METAL6_2019900_1318000 0.0234
R_VDD5_1003 METAL6_2019900_1318000 METAL6_2019900_1336300 0.0366
R_VDD5_1004 METAL6_2019900_1336300 METAL6_2019900_1348300 0.024
R_VDD5_1005 METAL6_2019900_1348300 METAL6_2019900_1359100 0.0216
R_VDD5_1006 METAL6_2019900_1359100 METAL6_2019900_1360300 0.0024
R_VDD5_1007 METAL6_2019900_1360300 METAL6_2019900_1371100 0.0216
R_VDD5_1008 METAL6_2019900_1371100 METAL6_2019900_1383100 0.024
R_VDD5_1009 METAL6_2019900_1383100 METAL6_2019900_1390100 0.014
R_VDD5_1010 METAL6_2019900_1390100 METAL6_2019900_1438000 0.0958
R_VDD5_1011 METAL6_2019900_1438000 METAL6_2019900_1450000 0.024
R_VDD5_1012 METAL6_2019900_1450000 METAL6_2019900_1462000 0.024
R_VDD5_1013 METAL6_2019900_1462000 METAL6_2019900_1526300 0.1286
R_VDD5_1014 METAL6_2019900_1526300 METAL6_2019900_1538300 0.024
R_VDD5_1015 METAL6_2019900_1538300 METAL6_2019900_1550300 0.024
R_VDD5_1016 METAL6_2019900_1550300 METAL6_2019900_1571100 0.0416
R_VDD5_1017 METAL6_2019900_1571100 METAL6_2019900_1585100 0.028
R_VDD5_1018 METAL6_2019900_1585100 METAL6_2019900_1766100 0.362
R_VDD5_1019 METAL6_2019900_1766100 METAL6_2012000_1766100 0.0158
R_VDD5_1020 METAL6_2012000_1766100 METAL6_2000000_1766100 0.024
R_VDD5_1021 METAL6_2000000_1766100 METAL6_2000000_1773100 0.014
R_VDD5_1022 METAL6_2000000_1773100 METAL6_2000000_1785100 0.024
R_VDD5_1023 METAL6_2000000_1785100 METAL6_1994500_1785100 0.011
R_VDD5_1024 METAL6_1994500_1785100 METAL6_1988000_1785100 0.013
R_VDD5_1025 METAL6_1988000_1785100 METAL6_1843600_1785100 0.2888
R_VDD5_1026 METAL6_1843600_1785100 METAL6_1838900_1785100 0.0094
R_VDD5_1027 METAL6_1838900_1785100 METAL6_1831600_1785100 0.0146
R_VDD5_1028 METAL6_1831600_1785100 METAL6_1826900_1785100 0.0094
R_VDD5_1029 METAL6_1826900_1785100 METAL6_1819600_1785100 0.0146
R_VDD5_1030 METAL6_1819600_1785100 METAL6_1814900_1785100 0.0094
R_VDD5_1031 METAL6_1814900_1785100 METAL6_1802900_1785100 0.024
R_VDD5_1032 METAL6_1802900_1785100 METAL6_1799900_1785100 0.006
R_VDD5_1033 METAL6_1799900_1785100 METAL6_1787900_1785100 0.024
R_VDD5_1034 METAL6_1787900_1785100 METAL6_1775900_1785100 0.024
R_VDD5_1035 METAL6_1775900_1785100 METAL6_1774500_1785100 0.0028
R_VDD5_1036 METAL6_1774500_1785100 METAL6_1762500_1785100 0.024
R_VDD5_1037 METAL6_1762500_1773100 METAL6_1762500_1785100 0.024
R_VDD5_1038 METAL6_1787900_1383100 METAL6_1787900_1371100 0.024
R_VDD5_1039 METAL6_2063600_1152600 METAL6_2075600_1152600 0.024
R_VDD5_1040 METAL6_2075600_1152600 METAL6_2075600_1236400 0.1676
R_VDD5_1041 METAL6_2075600_1236400 METAL6_2075600_1243400 0.014
R_VDD5_1042 METAL6_2075600_1243400 METAL6_2075600_1255400 0.024
R_VDD5_1043 METAL6_2075600_1255400 METAL6_2075600_1267400 0.024
R_VDD5_1044 METAL6_2075600_1267400 METAL6_2063600_1267400 0.024
R_VDD5_1045 METAL6_2063600_1267400 METAL6_2051600_1267400 0.024
R_VDD5_1046 METAL6_2051600_1267400 METAL6_2051600_1272600 0.0104
R_VDD5_1047 METAL6_2051600_1272600 METAL6_2051600_1306300 0.0674
R_VDD5_1048 METAL6_2051600_1306300 METAL6_2051600_1318000 0.0234
R_VDD5_1049 METAL6_2051600_1318000 METAL6_2051600_1336300 0.0366
R_VDD5_1050 METAL6_2051600_1336300 METAL6_2051600_1348300 0.024
R_VDD5_1051 METAL6_2051600_1348300 METAL6_2051600_1359100 0.0216
R_VDD5_1052 METAL6_2051600_1359100 METAL6_2046900_1359100 0.0094
R_VDD5_1053 METAL6_2046900_1359100 METAL6_2031900_1359100 0.03
R_VDD5_1054 METAL6_2031900_1359100 METAL5_2031900_1359100 0.1
R_VDD5_1055 METAL5_2031900_1359100 METAL5_2019900_1359100 0.048
R_VDD5_1056 METAL5_2019900_1359100 METAL5_2012000_1359100 0.0316
R_VDD5_1057 METAL5_2012000_1359100 METAL5_2007900_1359100 0.0164
R_VDD5_1058 METAL5_2007900_1359100 METAL6_2007900_1359100 0.1
R_VDD5_1059 METAL6_2007900_1359100 METAL6_2000000_1359100 0.0158
R_VDD5_1060 METAL6_2000000_1359100 METAL6_1994500_1359100 0.011
R_VDD5_1061 METAL6_1994500_1359100 METAL6_1988000_1359100 0.013
R_VDD5_1062 METAL6_1988000_1359100 METAL6_1843600_1359100 0.2888
R_VDD5_1063 METAL6_1843600_1359100 METAL6_1838900_1359100 0.0094
R_VDD5_1064 METAL6_1838900_1359100 METAL6_1831600_1359100 0.0146
R_VDD5_1065 METAL6_1831600_1359100 METAL6_1826900_1359100 0.0094
R_VDD5_1066 METAL6_1826900_1359100 METAL6_1819600_1359100 0.0146
R_VDD5_1067 METAL6_1819600_1359100 METAL6_1814900_1359100 0.0094
R_VDD5_1068 METAL6_1814900_1359100 METAL6_1802900_1359100 0.024
R_VDD5_1069 METAL6_1802900_1359100 METAL6_1799900_1359100 0.006
R_VDD5_1070 METAL6_1799900_1359100 METAL6_1787900_1359100 0.024
R_VDD5_1071 METAL6_1787900_1359100 METAL6_1787900_1360300 0.0024
R_VDD5_1072 METAL6_1787900_1360300 METAL6_1787900_1371100 0.0216
R_VDD5_1073 METAL6_1831600_1243400 METAL6_1831600_1255400 0.024
R_VDD5_1074 METAL6_1500000_8000 METAL6_1511000_8000 0.022
R_VDD5_1075 METAL6_1511000_8000 METAL6_1512000_8000 0.002
R_VDD5_1076 METAL6_1512000_8000 METAL6_1512000_20000 0.024
R_VDD5_1077 METAL6_1512000_20000 METAL6_1512000_69500 0.099
R_VDD5_1078 METAL6_1512000_69500 METAL6_1512000_150800 0.1626
R_VDD5_1079 METAL6_1512000_150800 METAL6_1512000_162800 0.024
R_VDD5_1080 METAL6_1512000_162800 METAL6_1512000_174800 0.024
R_VDD5_1081 METAL6_1512000_174800 METAL6_1523000_174800 0.022
R_VDD5_1082 METAL6_1523000_174800 METAL6_1538500_174800 0.031
R_VDD5_1083 METAL6_1538500_174800 METAL6_1550500_174800 0.024
R_VDD5_1084 METAL6_1550500_174800 METAL6_1562500_174800 0.024
R_VDD5_1085 METAL6_1562500_174800 METAL6_1562500_186800 0.024
R_VDD5_1086 METAL6_1562500_186800 METAL6_1574500_186800 0.024
R_VDD5_1087 METAL6_1574500_186800 METAL6_1574500_193800 0.014
R_VDD5_1088 METAL6_1574500_193800 METAL6_1574500_198800 0.01
R_VDD5_1089 METAL6_1574500_198800 METAL6_1574500_211300 0.025
R_VDD5_1090 METAL6_1574500_211300 METAL6_1574500_223300 0.024
R_VDD5_1091 METAL6_1574500_223300 METAL6_1574500_235300 0.024
R_VDD5_1092 METAL6_1574500_235300 METAL6_1574500_242300 0.014
R_VDD5_1093 METAL6_1574500_242300 METAL6_1574500_247300 0.01
R_VDD5_1094 METAL6_1574500_247300 METAL6_1574500_388800 0.283
R_VDD5_1095 METAL6_1574500_388800 METAL6_1574500_411700 0.0458
R_VDD5_1096 METAL6_1574500_411700 METAL6_1574500_423700 0.024
R_VDD5_1097 METAL6_1574500_423700 METAL6_1575900_423700 0.0028
R_VDD5_1098 METAL6_1575900_423700 METAL6_1587900_423700 0.024
R_VDD5_1099 METAL6_1587900_423700 METAL6_1599900_423700 0.024
R_VDD5_1100 METAL6_1599900_423700 METAL6_1602900_423700 0.006
R_VDD5_1101 METAL6_1602900_423700 METAL6_1614900_423700 0.024
R_VDD5_1102 METAL6_1614900_423700 METAL6_1619600_423700 0.0094
R_VDD5_1103 METAL6_1619600_423700 METAL6_1626900_423700 0.0146
R_VDD5_1104 METAL6_1626900_423700 METAL6_1631600_423700 0.0094
R_VDD5_1105 METAL6_1631600_423700 METAL6_1643600_423700 0.024
R_VDD5_1106 METAL6_1643600_423700 METAL6_1750500_423700 0.2138
R_VDD5_1107 METAL6_1750500_423700 METAL6_1762500_423700 0.024
R_VDD5_1108 METAL6_1762500_423700 METAL6_1774500_423700 0.024
R_VDD5_1109 METAL6_1774500_423700 METAL6_1775900_423700 0.0028
R_VDD5_1110 METAL6_1775900_423700 METAL6_1787900_423700 0.024
R_VDD5_1111 METAL6_1787900_423700 METAL6_1799900_423700 0.024
R_VDD5_1112 METAL6_1799900_423700 METAL6_1802900_423700 0.006
R_VDD5_1113 METAL6_1802900_423700 METAL6_1814900_423700 0.024
R_VDD5_1114 METAL6_1814900_423700 METAL6_1819600_423700 0.0094
R_VDD5_1115 METAL6_1819600_423700 METAL6_1826900_423700 0.0146
R_VDD5_1116 METAL6_1826900_423700 METAL6_1831600_423700 0.0094
R_VDD5_1117 METAL6_1831600_423700 METAL6_1838900_423700 0.0146
R_VDD5_1118 METAL6_1838900_423700 METAL6_1843600_423700 0.0094
R_VDD5_1119 METAL6_1843600_423700 METAL6_1988000_423700 0.2888
R_VDD5_1120 METAL6_1988000_423700 METAL6_1994500_423700 0.013
R_VDD5_1121 METAL6_1994500_423700 METAL6_1995900_423700 0.0028
R_VDD5_1122 METAL6_1995900_423700 METAL6_2000000_423700 0.0082
R_VDD5_1123 METAL6_2000000_423700 METAL6_2007900_423700 0.0158
R_VDD5_1124 METAL6_2007900_423700 METAL6_2012000_423700 0.0082
R_VDD5_1125 METAL6_2012000_423700 METAL6_2019900_423700 0.0158
R_VDD5_1126 METAL6_2019900_423700 METAL6_2031900_423700 0.024
R_VDD5_1127 METAL6_2031900_423700 METAL6_2039600_423700 0.0154
R_VDD5_1128 METAL6_2039600_423700 METAL6_2043900_423700 0.0086
R_VDD5_1129 METAL6_2043900_423700 METAL6_2046900_423700 0.006
R_VDD5_1130 METAL6_2046900_423700 METAL6_2051600_423700 0.0094
R_VDD5_1131 METAL6_2051600_423700 METAL6_2063600_423700 0.024
R_VDD5_1132 METAL6_2063600_423700 METAL6_2075600_423700 0.024
R_VDD5_1133 METAL6_2075600_423700 METAL6_2081000_423700 0.0108
R_VDD5_1134 METAL6_2081000_423700 METAL6_2087600_423700 0.0132
R_VDD5_1135 METAL6_2087600_423700 METAL6_2093000_423700 0.0108
R_VDD5_1136 METAL6_2093000_423700 METAL6_2105000_423700 0.024
R_VDD5_1137 METAL6_2105000_423700 METAL6_2105000_435700 0.024
R_VDD5_1138 METAL6_2105000_435700 METAL6_2105000_437300 0.0032
R_VDD5_1139 METAL6_2105000_437300 METAL6_2105000_447200 0.0198
R_VDD5_1140 METAL6_2105000_447200 METAL6_2105000_447700 0.001
R_VDD5_1141 METAL6_2105000_447700 METAL6_2105000_454700 0.014
R_VDD5_1142 METAL6_2105000_454700 METAL6_2105000_489500 0.0696
R_VDD5_1143 METAL6_2105000_489500 METAL6_2105000_501500 0.024
R_VDD5_1144 METAL6_2105000_501500 METAL6_2105000_510000 0.017
R_VDD5_1145 METAL6_2105000_510000 METAL6_2105000_513500 0.007
R_VDD5_1146 METAL6_2105000_513500 METAL6_2105000_522000 0.017
R_VDD5_1147 METAL6_2105000_522000 METAL6_2105000_534000 0.024
R_VDD5_1148 METAL6_2105000_534000 METAL6_2105000_541000 0.014
R_VDD5_1149 METAL6_2105000_541000 METAL6_2105000_583500 0.085
R_VDD5_1150 METAL6_2105000_583500 METAL6_2105000_637700 0.1084
R_VDD5_1151 METAL6_2105000_637700 METAL6_2105000_642200 0.009
R_VDD5_1152 METAL6_2105000_642200 METAL6_2105000_649200 0.014
R_VDD5_1153 METAL6_2105000_649200 METAL6_2105000_649700 0.001
R_VDD5_1154 METAL6_2105000_649700 METAL6_2105000_658600 0.0178
R_VDD5_1155 METAL6_2105000_658600 METAL6_2105000_661200 0.0052
R_VDD5_1156 METAL6_2105000_661200 METAL6_2105000_661700 0.001
R_VDD5_1157 METAL6_2105000_661700 METAL6_2093000_661700 0.024
R_VDD5_1158 METAL6_2093000_661700 METAL6_2093000_673200 0.023
R_VDD5_1159 METAL6_2093000_673200 METAL6_2093000_736000 0.1256
R_VDD5_1160 METAL6_2093000_736000 METAL6_2093000_817300 0.1626
R_VDD5_1161 METAL6_2093000_817300 METAL6_2087600_817300 0.0108
R_VDD5_1162 METAL6_2087600_817300 METAL6_2087600_817400 0.0002
R_VDD5_1163 METAL6_2087600_817400 METAL6_2087600_829300 0.0238
R_VDD5_1164 METAL6_2087600_829300 METAL5_2087600_829300 0.1
R_VDD5_1165 METAL5_2087600_829300 METAL5_2087600_829400 0.0004
R_VDD5_1166 METAL5_2087600_829400 METAL5_2087600_841300 0.0476
R_VDD5_1167 METAL5_2087600_841300 METAL5_2087600_841400 0.0004
R_VDD5_1168 METAL5_2087600_841400 METAL5_2087600_853300 0.0476
R_VDD5_1169 METAL5_2087600_853300 METAL6_2087600_853300 0.1
R_VDD5_1170 METAL6_2087600_853300 METAL6_2087600_853400 0.0002
R_VDD5_1171 METAL6_2087600_853400 METAL6_2087600_853700 0.0006
R_VDD5_1172 METAL6_2087600_853700 METAL6_2087600_860400 0.0134
R_VDD5_1173 METAL6_2087600_860400 METAL6_2087600_865300 0.0098
R_VDD5_1174 METAL6_2087600_865300 METAL6_2087600_1036300 0.342
R_VDD5_1175 METAL6_2087600_1036300 METAL6_2087600_1041400 0.0102
R_VDD5_1176 METAL6_2087600_1041400 METAL6_2087600_1043300 0.0038
R_VDD5_1177 METAL6_2087600_1043300 METAL6_2087600_1048700 0.0108
R_VDD5_1178 METAL6_2087600_1048700 METAL6_2087600_1055300 0.0132
R_VDD5_1179 METAL6_2087600_1055300 METAL6_2087600_1055400 0.0002
R_VDD5_1180 METAL6_2087600_1055400 METAL6_2087600_1055700 0.0006
R_VDD5_1181 METAL6_2087600_1055700 METAL6_2087600_1067300 0.0232
R_VDD5_1182 METAL6_2087600_1067300 METAL6_2087600_1067700 0.0008
R_VDD5_1183 METAL6_2087600_1067700 METAL6_2087600_1079700 0.024
R_VDD5_1184 METAL6_2087600_1079700 METAL6_2087600_1128600 0.0978
R_VDD5_1185 METAL6_2087600_1128600 METAL6_2087600_1140600 0.024
R_VDD5_1186 METAL6_2087600_1140600 METAL6_2087600_1152600 0.024
R_VDD5_1187 METAL6_2087600_1152600 METAL6_2087600_1164600 0.024
R_VDD5_1188 METAL6_2087600_1164600 METAL6_2087600_1236400 0.1436
R_VDD5_1189 METAL6_2087600_1236400 METAL6_2087600_1243400 0.014
R_VDD5_1190 METAL6_2087600_1243400 METAL6_2087600_1255400 0.024
R_VDD5_1191 METAL6_2087600_1255400 METAL5_2087600_1255400 0.1
R_VDD5_1192 METAL5_2087600_1255400 METAL5_2081000_1255400 0.0264
R_VDD5_1193 METAL5_2081000_1255400 METAL5_2075600_1255400 0.0216
R_VDD5_1194 METAL5_2075600_1255400 METAL5_2063600_1255400 0.048
R_VDD5_1195 METAL5_2063600_1255400 METAL5_2051600_1255400 0.048
R_VDD5_1196 METAL5_2051600_1255400 METAL5_2046900_1255400 0.0188
R_VDD5_1197 METAL5_2046900_1255400 METAL5_2043900_1255400 0.012
R_VDD5_1198 METAL5_2043900_1255400 METAL5_2039600_1255400 0.0172
R_VDD5_1199 METAL5_2039600_1255400 METAL5_2031900_1255400 0.0308
R_VDD5_1200 METAL5_2031900_1255400 METAL5_2019900_1255400 0.048
R_VDD5_1201 METAL5_2019900_1255400 METAL5_2012000_1255400 0.0316
R_VDD5_1202 METAL5_2012000_1255400 METAL5_2007900_1255400 0.0164
R_VDD5_1203 METAL5_2007900_1255400 METAL6_2007900_1255400 0.1
R_VDD5_1204 METAL6_2007900_1255400 METAL6_2000000_1255400 0.0158
R_VDD5_1205 METAL6_2000000_1255400 METAL6_1995900_1255400 0.0082
R_VDD5_1206 METAL6_1995900_1255400 METAL6_1994500_1255400 0.0028
R_VDD5_1207 METAL6_1994500_1255400 METAL6_1988000_1255400 0.013
R_VDD5_1208 METAL6_1988000_1255400 METAL6_1843600_1255400 0.2888
R_VDD5_1209 METAL6_1843600_1255400 METAL6_1838900_1255400 0.0094
R_VDD5_1210 METAL6_1838900_1255400 METAL6_1831600_1255400 0.0146
R_VDD5_1211 METAL6_1814900_853400 METAL6_1814900_841400 0.024
R_VDD5_1212 METAL5_2087600_841400 METAL5_2081000_841400 0.0264
R_VDD5_1213 METAL5_2081000_841400 METAL5_2075600_841400 0.0216
R_VDD5_1214 METAL5_2075600_841400 METAL5_2075600_841300 0.0004
R_VDD5_1215 METAL5_2075600_841300 METAL5_2075600_829400 0.0476
R_VDD5_1216 METAL5_2075600_829400 METAL5_2075600_829300 0.0004
R_VDD5_1217 METAL5_2075600_829300 METAL5_2075600_817400 0.0476
R_VDD5_1218 METAL5_2075600_817400 METAL5_2075600_817300 0.0004
R_VDD5_1219 METAL5_2075600_817300 METAL5_2063600_817300 0.048
R_VDD5_1220 METAL5_2063600_817300 METAL5_2051600_817300 0.048
R_VDD5_1221 METAL5_2051600_817300 METAL6_2051600_817300 0.1
R_VDD5_1222 METAL6_2051600_817300 METAL6_2046900_817300 0.0094
R_VDD5_1223 METAL6_2046900_817300 METAL6_2043900_817300 0.006
R_VDD5_1224 METAL6_2043900_817300 METAL6_2039600_817300 0.0086
R_VDD5_1225 METAL6_2039600_817300 METAL6_2031900_817300 0.0154
R_VDD5_1226 METAL6_2031900_817300 METAL6_2019900_817300 0.024
R_VDD5_1227 METAL6_2019900_817300 METAL6_2012000_817300 0.0158
R_VDD5_1228 METAL6_2012000_817300 METAL6_2007900_817300 0.0082
R_VDD5_1229 METAL6_2007900_817300 METAL6_2000000_817300 0.0158
R_VDD5_1230 METAL6_2000000_817300 METAL6_1995900_817300 0.0082
R_VDD5_1231 METAL6_1995900_817300 METAL6_1994500_817300 0.0028
R_VDD5_1232 METAL6_1994500_817300 METAL6_1988000_817300 0.013
R_VDD5_1233 METAL6_1988000_817300 METAL6_1843600_817300 0.2888
R_VDD5_1234 METAL6_1843600_817300 METAL6_1838900_817300 0.0094
R_VDD5_1235 METAL6_1838900_817300 METAL6_1831600_817300 0.0146
R_VDD5_1236 METAL6_1831600_817300 METAL6_1826900_817300 0.0094
R_VDD5_1237 METAL6_1826900_817300 METAL6_1819600_817300 0.0146
R_VDD5_1238 METAL6_1819600_817300 METAL6_1814900_817300 0.0094
R_VDD5_1239 METAL6_1814900_817300 METAL6_1814900_817400 0.0002
R_VDD5_1240 METAL6_1814900_817400 METAL5_1814900_817400 0.1
R_VDD5_1241 METAL5_1814900_817400 METAL5_1814900_829300 0.0476
R_VDD5_1242 METAL5_1814900_829300 METAL5_1814900_829400 0.0004
R_VDD5_1243 METAL5_1814900_829400 METAL5_1814900_841300 0.0476
R_VDD5_1244 METAL5_1814900_841300 METAL5_1814900_841400 0.0004
R_VDD5_1245 METAL5_1814900_841400 METAL6_1814900_841400 0.1
R_VDD5_1246 METAL6_1311000_447700 METAL6_1311000_447200 0.001
R_VDD5_1247 METAL6_1311000_447200 METAL6_1311000_437300 0.0198
R_VDD5_1248 METAL6_1311000_437300 METAL6_1311000_435700 0.0032
R_VDD5_1249 METAL6_1574500_411700 METAL6_1562500_411700 0.024
R_VDD5_1250 METAL6_1562500_411700 METAL6_1550500_411700 0.024
R_VDD5_1251 METAL6_1550500_411700 METAL6_1538500_411700 0.024
R_VDD5_1252 METAL6_1538500_411700 METAL6_1524000_411700 0.029
R_VDD5_1253 METAL6_1524000_411700 METAL6_1523000_411700 0.002
R_VDD5_1254 METAL6_1523000_411700 METAL5_1523000_411700 0.1
R_VDD5_1255 METAL5_1523000_411700 METAL5_1512000_411700 0.044
R_VDD5_1256 METAL5_1512000_411700 METAL5_1511000_411700 0.004
R_VDD5_1257 METAL5_1511000_411700 METAL5_1500000_411700 0.044
R_VDD5_1258 METAL5_1500000_411700 METAL5_1499000_411700 0.004
R_VDD5_1259 METAL5_1499000_411700 METAL6_1499000_411700 0.1
R_VDD5_1260 METAL6_1499000_411700 METAL6_1499000_423700 0.024
R_VDD5_1261 METAL6_1499000_423700 METAL6_1499000_435700 0.024
R_VDD5_1262 METAL6_1499000_435700 METAL6_1488000_435700 0.022
R_VDD5_1263 METAL6_1488000_435700 METAL6_1487000_435700 0.002
R_VDD5_1264 METAL6_1487000_435700 METAL6_1323000_435700 0.328
R_VDD5_1265 METAL6_1323000_435700 METAL6_1311000_435700 0.024
I_VDD5_12 METAL6_1762500_1773100 gnd 0.005
I_VDD5_13 METAL6_1787900_1383100 gnd 0.005
I_VDD5_14 METAL6_1831600_1243400 gnd 0.005
I_VDD5_15 METAL6_1814900_853400 gnd 0.005
I_VDD5_16 METAL6_1311000_447700 gnd 0.005

V_VDD6_6 METAL6_2000000_0 gnd 1.6
R_VDD6_1266 METAL6_2000000_0 METAL6_2000000_8000 0.016
R_VDD6_1267 METAL6_2000000_8000 METAL6_2000000_20000 0.024
R_VDD6_1268 METAL6_2000000_20000 METAL6_2000000_69500 0.099
R_VDD6_1269 METAL6_2000000_69500 METAL6_2000000_126800 0.1146
R_VDD6_1270 METAL6_2000000_126800 METAL6_2000000_138800 0.024
R_VDD6_1271 METAL6_2000000_138800 METAL6_2000000_150800 0.024
R_VDD6_1272 METAL6_2000000_150800 METAL6_2000000_162800 0.024
R_VDD6_1273 METAL6_2000000_162800 METAL5_2000000_162800 0.1
R_VDD6_1274 METAL5_2000000_162800 METAL5_2000000_174800 0.048
R_VDD6_1275 METAL5_2000000_174800 METAL5_2000000_181800 0.028
R_VDD6_1276 METAL5_2000000_181800 METAL5_2000000_186800 0.02
R_VDD6_1277 METAL5_2000000_186800 METAL6_2000000_186800 0.1
R_VDD6_1278 METAL6_2000000_186800 METAL6_2007900_186800 0.0158
R_VDD6_1279 METAL6_2007900_186800 METAL6_2007900_193800 0.014
R_VDD6_1280 METAL6_2007900_193800 METAL6_2007900_198800 0.01
R_VDD6_1281 METAL6_2007900_198800 METAL6_2007900_205800 0.014
R_VDD6_1282 METAL6_2007900_205800 METAL6_2007900_211300 0.011
R_VDD6_1283 METAL6_2007900_211300 METAL6_2007900_223300 0.024
R_VDD6_1284 METAL6_2007900_223300 METAL6_2007900_235300 0.024
R_VDD6_1285 METAL6_2007900_235300 METAL6_2007900_242300 0.014
R_VDD6_1286 METAL6_2007900_242300 METAL6_2007900_247300 0.01
R_VDD6_1287 METAL6_2007900_247300 METAL6_2007900_375700 0.2568
R_VDD6_1288 METAL6_2007900_375700 METAL6_2012000_375700 0.0082
R_VDD6_1289 METAL6_2012000_375700 METAL6_2019900_375700 0.0158
R_VDD6_1290 METAL6_2019900_375700 METAL6_2031900_375700 0.024
R_VDD6_1291 METAL6_2031900_375700 METAL6_2039600_375700 0.0154
R_VDD6_1292 METAL6_2039600_375700 METAL6_2043900_375700 0.0086
R_VDD6_1293 METAL6_2043900_375700 METAL6_2046900_375700 0.006
R_VDD6_1294 METAL6_2046900_375700 METAL6_2051600_375700 0.0094
R_VDD6_1295 METAL6_2051600_375700 METAL6_2063600_375700 0.024
R_VDD6_1296 METAL6_2063600_375700 METAL6_2075600_375700 0.024
R_VDD6_1297 METAL6_2075600_375700 METAL6_2081000_375700 0.0108
R_VDD6_1298 METAL6_2081000_375700 METAL6_2087600_375700 0.0132
R_VDD6_1299 METAL6_2087600_375700 METAL6_2093000_375700 0.0108
R_VDD6_1300 METAL6_2093000_375700 METAL6_2099600_375700 0.0132
R_VDD6_1301 METAL6_2099600_375700 METAL6_2105000_375700 0.0108
R_VDD6_1302 METAL6_2105000_375700 METAL6_2117000_375700 0.024
R_VDD6_1303 METAL6_2117000_375700 METAL5_2117000_375700 0.1
R_VDD6_1304 METAL5_2117000_375700 METAL5_2117000_376800 0.0044
R_VDD6_1305 METAL5_2117000_376800 METAL5_2117000_387700 0.0436
R_VDD6_1306 METAL5_2117000_387700 METAL5_2117000_388800 0.0044
R_VDD6_1307 METAL5_2117000_388800 METAL5_2117000_399700 0.0436
R_VDD6_1308 METAL5_2117000_399700 METAL5_2117000_400800 0.0044
R_VDD6_1309 METAL5_2117000_400800 METAL5_2117000_411700 0.0436
R_VDD6_1310 METAL5_2117000_411700 METAL5_2117000_423700 0.048
R_VDD6_1311 METAL5_2117000_423700 METAL6_2117000_423700 0.1
R_VDD6_1312 METAL6_2117000_423700 METAL6_2117000_435700 0.024
R_VDD6_1313 METAL6_2117000_435700 METAL6_2117000_437300 0.0032
R_VDD6_1314 METAL6_2117000_437300 METAL6_2117000_447200 0.0198
R_VDD6_1315 METAL6_2117000_447200 METAL6_2117000_447700 0.001
R_VDD6_1316 METAL6_2117000_447700 METAL6_2117000_454700 0.014
R_VDD6_1317 METAL6_2117000_454700 METAL6_2117000_459700 0.01
R_VDD6_1318 METAL6_2117000_459700 METAL6_2117000_489500 0.0596
R_VDD6_1319 METAL6_2117000_489500 METAL6_2117000_501500 0.024
R_VDD6_1320 METAL6_2117000_501500 METAL6_2117000_510000 0.017
R_VDD6_1321 METAL6_2117000_510000 METAL6_2117000_513500 0.007
R_VDD6_1322 METAL6_2117000_513500 METAL6_2117000_522000 0.017
R_VDD6_1323 METAL6_2117000_522000 METAL6_2117000_534000 0.024
R_VDD6_1324 METAL6_2117000_534000 METAL6_2117000_541000 0.014
R_VDD6_1325 METAL6_2117000_541000 METAL6_2117000_583500 0.085
R_VDD6_1326 METAL6_2117000_583500 METAL6_2117000_637700 0.1084
R_VDD6_1327 METAL6_2117000_637700 METAL6_2117000_642200 0.009
R_VDD6_1328 METAL6_2117000_642200 METAL6_2117000_649200 0.014
R_VDD6_1329 METAL6_2117000_649200 METAL6_2117000_649700 0.001
R_VDD6_1330 METAL6_2117000_649700 METAL6_2117000_658600 0.0178
R_VDD6_1331 METAL6_2117000_658600 METAL6_2117000_661200 0.0052
R_VDD6_1332 METAL6_2117000_661200 METAL6_2117000_661700 0.001
R_VDD6_1333 METAL6_2117000_661700 METAL6_2117000_673200 0.023
R_VDD6_1334 METAL6_2117000_673200 METAL6_2117000_673700 0.001
R_VDD6_1335 METAL6_2117000_673700 METAL6_2117000_736000 0.1246
R_VDD6_1336 METAL6_2117000_736000 METAL6_2117000_805300 0.1386
R_VDD6_1337 METAL6_2117000_805300 METAL6_2105000_805300 0.024
R_VDD6_1338 METAL6_2105000_805300 METAL6_2105000_805400 0.0002
R_VDD6_1339 METAL6_2105000_805400 METAL6_2105000_817300 0.0238
R_VDD6_1340 METAL6_2105000_817300 METAL6_2105000_817400 0.0002
R_VDD6_1341 METAL6_2105000_817400 METAL6_2105000_829300 0.0238
R_VDD6_1342 METAL6_2105000_829300 METAL5_2105000_829300 0.1
R_VDD6_1343 METAL5_2105000_829300 METAL5_2105000_829400 0.0004
R_VDD6_1344 METAL5_2105000_829400 METAL5_2105000_841300 0.0476
R_VDD6_1345 METAL5_2105000_841300 METAL5_2105000_841400 0.0004
R_VDD6_1346 METAL5_2105000_841400 METAL5_2105000_853300 0.0476
R_VDD6_1347 METAL5_2105000_853300 METAL6_2105000_853300 0.1
R_VDD6_1348 METAL6_2105000_853300 METAL6_2099600_853300 0.0108
R_VDD6_1349 METAL6_2099600_853300 METAL6_2099600_853400 0.0002
R_VDD6_1350 METAL6_2099600_853400 METAL6_2099600_853700 0.0006
R_VDD6_1351 METAL6_2099600_853700 METAL6_2099600_860400 0.0134
R_VDD6_1352 METAL6_2099600_860400 METAL6_2099600_865300 0.0098
R_VDD6_1353 METAL6_2099600_865300 METAL6_2099600_1036300 0.342
R_VDD6_1354 METAL6_2099600_1036300 METAL6_2099600_1041400 0.0102
R_VDD6_1355 METAL6_2099600_1041400 METAL6_2099600_1043300 0.0038
R_VDD6_1356 METAL6_2099600_1043300 METAL6_2099600_1048700 0.0108
R_VDD6_1357 METAL6_2099600_1048700 METAL6_2099600_1055300 0.0132
R_VDD6_1358 METAL6_2099600_1055300 METAL6_2099600_1055400 0.0002
R_VDD6_1359 METAL6_2099600_1055400 METAL6_2099600_1055700 0.0006
R_VDD6_1360 METAL6_2099600_1055700 METAL6_2099600_1067300 0.0232
R_VDD6_1361 METAL6_2099600_1067300 METAL6_2099600_1067700 0.0008
R_VDD6_1362 METAL6_2099600_1067700 METAL6_2099600_1079700 0.024
R_VDD6_1363 METAL6_2099600_1079700 METAL6_2099600_1128600 0.0978
R_VDD6_1364 METAL6_2099600_1128600 METAL6_2099600_1140600 0.024
R_VDD6_1365 METAL6_2099600_1140600 METAL6_2099600_1152600 0.024
R_VDD6_1366 METAL6_2099600_1152600 METAL6_2099600_1164600 0.024
R_VDD6_1367 METAL6_2099600_1164600 METAL6_2099600_1176600 0.024
R_VDD6_1368 METAL6_2099600_1176600 METAL6_2099600_1236400 0.1196
R_VDD6_1369 METAL6_2099600_1236400 METAL6_2099600_1243400 0.014
R_VDD6_1370 METAL6_2099600_1243400 METAL6_2099600_1255400 0.024
R_VDD6_1371 METAL6_2099600_1255400 METAL6_2099600_1267400 0.024
R_VDD6_1372 METAL6_2099600_1267400 METAL6_2093000_1267400 0.0132
R_VDD6_1373 METAL6_2093000_1267400 METAL6_2087600_1267400 0.0108
R_VDD6_1374 METAL6_2087600_1267400 METAL6_2087600_1272600 0.0104
R_VDD6_1375 METAL6_2087600_1272600 METAL6_2087600_1279400 0.0136
R_VDD6_1376 METAL6_2087600_1279400 METAL6_2087600_1306300 0.0538
R_VDD6_1377 METAL6_2087600_1306300 METAL6_2087600_1318000 0.0234
R_VDD6_1378 METAL6_2087600_1318000 METAL6_2087600_1336300 0.0366
R_VDD6_1379 METAL6_2087600_1336300 METAL6_2087600_1347100 0.0216
R_VDD6_1380 METAL6_2087600_1347100 METAL6_2081000_1347100 0.0132
R_VDD6_1381 METAL6_2081000_1347100 METAL6_2075600_1347100 0.0108
R_VDD6_1382 METAL6_2075600_1347100 METAL6_2063600_1347100 0.024
R_VDD6_1383 METAL6_2063600_1347100 METAL6_2063600_1348300 0.0024
R_VDD6_1384 METAL6_2063600_1348300 METAL6_2063600_1359100 0.0216
R_VDD6_1385 METAL6_2063600_1359100 METAL6_2063600_1360300 0.0024
R_VDD6_1386 METAL6_2063600_1360300 METAL6_2063600_1371100 0.0216
R_VDD6_1387 METAL6_2063600_1371100 METAL6_2051600_1371100 0.024
R_VDD6_1388 METAL6_2051600_1371100 METAL6_2046900_1371100 0.0094
R_VDD6_1389 METAL6_2046900_1371100 METAL6_2043900_1371100 0.006
R_VDD6_1390 METAL6_2043900_1371100 METAL6_2039600_1371100 0.0086
R_VDD6_1391 METAL6_2039600_1371100 METAL6_2031900_1371100 0.0154
R_VDD6_1392 METAL6_2031900_1371100 METAL6_2031900_1372300 0.0024
R_VDD6_1393 METAL6_2031900_1372300 METAL6_2031900_1383100 0.0216
R_VDD6_1394 METAL6_2031900_1383100 METAL6_2031900_1390100 0.014
R_VDD6_1395 METAL6_2031900_1390100 METAL6_2031900_1438000 0.0958
R_VDD6_1396 METAL6_2031900_1438000 METAL6_2031900_1450000 0.024
R_VDD6_1397 METAL6_2031900_1450000 METAL6_2031900_1462000 0.024
R_VDD6_1398 METAL6_2031900_1462000 METAL6_2031900_1526300 0.1286
R_VDD6_1399 METAL6_2031900_1526300 METAL6_2031900_1538300 0.024
R_VDD6_1400 METAL6_2031900_1538300 METAL6_2031900_1550300 0.024
R_VDD6_1401 METAL6_2031900_1550300 METAL6_2031900_1571100 0.0416
R_VDD6_1402 METAL6_2031900_1571100 METAL6_2031900_1585100 0.028
R_VDD6_1403 METAL6_2031900_1585100 METAL6_2031900_1754100 0.338
R_VDD6_1404 METAL6_2031900_1754100 METAL6_2031900_1766100 0.024
R_VDD6_1405 METAL6_2031900_1766100 METAL6_2031900_1773100 0.014
R_VDD6_1406 METAL6_2031900_1773100 METAL6_2031900_1778100 0.01
R_VDD6_1407 METAL6_2031900_1778100 METAL6_2019900_1778100 0.024
R_VDD6_1408 METAL6_2019900_1778100 METAL6_2012000_1778100 0.0158
R_VDD6_1409 METAL6_2012000_1778100 METAL6_2012000_1785100 0.014
R_VDD6_1410 METAL6_2012000_1785100 METAL6_2012000_1797100 0.024
R_VDD6_1411 METAL6_2012000_1797100 METAL6_2007900_1797100 0.0082
R_VDD6_1412 METAL6_2007900_1797100 METAL6_2000000_1797100 0.0158
R_VDD6_1413 METAL6_2000000_1797100 METAL6_1995900_1797100 0.0082
R_VDD6_1414 METAL6_1995900_1797100 METAL6_1994500_1797100 0.0028
R_VDD6_1415 METAL6_1994500_1797100 METAL6_1988000_1797100 0.013
R_VDD6_1416 METAL6_1988000_1797100 METAL6_1843600_1797100 0.2888
R_VDD6_1417 METAL6_1843600_1797100 METAL6_1838900_1797100 0.0094
R_VDD6_1418 METAL6_1838900_1797100 METAL6_1831600_1797100 0.0146
R_VDD6_1419 METAL6_1831600_1797100 METAL6_1826900_1797100 0.0094
R_VDD6_1420 METAL6_1826900_1797100 METAL6_1819600_1797100 0.0146
R_VDD6_1421 METAL6_1819600_1797100 METAL6_1814900_1797100 0.0094
R_VDD6_1422 METAL6_1814900_1797100 METAL6_1802900_1797100 0.024
R_VDD6_1423 METAL6_1802900_1797100 METAL6_1799900_1797100 0.006
R_VDD6_1424 METAL6_1799900_1797100 METAL6_1787900_1797100 0.024
R_VDD6_1425 METAL6_1787900_1797100 METAL6_1775900_1797100 0.024
R_VDD6_1426 METAL6_1775900_1797100 METAL6_1774500_1797100 0.0028
R_VDD6_1427 METAL6_1774500_1797100 METAL6_1762500_1797100 0.024
R_VDD6_1428 METAL6_1762500_1797100 METAL6_1750500_1797100 0.024
R_VDD6_1429 METAL6_1750500_1797100 METAL6_1643600_1797100 0.2138
R_VDD6_1430 METAL6_1643600_1797100 METAL6_1643600_1785100 0.024
R_VDD6_1431 METAL6_1643600_1785100 METAL6_1631600_1785100 0.024
R_VDD6_1432 METAL6_1631600_1785100 METAL6_1626900_1785100 0.0094
R_VDD6_1433 METAL6_1626900_1785100 METAL6_1622500_1785100 0.0088
R_VDD6_1434 METAL6_1622500_1785100 METAL6_1619600_1785100 0.0058
R_VDD6_1435 METAL6_1619600_1785100 METAL6_1614900_1785100 0.0094
R_VDD6_1436 METAL6_1614900_1785100 METAL6_1610500_1785100 0.0088
R_VDD6_1437 METAL6_1610500_1785100 METAL6_1602900_1785100 0.0152
R_VDD6_1438 METAL6_1602900_1785100 METAL6_1599900_1785100 0.006
R_VDD6_1439 METAL6_1599900_1785100 METAL6_1598500_1785100 0.0028
R_VDD6_1440 METAL6_1598500_1785100 METAL6_1587900_1785100 0.0212
R_VDD6_1441 METAL6_1587900_1785100 METAL6_1586500_1785100 0.0028
R_VDD6_1442 METAL6_1586500_1785100 METAL6_1575900_1785100 0.0212
R_VDD6_1443 METAL6_1575900_1785100 METAL6_1574500_1785100 0.0028
R_VDD6_1444 METAL6_1574500_1785100 METAL6_1562500_1785100 0.024
R_VDD6_1445 METAL6_1562500_1773100 METAL6_1562500_1785100 0.024
R_VDD6_1446 METAL6_1587900_1383100 METAL6_1587900_1371100 0.024
R_VDD6_1447 METAL6_2087600_1347100 METAL5_2087600_1347100 0.1
R_VDD6_1448 METAL5_2087600_1347100 METAL5_2081000_1347100 0.0264
R_VDD6_1449 METAL5_2081000_1347100 METAL5_2075600_1347100 0.0216
R_VDD6_1450 METAL5_2075600_1347100 METAL5_2063600_1347100 0.048
R_VDD6_1451 METAL5_2063600_1347100 METAL5_2051600_1347100 0.048
R_VDD6_1452 METAL5_2051600_1347100 METAL5_2046900_1347100 0.0188
R_VDD6_1453 METAL5_2046900_1347100 METAL5_2043900_1347100 0.012
R_VDD6_1454 METAL5_2043900_1347100 METAL5_2039600_1347100 0.0172
R_VDD6_1455 METAL5_2039600_1347100 METAL5_2031900_1347100 0.0308
R_VDD6_1456 METAL5_2031900_1347100 METAL5_2024000_1347100 0.0316
R_VDD6_1457 METAL5_2024000_1347100 METAL5_2019900_1347100 0.0164
R_VDD6_1458 METAL5_2019900_1347100 METAL5_2012000_1347100 0.0316
R_VDD6_1459 METAL5_2012000_1347100 METAL5_2007900_1347100 0.0164
R_VDD6_1460 METAL5_2007900_1347100 METAL6_2007900_1347100 0.1
R_VDD6_1461 METAL6_2007900_1347100 METAL6_2000000_1347100 0.0158
R_VDD6_1462 METAL6_2000000_1347100 METAL6_1995900_1347100 0.0082
R_VDD6_1463 METAL6_1995900_1347100 METAL6_1994500_1347100 0.0028
R_VDD6_1464 METAL6_1994500_1347100 METAL6_1988000_1347100 0.013
R_VDD6_1465 METAL6_1988000_1347100 METAL6_1843600_1347100 0.2888
R_VDD6_1466 METAL6_1843600_1347100 METAL6_1838900_1347100 0.0094
R_VDD6_1467 METAL6_1838900_1347100 METAL6_1831600_1347100 0.0146
R_VDD6_1468 METAL6_1831600_1347100 METAL6_1826900_1347100 0.0094
R_VDD6_1469 METAL6_1826900_1347100 METAL6_1819600_1347100 0.0146
R_VDD6_1470 METAL6_1819600_1347100 METAL6_1814900_1347100 0.0094
R_VDD6_1471 METAL6_1814900_1347100 METAL6_1802900_1347100 0.024
R_VDD6_1472 METAL6_1802900_1347100 METAL6_1799900_1347100 0.006
R_VDD6_1473 METAL6_1799900_1347100 METAL6_1787900_1347100 0.024
R_VDD6_1474 METAL6_1787900_1347100 METAL6_1775900_1347100 0.024
R_VDD6_1475 METAL6_1775900_1347100 METAL6_1774500_1347100 0.0028
R_VDD6_1476 METAL6_1774500_1347100 METAL6_1762500_1347100 0.024
R_VDD6_1477 METAL6_1762500_1347100 METAL6_1750500_1347100 0.024
R_VDD6_1478 METAL6_1750500_1347100 METAL6_1655600_1347100 0.1898
R_VDD6_1479 METAL6_1655600_1347100 METAL6_1643600_1347100 0.024
R_VDD6_1480 METAL6_1643600_1347100 METAL6_1631600_1347100 0.024
R_VDD6_1481 METAL6_1631600_1347100 METAL6_1626900_1347100 0.0094
R_VDD6_1482 METAL6_1626900_1347100 METAL6_1622500_1347100 0.0088
R_VDD6_1483 METAL6_1622500_1347100 METAL6_1619600_1347100 0.0058
R_VDD6_1484 METAL6_1619600_1347100 METAL6_1614900_1347100 0.0094
R_VDD6_1485 METAL6_1614900_1347100 METAL6_1610500_1347100 0.0088
R_VDD6_1486 METAL6_1610500_1347100 METAL6_1602900_1347100 0.0152
R_VDD6_1487 METAL6_1602900_1347100 METAL6_1599900_1347100 0.006
R_VDD6_1488 METAL6_1599900_1347100 METAL6_1598500_1347100 0.0028
R_VDD6_1489 METAL6_1598500_1347100 METAL6_1587900_1347100 0.0212
R_VDD6_1490 METAL6_1587900_1347100 METAL6_1587900_1348300 0.0024
R_VDD6_1491 METAL6_1587900_1348300 METAL6_1587900_1359100 0.0216
R_VDD6_1492 METAL6_1587900_1359100 METAL6_1587900_1360300 0.0024
R_VDD6_1493 METAL6_1587900_1360300 METAL6_1587900_1371100 0.0216
R_VDD6_1494 METAL6_1631600_1243400 METAL6_1631600_1255400 0.024
R_VDD6_1495 METAL6_2099600_1036300 METAL6_2105000_1036300 0.0108
R_VDD6_1496 METAL6_2105000_1036300 METAL6_2111600_1036300 0.0132
R_VDD6_1497 METAL6_2111600_1036300 METAL6_2111600_1041400 0.0102
R_VDD6_1498 METAL6_2111600_1041400 METAL6_2111600_1043300 0.0038
R_VDD6_1499 METAL6_2111600_1043300 METAL6_2111600_1048700 0.0108
R_VDD6_1500 METAL6_2111600_1048700 METAL6_2111600_1055300 0.0132
R_VDD6_1501 METAL6_2111600_1055300 METAL6_2111600_1055400 0.0002
R_VDD6_1502 METAL6_2111600_1055400 METAL6_2111600_1055700 0.0006
R_VDD6_1503 METAL6_2111600_1055700 METAL6_2111600_1067300 0.0232
R_VDD6_1504 METAL6_2111600_1067300 METAL6_2111600_1067700 0.0008
R_VDD6_1505 METAL6_2111600_1067700 METAL6_2111600_1079700 0.024
R_VDD6_1506 METAL6_2111600_1079700 METAL6_2111600_1128600 0.0978
R_VDD6_1507 METAL6_2111600_1128600 METAL6_2111600_1140600 0.024
R_VDD6_1508 METAL6_2111600_1140600 METAL6_2111600_1152600 0.024
R_VDD6_1509 METAL6_2111600_1152600 METAL6_2111600_1164600 0.024
R_VDD6_1510 METAL6_2111600_1164600 METAL6_2111600_1176600 0.024
R_VDD6_1511 METAL6_2111600_1176600 METAL6_2111600_1236400 0.1196
R_VDD6_1512 METAL6_2111600_1236400 METAL6_2111600_1243400 0.014
R_VDD6_1513 METAL6_2111600_1243400 METAL6_2111600_1255400 0.024
R_VDD6_1514 METAL6_2111600_1255400 METAL6_2111600_1267400 0.024
R_VDD6_1515 METAL6_2111600_1267400 METAL5_2111600_1267400 0.1
R_VDD6_1516 METAL5_2111600_1267400 METAL5_2105000_1267400 0.0264
R_VDD6_1517 METAL5_2105000_1267400 METAL5_2099600_1267400 0.0216
R_VDD6_1518 METAL5_2099600_1267400 METAL5_2093000_1267400 0.0264
R_VDD6_1519 METAL5_2093000_1267400 METAL5_2087600_1267400 0.0216
R_VDD6_1520 METAL5_2087600_1267400 METAL5_2081000_1267400 0.0264
R_VDD6_1521 METAL5_2081000_1267400 METAL5_2075600_1267400 0.0216
R_VDD6_1522 METAL5_2075600_1267400 METAL5_2063600_1267400 0.048
R_VDD6_1523 METAL5_2063600_1267400 METAL5_2051600_1267400 0.048
R_VDD6_1524 METAL5_2051600_1267400 METAL5_2046900_1267400 0.0188
R_VDD6_1525 METAL5_2046900_1267400 METAL5_2043900_1267400 0.012
R_VDD6_1526 METAL5_2043900_1267400 METAL5_2039600_1267400 0.0172
R_VDD6_1527 METAL5_2039600_1267400 METAL5_2031900_1267400 0.0308
R_VDD6_1528 METAL5_2031900_1267400 METAL5_2024000_1267400 0.0316
R_VDD6_1529 METAL5_2024000_1267400 METAL5_2019900_1267400 0.0164
R_VDD6_1530 METAL5_2019900_1267400 METAL5_2012000_1267400 0.0316
R_VDD6_1531 METAL5_2012000_1267400 METAL5_2007900_1267400 0.0164
R_VDD6_1532 METAL5_2007900_1267400 METAL6_2007900_1267400 0.1
R_VDD6_1533 METAL6_2007900_1267400 METAL6_2000000_1267400 0.0158
R_VDD6_1534 METAL6_2000000_1267400 METAL6_1995900_1267400 0.0082
R_VDD6_1535 METAL6_1995900_1267400 METAL6_1994500_1267400 0.0028
R_VDD6_1536 METAL6_1994500_1267400 METAL6_1988000_1267400 0.013
R_VDD6_1537 METAL6_1988000_1267400 METAL6_1843600_1267400 0.2888
R_VDD6_1538 METAL6_1843600_1267400 METAL6_1838900_1267400 0.0094
R_VDD6_1539 METAL6_1838900_1267400 METAL6_1831600_1267400 0.0146
R_VDD6_1540 METAL6_1831600_1267400 METAL6_1826900_1267400 0.0094
R_VDD6_1541 METAL6_1826900_1267400 METAL6_1819600_1267400 0.0146
R_VDD6_1542 METAL6_1819600_1267400 METAL6_1819600_1255400 0.024
R_VDD6_1543 METAL6_1819600_1255400 METAL6_1814900_1255400 0.0094
R_VDD6_1544 METAL6_1814900_1255400 METAL6_1802900_1255400 0.024
R_VDD6_1545 METAL6_1802900_1255400 METAL6_1799900_1255400 0.006
R_VDD6_1546 METAL6_1799900_1255400 METAL6_1787900_1255400 0.024
R_VDD6_1547 METAL6_1787900_1255400 METAL6_1775900_1255400 0.024
R_VDD6_1548 METAL6_1775900_1255400 METAL6_1774500_1255400 0.0028
R_VDD6_1549 METAL6_1774500_1255400 METAL6_1762500_1255400 0.024
R_VDD6_1550 METAL6_1762500_1255400 METAL6_1750500_1255400 0.024
R_VDD6_1551 METAL6_1750500_1255400 METAL6_1655600_1255400 0.1898
R_VDD6_1552 METAL6_1655600_1255400 METAL6_1643600_1255400 0.024
R_VDD6_1553 METAL6_1643600_1255400 METAL6_1631600_1255400 0.024
R_VDD6_1554 METAL6_1614900_853400 METAL6_1614900_841400 0.024
R_VDD6_1555 METAL6_2000000_8000 METAL6_2007900_8000 0.0158
R_VDD6_1556 METAL6_2007900_8000 METAL6_2012000_8000 0.0082
R_VDD6_1557 METAL6_2012000_8000 METAL6_2012000_20000 0.024
R_VDD6_1558 METAL6_2012000_20000 METAL6_2012000_69500 0.099
R_VDD6_1559 METAL6_2012000_69500 METAL6_2012000_126800 0.1146
R_VDD6_1560 METAL6_2012000_126800 METAL6_2012000_138800 0.024
R_VDD6_1561 METAL6_2012000_138800 METAL6_2012000_150800 0.024
R_VDD6_1562 METAL6_2012000_150800 METAL6_2012000_162800 0.024
R_VDD6_1563 METAL6_2012000_162800 METAL6_2019900_162800 0.0158
R_VDD6_1564 METAL6_2019900_162800 METAL5_2019900_162800 0.1
R_VDD6_1565 METAL5_2019900_162800 METAL5_2019900_174800 0.048
R_VDD6_1566 METAL5_2019900_174800 METAL5_2019900_181800 0.028
R_VDD6_1567 METAL5_2019900_181800 METAL5_2019900_186800 0.02
R_VDD6_1568 METAL5_2019900_186800 METAL6_2019900_186800 0.1
R_VDD6_1569 METAL6_2019900_186800 METAL6_2019900_193800 0.014
R_VDD6_1570 METAL6_2019900_193800 METAL6_2019900_198800 0.01
R_VDD6_1571 METAL6_2019900_198800 METAL6_2019900_205800 0.014
R_VDD6_1572 METAL6_2019900_205800 METAL6_2019900_211300 0.011
R_VDD6_1573 METAL6_2019900_211300 METAL6_2019900_223300 0.024
R_VDD6_1574 METAL6_2019900_223300 METAL6_2019900_235300 0.024
R_VDD6_1575 METAL6_2019900_235300 METAL6_2019900_242300 0.014
R_VDD6_1576 METAL6_2019900_242300 METAL6_2019900_247300 0.01
R_VDD6_1577 METAL6_2019900_247300 METAL6_2019900_363700 0.2328
R_VDD6_1578 METAL6_2019900_363700 METAL6_2024000_363700 0.0082
R_VDD6_1579 METAL6_2024000_363700 METAL6_2031900_363700 0.0158
R_VDD6_1580 METAL6_2031900_363700 METAL6_2039600_363700 0.0154
R_VDD6_1581 METAL6_2039600_363700 METAL6_2043900_363700 0.0086
R_VDD6_1582 METAL6_2043900_363700 METAL6_2046900_363700 0.006
R_VDD6_1583 METAL6_2046900_363700 METAL6_2051600_363700 0.0094
R_VDD6_1584 METAL6_2051600_363700 METAL6_2063600_363700 0.024
R_VDD6_1585 METAL6_2063600_363700 METAL6_2075600_363700 0.024
R_VDD6_1586 METAL6_2075600_363700 METAL6_2081000_363700 0.0108
R_VDD6_1587 METAL6_2081000_363700 METAL6_2087600_363700 0.0132
R_VDD6_1588 METAL6_2087600_363700 METAL6_2093000_363700 0.0108
R_VDD6_1589 METAL6_2093000_363700 METAL6_2099600_363700 0.0132
R_VDD6_1590 METAL6_2099600_363700 METAL6_2105000_363700 0.0108
R_VDD6_1591 METAL6_2105000_363700 METAL6_2111600_363700 0.0132
R_VDD6_1592 METAL6_2111600_363700 METAL6_2117000_363700 0.0108
R_VDD6_1593 METAL6_2117000_363700 METAL6_2123600_363700 0.0132
R_VDD6_1594 METAL6_2123600_363700 METAL6_2129000_363700 0.0108
R_VDD6_1595 METAL6_2129000_363700 METAL6_2129000_375700 0.024
R_VDD6_1596 METAL6_2129000_375700 METAL5_2129000_375700 0.1
R_VDD6_1597 METAL5_2129000_375700 METAL5_2129000_376800 0.0044
R_VDD6_1598 METAL5_2129000_376800 METAL5_2129000_387700 0.0436
R_VDD6_1599 METAL5_2129000_387700 METAL5_2129000_388800 0.0044
R_VDD6_1600 METAL5_2129000_388800 METAL5_2129000_399700 0.0436
R_VDD6_1601 METAL5_2129000_399700 METAL5_2129000_400800 0.0044
R_VDD6_1602 METAL5_2129000_400800 METAL5_2129000_411700 0.0436
R_VDD6_1603 METAL5_2129000_411700 METAL5_2129000_423700 0.048
R_VDD6_1604 METAL5_2129000_423700 METAL6_2129000_423700 0.1
R_VDD6_1605 METAL6_2129000_423700 METAL6_2129000_435700 0.024
R_VDD6_1606 METAL6_2129000_435700 METAL6_2129000_437300 0.0032
R_VDD6_1607 METAL6_2129000_437300 METAL6_2129000_447200 0.0198
R_VDD6_1608 METAL6_2129000_447200 METAL6_2129000_447700 0.001
R_VDD6_1609 METAL6_2129000_447700 METAL6_2129000_454700 0.014
R_VDD6_1610 METAL6_2129000_454700 METAL6_2129000_459700 0.01
R_VDD6_1611 METAL6_2129000_459700 METAL6_2129000_489500 0.0596
R_VDD6_1612 METAL6_2129000_489500 METAL6_2129000_501500 0.024
R_VDD6_1613 METAL6_2129000_501500 METAL6_2129000_510000 0.017
R_VDD6_1614 METAL6_2129000_510000 METAL6_2129000_513500 0.007
R_VDD6_1615 METAL6_2129000_513500 METAL6_2129000_522000 0.017
R_VDD6_1616 METAL6_2129000_522000 METAL6_2129000_534000 0.024
R_VDD6_1617 METAL6_2129000_534000 METAL6_2129000_541000 0.014
R_VDD6_1618 METAL6_2129000_541000 METAL6_2129000_583500 0.085
R_VDD6_1619 METAL6_2129000_583500 METAL6_2129000_637700 0.1084
R_VDD6_1620 METAL6_2129000_637700 METAL6_2129000_642200 0.009
R_VDD6_1621 METAL6_2129000_642200 METAL6_2129000_649200 0.014
R_VDD6_1622 METAL6_2129000_649200 METAL6_2129000_649700 0.001
R_VDD6_1623 METAL6_2129000_649700 METAL5_2129000_649700 0.1
R_VDD6_1624 METAL5_2129000_649700 METAL5_2123600_649700 0.0216
R_VDD6_1625 METAL5_2123600_649700 METAL5_2117000_649700 0.0264
R_VDD6_1626 METAL5_2117000_649700 METAL5_2111600_649700 0.0216
R_VDD6_1627 METAL5_2111600_649700 METAL5_2105000_649700 0.0264
R_VDD6_1628 METAL5_2105000_649700 METAL5_2099600_649700 0.0216
R_VDD6_1629 METAL5_2099600_649700 METAL5_2093000_649700 0.0264
R_VDD6_1630 METAL5_2093000_649700 METAL5_2087600_649700 0.0216
R_VDD6_1631 METAL5_2087600_649700 METAL5_2081000_649700 0.0264
R_VDD6_1632 METAL5_2081000_649700 METAL5_2075600_649700 0.0216
R_VDD6_1633 METAL5_2075600_649700 METAL5_2063600_649700 0.048
R_VDD6_1634 METAL5_2063600_649700 METAL5_2051600_649700 0.048
R_VDD6_1635 METAL5_2051600_649700 METAL6_2051600_649700 0.1
R_VDD6_1636 METAL6_2051600_649700 METAL6_2051600_658600 0.0178
R_VDD6_1637 METAL6_2051600_658600 METAL6_2046900_658600 0.0094
R_VDD6_1638 METAL6_2046900_658600 METAL6_2043900_658600 0.006
R_VDD6_1639 METAL6_2043900_658600 METAL6_2039600_658600 0.0086
R_VDD6_1640 METAL6_2039600_658600 METAL6_2031900_658600 0.0154
R_VDD6_1641 METAL6_2031900_658600 METAL6_2024000_658600 0.0158
R_VDD6_1642 METAL6_2024000_658600 METAL6_2019900_658600 0.0082
R_VDD6_1643 METAL6_2019900_658600 METAL6_2012000_658600 0.0158
R_VDD6_1644 METAL6_2012000_658600 METAL6_2007900_658600 0.0082
R_VDD6_1645 METAL6_2007900_658600 METAL6_2000000_658600 0.0158
R_VDD6_1646 METAL6_2000000_658600 METAL6_1995900_658600 0.0082
R_VDD6_1647 METAL6_1995900_658600 METAL6_1995900_661200 0.0052
R_VDD6_1648 METAL6_1995900_661200 METAL6_1994500_661200 0.0028
R_VDD6_1649 METAL6_1994500_661200 METAL6_1988000_661200 0.013
R_VDD6_1650 METAL6_1988000_661200 METAL6_1843600_661200 0.2888
R_VDD6_1651 METAL6_1843600_661200 METAL6_1838900_661200 0.0094
R_VDD6_1652 METAL6_1838900_661200 METAL6_1831600_661200 0.0146
R_VDD6_1653 METAL6_1831600_661200 METAL6_1826900_661200 0.0094
R_VDD6_1654 METAL6_1826900_661200 METAL6_1819600_661200 0.0146
R_VDD6_1655 METAL6_1819600_661200 METAL6_1814900_661200 0.0094
R_VDD6_1656 METAL6_1814900_661200 METAL6_1807600_661200 0.0146
R_VDD6_1657 METAL6_1807600_661200 METAL6_1802900_661200 0.0094
R_VDD6_1658 METAL6_1802900_661200 METAL6_1799900_661200 0.006
R_VDD6_1659 METAL6_1799900_661200 METAL6_1787900_661200 0.024
R_VDD6_1660 METAL6_1787900_661200 METAL6_1775900_661200 0.024
R_VDD6_1661 METAL6_1775900_661200 METAL6_1774500_661200 0.0028
R_VDD6_1662 METAL6_1774500_661200 METAL6_1762500_661200 0.024
R_VDD6_1663 METAL6_1762500_661200 METAL6_1750500_661200 0.024
R_VDD6_1664 METAL6_1750500_661200 METAL6_1655600_661200 0.1898
R_VDD6_1665 METAL6_1655600_661200 METAL6_1643600_661200 0.024
R_VDD6_1666 METAL6_1643600_661200 METAL6_1631600_661200 0.024
R_VDD6_1667 METAL6_1631600_661200 METAL6_1626900_661200 0.0094
R_VDD6_1668 METAL6_1626900_661200 METAL6_1622500_661200 0.0088
R_VDD6_1669 METAL6_1622500_661200 METAL6_1619600_661200 0.0058
R_VDD6_1670 METAL6_1619600_661200 METAL6_1614900_661200 0.0094
R_VDD6_1671 METAL6_1614900_661200 METAL6_1614900_661700 0.001
R_VDD6_1672 METAL6_1614900_661700 METAL6_1614900_673200 0.023
R_VDD6_1673 METAL6_1614900_673200 METAL6_1614900_673700 0.001
R_VDD6_1674 METAL6_1614900_673700 METAL6_1614900_736000 0.1246
R_VDD6_1675 METAL6_1614900_736000 METAL6_1614900_793300 0.1146
R_VDD6_1676 METAL6_1614900_793300 METAL6_1614900_805300 0.024
R_VDD6_1677 METAL6_1614900_805300 METAL6_1614900_805400 0.0002
R_VDD6_1678 METAL6_1614900_805400 METAL6_1614900_817300 0.0238
R_VDD6_1679 METAL6_1614900_817300 METAL6_1614900_817400 0.0002
R_VDD6_1680 METAL6_1614900_817400 METAL5_1614900_817400 0.1
R_VDD6_1681 METAL5_1614900_817400 METAL5_1614900_829300 0.0476
R_VDD6_1682 METAL5_1614900_829300 METAL5_1614900_829400 0.0004
R_VDD6_1683 METAL5_1614900_829400 METAL5_1614900_841300 0.0476
R_VDD6_1684 METAL5_1614900_841300 METAL5_1614900_841400 0.0004
R_VDD6_1685 METAL5_1614900_841400 METAL6_1614900_841400 0.1
R_VDD6_1686 METAL6_1511000_447700 METAL6_1511000_447200 0.001
R_VDD6_1687 METAL6_1511000_447200 METAL6_1511000_437300 0.0198
R_VDD6_1688 METAL6_1511000_437300 METAL6_1511000_435700 0.0032
R_VDD6_1689 METAL6_2075600_363700 METAL6_2075600_351700 0.024
R_VDD6_1690 METAL6_2075600_351700 METAL6_2063600_351700 0.024
R_VDD6_1691 METAL6_2063600_351700 METAL6_2051600_351700 0.024
R_VDD6_1692 METAL6_2051600_351700 METAL6_2046900_351700 0.0094
R_VDD6_1693 METAL6_2046900_351700 METAL6_2043900_351700 0.006
R_VDD6_1694 METAL6_2043900_351700 METAL6_2039600_351700 0.0086
R_VDD6_1695 METAL6_2039600_351700 METAL6_2031900_351700 0.0154
R_VDD6_1696 METAL6_2031900_351700 METAL5_2031900_351700 0.1
R_VDD6_1697 METAL5_2031900_351700 METAL5_2024000_351700 0.0316
R_VDD6_1698 METAL5_2024000_351700 METAL5_2019900_351700 0.0164
R_VDD6_1699 METAL5_2019900_351700 METAL5_2012000_351700 0.0316
R_VDD6_1700 METAL5_2012000_351700 METAL5_2007900_351700 0.0164
R_VDD6_1701 METAL5_2007900_351700 METAL5_2000000_351700 0.0316
R_VDD6_1702 METAL5_2000000_351700 METAL5_1995900_351700 0.0164
R_VDD6_1703 METAL5_1995900_351700 METAL6_1995900_351700 0.1
R_VDD6_1704 METAL6_1995900_351700 METAL6_1995900_363700 0.024
R_VDD6_1705 METAL6_1995900_363700 METAL6_1995900_375700 0.024
R_VDD6_1706 METAL6_1995900_375700 METAL6_1994500_375700 0.0028
R_VDD6_1707 METAL6_1994500_375700 METAL6_1988000_375700 0.013
R_VDD6_1708 METAL6_1988000_375700 METAL6_1983900_375700 0.0082
R_VDD6_1709 METAL6_1983900_375700 METAL6_1843600_375700 0.2806
R_VDD6_1710 METAL6_1843600_375700 METAL6_1838900_375700 0.0094
R_VDD6_1711 METAL6_1838900_375700 METAL6_1831600_375700 0.0146
R_VDD6_1712 METAL6_1831600_375700 METAL6_1826900_375700 0.0094
R_VDD6_1713 METAL6_1826900_375700 METAL6_1819600_375700 0.0146
R_VDD6_1714 METAL6_1819600_375700 METAL6_1814900_375700 0.0094
R_VDD6_1715 METAL6_1814900_375700 METAL6_1807600_375700 0.0146
R_VDD6_1716 METAL6_1807600_375700 METAL6_1802900_375700 0.0094
R_VDD6_1717 METAL6_1802900_375700 METAL6_1799900_375700 0.006
R_VDD6_1718 METAL6_1799900_375700 METAL6_1787900_375700 0.024
R_VDD6_1719 METAL6_1787900_375700 METAL6_1775900_375700 0.024
R_VDD6_1720 METAL6_1775900_375700 METAL6_1774500_375700 0.0028
R_VDD6_1721 METAL6_1774500_375700 METAL6_1762500_375700 0.024
R_VDD6_1722 METAL6_1762500_375700 METAL6_1750500_375700 0.024
R_VDD6_1723 METAL6_1750500_375700 METAL6_1655600_375700 0.1898
R_VDD6_1724 METAL6_1655600_375700 METAL6_1643600_375700 0.024
R_VDD6_1725 METAL6_1643600_375700 METAL6_1631600_375700 0.024
R_VDD6_1726 METAL6_1631600_375700 METAL6_1626900_375700 0.0094
R_VDD6_1727 METAL6_1626900_375700 METAL6_1622500_375700 0.0088
R_VDD6_1728 METAL6_1622500_375700 METAL5_1622500_375700 0.1
R_VDD6_1729 METAL5_1622500_375700 METAL5_1619600_375700 0.0116
R_VDD6_1730 METAL5_1619600_375700 METAL5_1614900_375700 0.0188
R_VDD6_1731 METAL5_1614900_375700 METAL5_1610500_375700 0.0176
R_VDD6_1732 METAL5_1610500_375700 METAL5_1602900_375700 0.0304
R_VDD6_1733 METAL5_1602900_375700 METAL5_1599900_375700 0.012
R_VDD6_1734 METAL5_1599900_375700 METAL5_1598500_375700 0.0056
R_VDD6_1735 METAL5_1598500_375700 METAL5_1587900_375700 0.0424
R_VDD6_1736 METAL5_1587900_375700 METAL5_1586500_375700 0.0056
R_VDD6_1737 METAL5_1586500_375700 METAL5_1575900_375700 0.0424
R_VDD6_1738 METAL5_1575900_375700 METAL5_1574500_375700 0.0056
R_VDD6_1739 METAL5_1574500_375700 METAL5_1562500_375700 0.048
R_VDD6_1740 METAL5_1562500_375700 METAL5_1550500_375700 0.048
R_VDD6_1741 METAL5_1550500_375700 METAL5_1538500_375700 0.048
R_VDD6_1742 METAL5_1538500_375700 METAL5_1538500_376800 0.0044
R_VDD6_1743 METAL5_1538500_376800 METAL5_1538500_387700 0.0436
R_VDD6_1744 METAL5_1538500_387700 METAL5_1538500_388800 0.0044
R_VDD6_1745 METAL5_1538500_388800 METAL5_1538500_399700 0.0436
R_VDD6_1746 METAL5_1538500_399700 METAL5_1538500_400800 0.0044
R_VDD6_1747 METAL5_1538500_400800 METAL5_1538500_411700 0.0436
R_VDD6_1748 METAL5_1538500_411700 METAL5_1538500_423700 0.048
R_VDD6_1749 METAL5_1538500_423700 METAL5_1538500_435700 0.048
R_VDD6_1750 METAL5_1538500_435700 METAL6_1538500_435700 0.1
R_VDD6_1751 METAL6_1538500_435700 METAL6_1536000_435700 0.005
R_VDD6_1752 METAL6_1536000_435700 METAL6_1535000_435700 0.002
R_VDD6_1753 METAL6_1535000_435700 METAL6_1524000_435700 0.022
R_VDD6_1754 METAL6_1524000_435700 METAL6_1523000_435700 0.002
R_VDD6_1755 METAL6_1523000_435700 METAL6_1512000_435700 0.022
R_VDD6_1756 METAL6_1512000_435700 METAL6_1511000_435700 0.002
I_VDD6_17 METAL6_1562500_1773100 gnd 0.006
I_VDD6_18 METAL6_1587900_1383100 gnd 0.006
I_VDD6_19 METAL6_1631600_1243400 gnd 0.006
I_VDD6_20 METAL6_1614900_853400 gnd 0.006
I_VDD6_21 METAL6_1511000_447700 gnd 0.006

.tran 1ns 1ns
.end
