#Comments
RVDD1_1 METAL5_196700_26000 METAL5_2217000_26000 40.406
RVDD1_2 METAL6_196700_0 METAL6_196700_26000 0.26
RVDD1_3 METAL5_2217000_1346000 METAL5_2295000_1373300 1.56
RVDD1_4 METAL5_2217000_26000 METAL5_2217000_1346000 26.4
RVDD1_5 METAL5_196700_26000 METAL6_196700_26000 10
V_VDD1_1 METAL6_196700_0 gnd 1.0
IVDD1_1 METAL5_2295000_1373300 gnd 0.005000

RVDD2_1 METAL5_500000_46900 METAL5_2148900_46900 13.1912
RVDD2_2 METAL6_500000_0 METAL6_500000_46900 0.1876
RVDD2_3 METAL5_2148900_1539100 METAL5_2295000_1563300 1.1688
RVDD2_4 METAL5_2148900_46900 METAL5_2148900_1539100 11.9376
RVDD2_5 METAL5_500000_46900 METAL6_500000_46900 5
V_VDD2_1 METAL6_500000_0 gnd 1.2
IVDD2_1 METAL5_2295000_1563300 gnd 0.002000

RVDD3_1 METAL5_636200_526500 METAL5_926000_503700 2.3184
RVDD3_2 METAL5_700000_1165600 METAL5_886600_1147300 1.4928
RVDD3_3 METAL5_767300_1475000 METAL5_886600_1462800 0.9544
RVDD3_4 METAL6_785800_685500 METAL6_926000_685500 0.5608
RVDD3_5 METAL6_785800_1074300 METAL6_886600_1074300 0.4032
RVDD3_6 METAL6_785800_685500 METAL6_785800_1074300 1.5552
RVDD3_7 METAL6_795400_71300 METAL6_1000000_71300 0.8184
RVDD3_8 METAL6_795400_305200 METAL6_926000_305200 0.5224
RVDD3_9 METAL6_795400_71300 METAL6_795400_305200 0.9356
RVDD3_10 METAL6_886600_1074300 METAL6_886600_1147300 0.292
RVDD3_11 METAL6_886600_1147300 METAL6_886600_1462800 1.262
RVDD3_12 METAL6_926000_305200 METAL6_926000_503700 0.794
RVDD3_13 METAL6_926000_503700 METAL6_926000_685500 0.7272
RVDD3_14 METAL6_1000000_0 METAL6_1000000_71300 0.2852
RVDD3_15 METAL5_886600_1462800 METAL6_886600_1462800 5
RVDD3_16 METAL5_886600_1147300 METAL6_886600_1147300 5
RVDD3_17 METAL5_926000_503700 METAL6_926000_503700 5
V_VDD3_1 METAL6_1000000_0 gnd 1.0
IVDD3_1 METAL5_700000_1165600 gnd 0.004000
IVDD3_2 METAL5_767300_1475000 gnd 0.004000
IVDD3_3 METAL5_636200_526500 gnd 0.010000

RVDD4_1 METAL1_1197500_88100 METAL1_2691600_88100 23.9056
RVDD4_2 METAL1_2691600_88100 METAL1_2989900_88100 4.7728
RVDD4_3 METAL1_2989900_88100 METAL1_3352500_88100 5.8016
RVDD4_4 METAL6_1197500_0 METAL6_1197500_88100 0.3524
RVDD4_5 METAL1_2425600_768600 METAL1_3352500_768600 14.8304
RVDD4_6 METAL1_2454100_1113400 METAL1_2830700_1113400 6.0256
RVDD4_7 METAL1_2830700_1113400 METAL1_3352500_1113400 8.3488
RVDD4_8 METAL4_2440700_654200 METAL4_2425600_768600 1.8304
RVDD4_9 METAL4_2477500_1060700 METAL4_2454100_1113400 0.8432
RVDD4_10 METAL4_2691600_88100 METAL4_2704300_186800 1.5792
RVDD4_11 METAL4_2856800_1048300 METAL4_2830700_1113400 1.0416
RVDD4_12 METAL1_3152900_458400 METAL1_3352500_458400 3.1936
RVDD4_13 METAL4_2989900_88100 METAL4_3026800_235300 2.3552
RVDD4_14 METAL4_3152900_458400 METAL4_3171300_534000 1.2096
RVDD4_15 METAL1_3352500_88100 METAL1_3352500_458400 5.9248
RVDD4_16 METAL1_3352500_458400 METAL1_3352500_768600 4.9632
RVDD4_17 METAL1_3352500_768600 METAL1_3352500_1113400 5.5168
RVDD4_18 METAL1_2454100_1113400 METAL2_2454100_1113400 5
RVDD4_19 METAL1_2830700_1113400 METAL2_2830700_1113400 5
RVDD4_20 METAL1_2425600_768600 METAL2_2425600_768600 5
RVDD4_21 METAL1_3152900_458400 METAL2_3152900_458400 5
RVDD4_22 METAL1_2989900_88100 METAL2_2989900_88100 5
RVDD4_23 METAL1_2691600_88100 METAL2_2691600_88100 5
RVDD4_24 METAL1_1197500_88100 METAL2_1197500_88100 5
RVDD4_25 METAL2_2454100_1113400 METAL3_2454100_1113400 5
RVDD4_26 METAL2_2830700_1113400 METAL3_2830700_1113400 5
RVDD4_27 METAL2_3152900_458400 METAL3_3152900_458400 5
RVDD4_28 METAL2_2691600_88100 METAL3_2691600_88100 5
RVDD4_29 METAL2_2989900_88100 METAL3_2989900_88100 5
RVDD4_30 METAL2_2425600_768600 METAL3_2425600_768600 5
RVDD4_31 METAL2_1197500_88100 METAL3_1197500_88100 5
RVDD4_32 METAL3_2454100_1113400 METAL4_2454100_1113400 5
RVDD4_33 METAL3_2830700_1113400 METAL4_2830700_1113400 5
RVDD4_34 METAL3_2425600_768600 METAL4_2425600_768600 5
RVDD4_35 METAL3_3152900_458400 METAL4_3152900_458400 5
RVDD4_36 METAL3_2989900_88100 METAL4_2989900_88100 5
RVDD4_37 METAL3_2691600_88100 METAL4_2691600_88100 5
RVDD4_38 METAL3_1197500_88100 METAL4_1197500_88100 5
RVDD4_39 METAL4_1197500_88100 METAL5_1197500_88100 5
RVDD4_40 METAL5_1197500_88100 METAL6_1197500_88100 5
V_VDD4_1 METAL6_1197500_0 gnd 1.4
IVDD4_1 METAL4_2477500_1060700 gnd 0.004000
IVDD4_2 METAL4_2856800_1048300 gnd 0.005000
IVDD4_3 METAL4_3026800_235300 gnd 0.003000
IVDD4_4 METAL4_2704300_186800 gnd 0.005000
IVDD4_5 METAL4_3171300_534000 gnd 0.003000
IVDD4_6 METAL4_2440700_654200 gnd 0.004000

RVDD5_1 METAL6_931800_774400 METAL6_1035300_774400 0.414
RVDD5_2 METAL6_1035300_774400 METAL6_1303900_774400 1.0744
RVDD5_3 METAL6_931800_1352300 METAL6_1798500_1352300 3.4668
RVDD5_4 METAL6_1798500_1352300 METAL6_1829500_1352300 0.124
RVDD5_5 METAL6_931800_1861600 METAL6_1761000_1861600 3.3168
RVDD5_6 METAL6_931800_774400 METAL6_931800_1352300 2.3116
RVDD5_7 METAL6_931800_1352300 METAL6_931800_1861600 2.0372
RVDD5_8 METAL6_1035300_300400 METAL6_1306600_300400 1.0852
RVDD5_9 METAL6_1306600_300400 METAL6_1497500_300400 0.7636
RVDD5_10 METAL6_1035300_300400 METAL6_1035300_774400 1.896
RVDD5_11 METAL6_1303900_799600 METAL6_1516300_799600 0.8496
RVDD5_12 METAL6_1303900_774400 METAL6_1303900_799600 0.1008
RVDD5_13 METAL6_1306600_300400 METAL6_1336000_447700 0.5892
RVDD5_14 METAL6_1497500_0 METAL6_1497500_300400 1.2016
RVDD5_15 METAL6_1516300_705900 METAL6_1813600_705900 1.1892
RVDD5_16 METAL6_1516300_705900 METAL6_1516300_799600 0.3748
RVDD5_17 METAL6_1787500_1778100 METAL6_1761000_1861600 0.334
RVDD5_18 METAL6_1798500_1352300 METAL6_1812900_1383100 0.1232
RVDD5_19 METAL6_1813600_705900 METAL6_1839900_853400 0.59
RVDD5_20 METAL6_1856600_1248400 METAL6_1829500_1352300 0.4156
V_VDD5_1 METAL6_1497500_0 gnd 1.0
IVDD5_1 METAL6_1787500_1778100 gnd 0.005000
IVDD5_2 METAL6_1856600_1248400 gnd 0.005000
IVDD5_3 METAL6_1812900_1383100 gnd 0.005000
IVDD5_4 METAL6_1839900_853400 gnd 0.005000
IVDD5_5 METAL6_1336000_447700 gnd 0.005000

RVDD6_1 METAL5_1506400_379200 METAL5_2000000_379200 3.9488
RVDD6_2 METAL5_2000000_379200 METAL5_2110500_379200 0.884
RVDD6_3 METAL5_1506400_379200 METAL5_1536000_447700 0.548
RVDD6_4 METAL5_1560000_1812600 METAL5_2110500_1812600 4.404
RVDD6_5 METAL5_1606500_1308300 METAL5_1639100_1308300 0.2608
RVDD6_6 METAL5_1639100_1308300 METAL5_2110500_1308300 3.7712
RVDD6_7 METAL5_1587500_1778100 METAL5_1560000_1812600 0.276
RVDD6_8 METAL5_1618700_777300 METAL5_2110500_777300 3.9344
RVDD6_9 METAL5_1606500_1308300 METAL5_1612900_1383100 0.5984
RVDD6_10 METAL5_1618700_777300 METAL5_1639900_853400 0.6088
RVDD6_11 METAL5_1656600_1248400 METAL5_1639100_1308300 0.4792
RVDD6_12 METAL6_2000000_0 METAL6_2000000_379200 1.5168
RVDD6_13 METAL6_2110500_379200 METAL6_2110500_777300 1.5924
RVDD6_14 METAL6_2110500_777300 METAL6_2110500_1308300 2.124
RVDD6_15 METAL6_2110500_1308300 METAL6_2110500_1812600 2.0172
RVDD6_16 METAL5_2110500_1308300 METAL6_2110500_1308300 5
RVDD6_17 METAL5_2110500_1812600 METAL6_2110500_1812600 5
RVDD6_18 METAL5_2110500_379200 METAL6_2110500_379200 5
RVDD6_19 METAL5_2000000_379200 METAL6_2000000_379200 5
RVDD6_20 METAL5_2110500_777300 METAL6_2110500_777300 5
V_VDD6_1 METAL6_2000000_0 gnd 1.6
IVDD6_1 METAL5_1587500_1778100 gnd
IVDD6_2 METAL5_1656600_1248400 gnd
IVDD6_3 METAL5_1612900_1383100 gnd 0.0060000.0060000.0060000.0060000.006000
IVDD6_4 METAL5_1639900_853400 gnd
IVDD6_5 METAL5_1536000_447700 gnd

.tran 1ns 1ns
.end
.control
set noaskquit
run
quit
.enddc
