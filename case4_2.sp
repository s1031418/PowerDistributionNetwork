#Comments
V_VDD1_1 METAL6_300000_0 gnd 1
R_VDD1_1 METAL6_300000_0 METAL6_300000_8000 0.016
R_VDD1_2 METAL6_300000_8000 METAL6_294000_8000 0.012
R_VDD1_3 METAL6_294000_8000 METAL6_293000_8000 0.002
R_VDD1_4 METAL6_293000_8000 METAL6_292000_8000 0.002
R_VDD1_5 METAL6_292000_8000 METAL6_290000_8000 0.004
R_VDD1_6 METAL6_290000_8000 METAL6_288000_8000 0.004
R_VDD1_7 METAL6_288000_8000 METAL6_282000_8000 0.012
R_VDD1_8 METAL6_282000_8000 METAL6_281000_8000 0.002
R_VDD1_9 METAL6_281000_8000 METAL6_280000_8000 0.002
R_VDD1_10 METAL6_280000_8000 METAL6_278000_8000 0.004
R_VDD1_11 METAL6_278000_8000 METAL6_276000_8000 0.004
R_VDD1_12 METAL6_276000_8000 METAL6_270000_8000 0.012
R_VDD1_13 METAL6_270000_8000 METAL6_270000_20000 0.024
R_VDD1_14 METAL6_270000_20000 METAL6_270000_32000 0.024
R_VDD1_15 METAL6_270000_32000 METAL6_270000_44000 0.024
R_VDD1_16 METAL6_270000_44000 METAL6_269000_44000 0.002
R_VDD1_17 METAL6_269000_44000 METAL6_266000_44000 0.006
R_VDD1_18 METAL6_266000_44000 METAL6_264000_44000 0.004
R_VDD1_19 METAL6_264000_44000 METAL6_258000_44000 0.012
R_VDD1_20 METAL6_258000_44000 METAL6_258000_45000 0.002
R_VDD1_21 METAL6_258000_45000 METAL6_258000_56000 0.022
R_VDD1_22 METAL6_258000_56000 METAL6_257000_56000 0.002
R_VDD1_23 METAL6_257000_56000 METAL6_257000_57000 0.002
R_VDD1_24 METAL6_257000_57000 METAL6_257000_68000 0.022
R_VDD1_25 METAL6_257000_68000 METAL6_257000_69000 0.002
R_VDD1_26 METAL6_257000_69000 METAL6_257000_80000 0.022
R_VDD1_27 METAL6_257000_80000 METAL6_257000_81000 0.002
R_VDD1_28 METAL6_257000_81000 METAL6_257000_92000 0.022
R_VDD1_29 METAL6_257000_92000 METAL6_257000_93000 0.002
R_VDD1_30 METAL6_257000_93000 METAL6_257000_105000 0.024
R_VDD1_31 METAL6_257000_105000 METAL6_257000_109000 0.008
R_VDD1_32 METAL6_257000_109000 METAL6_257000_117000 0.016
R_VDD1_33 METAL6_257000_117000 METAL6_257000_121000 0.008
R_VDD1_34 METAL6_257000_121000 METAL6_257000_129000 0.016
R_VDD1_35 METAL6_257000_129000 METAL6_257000_133000 0.008
R_VDD1_36 METAL6_257000_133000 METAL6_257000_141000 0.016
R_VDD1_37 METAL6_257000_141000 METAL6_257000_145000 0.008
R_VDD1_38 METAL6_257000_145000 METAL6_257000_153000 0.016
R_VDD1_39 METAL6_257000_153000 METAL5_257000_153000 0.1
R_VDD1_40 METAL5_257000_153000 METAL4_257000_153000 0.1
R_VDD1_41 METAL4_257000_153000 METAL3_257000_153000 0.1
R_VDD1_42 METAL3_257000_153000 METAL3_258000_153000 0.008
R_VDD1_43 METAL3_258000_153000 METAL3_264000_153000 0.048
R_VDD1_44 METAL3_264000_153000 METAL3_266000_153000 0.016
R_VDD1_45 METAL3_266000_153000 METAL3_269000_153000 0.024
R_VDD1_46 METAL3_269000_153000 METAL3_269000_157000 0.032
R_VDD1_47 METAL3_269000_157000 METAL3_269000_165000 0.064
R_VDD1_48 METAL3_269000_165000 METAL3_269000_169000 0.032
R_VDD1_49 METAL3_269000_169000 METAL3_269000_177000 0.064
R_VDD1_50 METAL3_269000_177000 METAL3_269000_181000 0.032
R_VDD1_51 METAL3_269000_181000 METAL3_269000_193000 0.096
R_VDD1_52 METAL3_269000_193000 METAL3_269000_205000 0.096
R_VDD1_53 METAL3_269000_205000 METAL3_269000_217000 0.096
R_VDD1_54 METAL3_269000_217000 METAL3_269000_229000 0.096
R_VDD1_55 METAL3_269000_229000 METAL3_269000_233000 0.032
R_VDD1_56 METAL3_269000_233000 METAL3_269000_241000 0.064
R_VDD1_57 METAL3_269000_241000 METAL3_269000_245000 0.032
R_VDD1_58 METAL3_269000_245000 METAL3_269000_253000 0.064
R_VDD1_59 METAL3_269000_253000 METAL3_269000_257000 0.032
R_VDD1_60 METAL3_269000_257000 METAL3_269000_265000 0.064
R_VDD1_61 METAL3_269000_265000 METAL3_269000_269000 0.032
R_VDD1_62 METAL3_269000_269000 METAL3_269000_277000 0.064
R_VDD1_63 METAL3_269000_277000 METAL3_269000_281000 0.032
R_VDD1_64 METAL3_269000_281000 METAL3_269000_289000 0.064
R_VDD1_65 METAL3_269000_289000 METAL3_269000_293000 0.032
R_VDD1_66 METAL3_269000_293000 METAL3_269000_301000 0.064
R_VDD1_67 METAL3_269000_301000 METAL3_269000_305000 0.032
R_VDD1_68 METAL3_269000_305000 METAL3_269000_313000 0.064
R_VDD1_69 METAL3_269000_313000 METAL3_269000_317000 0.032
R_VDD1_70 METAL3_269000_317000 METAL3_269000_329000 0.096
R_VDD1_71 METAL3_269000_329000 METAL3_269000_341000 0.096
R_VDD1_72 METAL3_269000_341000 METAL3_269000_353000 0.096
R_VDD1_73 METAL3_269000_353000 METAL3_269000_365000 0.096
R_VDD1_74 METAL3_269000_365000 METAL3_269000_377000 0.096
R_VDD1_75 METAL3_269000_377000 METAL3_269000_381000 0.032
R_VDD1_76 METAL3_269000_381000 METAL3_269000_389000 0.064
R_VDD1_77 METAL3_269000_389000 METAL3_269000_393000 0.032
R_VDD1_78 METAL3_269000_393000 METAL3_269000_401000 0.064
R_VDD1_79 METAL3_269000_401000 METAL3_269000_405000 0.032
R_VDD1_80 METAL3_269000_405000 METAL3_269000_417000 0.096
R_VDD1_81 METAL3_269000_417000 METAL3_269000_429000 0.096
R_VDD1_82 METAL3_269000_429000 METAL3_269000_441000 0.096
R_VDD1_83 METAL3_269000_441000 METAL3_269000_453000 0.096
R_VDD1_84 METAL3_269000_453000 METAL3_269000_465000 0.096
R_VDD1_85 METAL3_269000_465000 METAL3_269000_469000 0.032
R_VDD1_86 METAL3_269000_469000 METAL3_269000_477000 0.064
R_VDD1_87 METAL3_269000_477000 METAL3_269000_481000 0.032
R_VDD1_88 METAL3_269000_481000 METAL3_269000_489000 0.064
R_VDD1_89 METAL3_269000_489000 METAL3_269000_493000 0.032
R_VDD1_90 METAL3_269000_493000 METAL3_269000_501000 0.064
R_VDD1_91 METAL3_269000_501000 METAL3_269000_505000 0.032
R_VDD1_92 METAL3_269000_505000 METAL3_269000_517000 0.096
R_VDD1_93 METAL3_269000_517000 METAL3_269000_529000 0.096
R_VDD1_94 METAL3_269000_529000 METAL3_270000_529000 0.008
R_VDD1_95 METAL3_270000_529000 METAL3_276000_529000 0.048
R_VDD1_96 METAL3_276000_529000 METAL3_278000_529000 0.016
R_VDD1_97 METAL3_278000_529000 METAL3_280000_529000 0.016
R_VDD1_98 METAL3_280000_529000 METAL3_281000_529000 0.008
R_VDD1_99 METAL3_281000_529000 METAL3_281000_541000 0.096
R_VDD1_100 METAL3_281000_541000 METAL3_281000_553000 0.096
R_VDD1_101 METAL3_281000_553000 METAL3_281000_565000 0.096
R_VDD1_102 METAL3_281000_565000 METAL3_281000_577000 0.096
R_VDD1_103 METAL3_281000_577000 METAL3_281000_589000 0.096
R_VDD1_104 METAL3_281000_589000 METAL3_281000_601000 0.096
R_VDD1_105 METAL3_281000_601000 METAL3_282000_601000 0.008
R_VDD1_106 METAL3_282000_601000 METAL3_288000_601000 0.048
R_VDD1_107 METAL3_288000_601000 METAL3_290000_601000 0.016
R_VDD1_108 METAL3_290000_601000 METAL3_292000_601000 0.016
R_VDD1_109 METAL3_292000_601000 METAL3_293000_601000 0.008
R_VDD1_110 METAL3_293000_601000 METAL3_294000_601000 0.008
R_VDD1_111 METAL3_294000_601000 METAL3_300000_601000 0.048
R_VDD1_112 METAL3_300000_601000 METAL3_302000_601000 0.016
R_VDD1_113 METAL3_302000_601000 METAL3_304000_601000 0.016
R_VDD1_114 METAL3_304000_601000 METAL3_305000_601000 0.008
R_VDD1_115 METAL3_305000_601000 METAL3_306000_601000 0.008
R_VDD1_116 METAL3_306000_601000 METAL3_312000_601000 0.048
R_VDD1_117 METAL3_312000_601000 METAL4_312000_601000 0.1
R_VDD1_118 METAL4_312000_601000 METAL5_312000_601000 0.1
R_VDD1_119 METAL5_312000_601000 METAL5_312000_613000 0.048
R_VDD1_120 METAL5_312000_613000 METAL5_312000_625000 0.048
R_VDD1_121 METAL5_312000_625000 METAL5_312000_681000 0.224
R_VDD1_122 METAL5_312000_681000 METAL5_312000_693000 0.048
R_VDD1_123 METAL5_312000_693000 METAL5_312000_705000 0.048
R_VDD1_124 METAL5_312000_705000 METAL5_312000_707000 0.008
R_VDD1_125 METAL5_312000_707000 METAL5_312000_717000 0.04
R_VDD1_126 METAL5_312000_717000 METAL5_312000_729000 0.048
R_VDD1_127 METAL5_312000_729000 METAL5_312000_757000 0.112
R_VDD1_128 METAL5_312000_757000 METAL5_312000_769000 0.048
R_VDD1_129 METAL5_312000_769000 METAL5_312000_781000 0.048
R_VDD1_130 METAL5_312000_781000 METAL5_312000_793000 0.048
R_VDD1_131 METAL5_312000_793000 METAL5_312000_805000 0.048
R_VDD1_132 METAL5_312000_805000 METAL4_312000_805000 0.1
R_VDD1_133 METAL4_312000_805000 METAL3_312000_805000 0.1
R_VDD1_134 METAL3_312000_805000 METAL3_312000_817000 0.096
R_VDD1_135 METAL3_312000_817000 METAL3_312000_829000 0.096
R_VDD1_136 METAL3_312000_829000 METAL3_312000_841000 0.096
R_VDD1_137 METAL3_312000_841000 METAL3_312000_853000 0.096
R_VDD1_138 METAL3_312000_853000 METAL3_306000_853000 0.048
R_VDD1_139 METAL3_306000_853000 METAL3_306000_857000 0.032
R_VDD1_140 METAL3_306000_857000 METAL3_306000_865000 0.064
R_VDD1_141 METAL3_306000_865000 METAL3_306000_869000 0.032
R_VDD1_142 METAL3_306000_869000 METAL3_306000_877000 0.064
R_VDD1_143 METAL3_306000_877000 METAL3_306000_881000 0.032
R_VDD1_144 METAL3_306000_881000 METAL3_306000_889000 0.064
R_VDD1_145 METAL3_306000_889000 METAL3_306000_893000 0.032
R_VDD1_146 METAL3_306000_893000 METAL3_306000_901000 0.064
R_VDD1_147 METAL3_306000_901000 METAL3_306000_905000 0.032
R_VDD1_148 METAL3_306000_905000 METAL3_306000_913000 0.064
R_VDD1_149 METAL3_306000_913000 METAL3_306000_917000 0.032
R_VDD1_150 METAL3_306000_917000 METAL3_306000_929000 0.096
R_VDD1_151 METAL3_306000_929000 METAL3_306000_941000 0.096
R_VDD1_152 METAL3_306000_941000 METAL3_306000_953000 0.096
R_VDD1_153 METAL3_306000_953000 METAL3_306000_965000 0.096
R_VDD1_154 METAL3_306000_965000 METAL3_306000_977000 0.096
R_VDD1_155 METAL3_306000_977000 METAL3_306000_989000 0.096
R_VDD1_156 METAL3_306000_989000 METAL3_306000_1001000 0.096
R_VDD1_157 METAL3_306000_1001000 METAL3_306000_1013000 0.096
R_VDD1_158 METAL3_306000_1013000 METAL3_306000_1025000 0.096
R_VDD1_159 METAL3_306000_1025000 METAL3_306000_1041000 0.128
R_VDD1_160 METAL3_306000_1041000 METAL3_306000_1053000 0.096
R_VDD1_161 METAL3_306000_1053000 METAL3_306000_1065000 0.096
R_VDD1_162 METAL3_306000_1065000 METAL3_306000_1077000 0.096
R_VDD1_163 METAL3_306000_1077000 METAL3_306000_1089000 0.096
R_VDD1_164 METAL3_306000_1089000 METAL3_305000_1089000 0.008
R_VDD1_165 METAL3_305000_1089000 METAL3_304000_1089000 0.008
R_VDD1_166 METAL3_304000_1089000 METAL3_302000_1089000 0.016
R_VDD1_167 METAL3_302000_1089000 METAL3_300000_1089000 0.016
R_VDD1_168 METAL3_300000_1089000 METAL3_294000_1089000 0.048
R_VDD1_169 METAL3_294000_1089000 METAL3_293000_1089000 0.008
R_VDD1_170 METAL3_293000_1089000 METAL3_292000_1089000 0.008
R_VDD1_171 METAL3_292000_1089000 METAL3_290000_1089000 0.016
R_VDD1_172 METAL3_290000_1089000 METAL3_288000_1089000 0.016
R_VDD1_173 METAL3_288000_1089000 METAL4_288000_1089000 0.1
R_VDD1_174 METAL4_288000_1089000 METAL5_288000_1089000 0.1
R_VDD1_175 METAL5_288000_1089000 METAL5_288000_1101000 0.048
R_VDD1_176 METAL5_288000_1101000 METAL5_288000_1113000 0.048
R_VDD1_177 METAL5_288000_1113000 METAL5_288000_1153000 0.16
R_VDD1_178 METAL5_288000_1153000 METAL5_288000_1165000 0.048
R_VDD1_179 METAL5_288000_1165000 METAL5_288000_1177000 0.048
R_VDD1_180 METAL5_288000_1177000 METAL5_288000_1189000 0.048
R_VDD1_181 METAL5_288000_1189000 METAL5_288000_1201000 0.048
R_VDD1_182 METAL5_288000_1201000 METAL5_288000_1205000 0.016
R_VDD1_183 METAL5_288000_1205000 METAL5_288000_1217000 0.048
R_VDD1_184 METAL5_288000_1217000 METAL5_288000_1229000 0.048
R_VDD1_185 METAL5_288000_1229000 METAL5_288000_1241000 0.048
R_VDD1_186 METAL5_288000_1241000 METAL5_288000_1253000 0.048
R_VDD1_187 METAL5_288000_1253000 METAL5_288000_1265000 0.048
R_VDD1_188 METAL5_288000_1265000 METAL5_290000_1265000 0.008
R_VDD1_189 METAL5_290000_1265000 METAL5_292000_1265000 0.008
R_VDD1_190 METAL5_292000_1265000 METAL5_293000_1265000 0.004
R_VDD1_191 METAL5_293000_1265000 METAL5_294000_1265000 0.004
R_VDD1_192 METAL5_294000_1265000 METAL5_300000_1265000 0.024
R_VDD1_193 METAL5_300000_1265000 METAL4_300000_1265000 0.1
R_VDD1_194 METAL4_300000_1265000 METAL4_300000_1277000 0.096
R_VDD1_195 METAL4_300000_1277000 METAL4_300000_1289000 0.096
R_VDD1_196 METAL4_300000_1289000 METAL4_300000_1301000 0.096
R_VDD1_197 METAL4_300000_1301000 METAL4_300000_1333000 0.256
R_VDD1_198 METAL4_300000_1333000 METAL4_300000_1345000 0.096
R_VDD1_199 METAL4_300000_1345000 METAL4_302000_1345000 0.016
R_VDD1_200 METAL4_302000_1345000 METAL4_302000_1357000 0.096
R_VDD1_201 METAL4_302000_1357000 METAL4_302000_1369000 0.096
R_VDD1_202 METAL4_302000_1369000 METAL4_302000_1381000 0.096
R_VDD1_203 METAL4_302000_1381000 METAL4_302000_1393000 0.096
R_VDD1_204 METAL4_302000_1393000 METAL4_304000_1393000 0.016
R_VDD1_205 METAL4_304000_1393000 METAL4_305000_1393000 0.008
R_VDD1_206 METAL4_305000_1393000 METAL4_305000_1405000 0.096
R_VDD1_207 METAL4_305000_1405000 METAL5_305000_1405000 0.1
R_VDD1_208 METAL5_305000_1405000 METAL5_305000_1407000 0.008
R_VDD1_209 METAL5_305000_1407000 METAL5_305000_1417000 0.04
R_VDD1_210 METAL5_305000_1417000 METAL5_305000_1429000 0.048
R_VDD1_211 METAL5_305000_1429000 METAL5_305000_1505000 0.304
R_VDD1_212 METAL5_305000_1505000 METAL5_305000_1517000 0.048
R_VDD1_213 METAL5_305000_1517000 METAL5_305000_1529000 0.048
R_VDD1_214 METAL5_305000_1529000 METAL5_305000_1541000 0.048
R_VDD1_215 METAL5_305000_1541000 METAL4_305000_1541000 0.1
R_VDD1_216 METAL4_305000_1541000 METAL4_305000_1553000 0.096
R_VDD1_217 METAL4_305000_1553000 METAL4_305000_1565000 0.096
R_VDD1_218 METAL4_305000_1565000 METAL5_305000_1565000 0.1
R_VDD1_219 METAL5_305000_1565000 METAL5_305000_1577000 0.048
R_VDD1_220 METAL5_305000_1577000 METAL5_305000_1589000 0.048
R_VDD1_221 METAL5_305000_1589000 METAL5_305000_1617000 0.112
R_VDD1_222 METAL5_305000_1617000 METAL5_306000_1617000 0.004
R_VDD1_223 METAL5_306000_1617000 METAL5_312000_1617000 0.024
R_VDD1_224 METAL5_312000_1617000 METAL5_314000_1617000 0.008
R_VDD1_225 METAL5_314000_1617000 METAL4_314000_1617000 0.1
R_VDD1_226 METAL4_314000_1617000 METAL3_314000_1617000 0.1
R_VDD1_227 METAL3_314000_1617000 METAL3_314000_1629000 0.096
R_VDD1_228 METAL3_314000_1629000 METAL3_314000_1641000 0.096
R_VDD1_229 METAL3_314000_1641000 METAL3_314000_1653000 0.096
R_VDD1_230 METAL3_314000_1653000 METAL3_314000_1665000 0.096
R_VDD1_231 METAL3_314000_1665000 METAL3_314000_1677000 0.096
R_VDD1_232 METAL3_314000_1677000 METAL3_314000_1689000 0.096
R_VDD1_233 METAL3_314000_1689000 METAL4_314000_1689000 0.1
R_VDD1_234 METAL4_314000_1689000 METAL4_314000_1701000 0.096
R_VDD1_235 METAL4_314000_1701000 METAL4_314000_1753000 0.416
R_VDD1_236 METAL4_314000_1753000 METAL4_314000_1765000 0.096
R_VDD1_237 METAL4_314000_1765000 METAL4_314000_1777000 0.096
R_VDD1_238 METAL4_314000_1777000 METAL4_314000_1789000 0.096
R_VDD1_239 METAL4_314000_1789000 METAL4_314000_1805000 0.128
R_VDD1_240 METAL4_314000_1805000 METAL4_316000_1805000 0.016
R_VDD1_241 METAL4_316000_1805000 METAL4_317000_1805000 0.008
R_VDD1_242 METAL4_317000_1805000 METAL4_317000_1817000 0.096
R_VDD1_243 METAL4_317000_1817000 METAL4_317000_1829000 0.096
R_VDD1_244 METAL4_317000_1829000 METAL4_317000_1841000 0.096
R_VDD1_245 METAL4_317000_1841000 METAL4_317000_1853000 0.096
R_VDD1_246 METAL4_317000_1853000 METAL4_317000_1865000 0.096
R_VDD1_247 METAL4_317000_1865000 METAL4_317000_1877000 0.096
R_VDD1_248 METAL4_317000_1877000 METAL4_317000_1905000 0.224
R_VDD1_249 METAL4_317000_1905000 METAL4_317000_1917000 0.096
R_VDD1_250 METAL4_317000_1917000 METAL4_318000_1917000 0.008
R_VDD1_251 METAL4_318000_1917000 METAL4_324000_1917000 0.048
R_VDD1_252 METAL4_324000_1917000 METAL4_326000_1917000 0.016
R_VDD1_253 METAL4_326000_1917000 METAL4_328000_1917000 0.016
R_VDD1_254 METAL4_328000_1917000 METAL4_330000_1917000 0.016
R_VDD1_255 METAL4_330000_1917000 METAL4_336000_1917000 0.048
R_VDD1_256 METAL4_336000_1917000 METAL4_338000_1917000 0.016
R_VDD1_257 METAL4_338000_1917000 METAL4_340000_1917000 0.016
R_VDD1_258 METAL4_340000_1917000 METAL4_342000_1917000 0.016
R_VDD1_259 METAL4_342000_1917000 METAL4_348000_1917000 0.048
R_VDD1_260 METAL4_348000_1917000 METAL4_348000_1929000 0.096
R_VDD1_261 METAL4_348000_1929000 METAL4_348000_1941000 0.096
R_VDD1_262 METAL4_348000_1941000 METAL4_348000_1953000 0.096
R_VDD1_263 METAL4_348000_1953000 METAL4_348000_1965000 0.096
R_VDD1_264 METAL4_348000_1965000 METAL4_348000_1977000 0.096
R_VDD1_265 METAL4_348000_1977000 METAL4_348000_1989000 0.096
R_VDD1_266 METAL4_348000_1989000 METAL5_348000_1989000 0.1
R_VDD1_267 METAL5_348000_1989000 METAL5_348000_2001000 0.048
R_VDD1_268 METAL5_348000_2001000 METAL5_348000_2013000 0.048
R_VDD1_269 METAL5_348000_2013000 METAL5_348000_2093000 0.32
R_VDD1_270 METAL5_348000_2093000 METAL5_348000_2107000 0.056
R_VDD1_271 METAL5_348000_2107000 METAL5_348000_2217000 0.44
R_VDD1_272 METAL5_348000_2217000 METAL5_348000_2229000 0.048
R_VDD1_273 METAL5_348000_2229000 METAL5_348000_2241000 0.048
R_VDD1_274 METAL5_348000_2241000 METAL5_348000_2253000 0.048
R_VDD1_275 METAL5_348000_2253000 METAL5_348000_2265000 0.048
R_VDD1_276 METAL5_348000_2265000 METAL5_348000_2277000 0.048
R_VDD1_277 METAL5_348000_2277000 METAL5_348000_2289000 0.048
R_VDD1_278 METAL5_348000_2289000 METAL5_348000_2341000 0.208
R_VDD1_279 METAL5_348000_2341000 METAL5_348000_2353000 0.048
R_VDD1_280 METAL5_348000_2353000 METAL5_348000_2365000 0.048
R_VDD1_281 METAL5_348000_2365000 METAL5_348000_2377000 0.048
R_VDD1_282 METAL5_348000_2377000 METAL5_348000_2389000 0.048
R_VDD1_283 METAL5_348000_2389000 METAL5_348000_2401000 0.048
R_VDD1_284 METAL5_348000_2401000 METAL5_348000_2453000 0.208
R_VDD1_285 METAL5_348000_2453000 METAL5_348000_2465000 0.048
R_VDD1_286 METAL5_348000_2465000 METAL5_348000_2477000 0.048
R_VDD1_287 METAL5_348000_2477000 METAL5_348000_2489000 0.048
R_VDD1_288 METAL5_348000_2489000 METAL5_348000_2553000 0.256
R_VDD1_289 METAL5_348000_2553000 METAL5_348000_2565000 0.048
R_VDD1_290 METAL5_348000_2565000 METAL5_348000_2577000 0.048
R_VDD1_291 METAL5_348000_2577000 METAL5_348000_2605000 0.112
R_VDD1_292 METAL5_348000_2605000 METAL4_348000_2605000 0.1
R_VDD1_293 METAL4_348000_2605000 METAL4_348000_2617000 0.096
R_VDD1_294 METAL4_348000_2617000 METAL4_348000_2629000 0.096
R_VDD1_295 METAL4_348000_2629000 METAL4_348000_2641000 0.096
R_VDD1_296 METAL4_348000_2641000 METAL4_348000_2653000 0.096
R_VDD1_297 METAL4_348000_2653000 METAL4_348000_2665000 0.096
R_VDD1_298 METAL4_348000_2665000 METAL4_348000_2677000 0.096
R_VDD1_299 METAL4_348000_2677000 METAL5_348000_2677000 0.1
R_VDD1_300 METAL5_348000_2677000 METAL5_348000_2689000 0.048
R_VDD1_301 METAL5_348000_2689000 METAL5_348000_2701000 0.048
R_VDD1_302 METAL5_348000_2701000 METAL5_348000_2713000 0.048
R_VDD1_303 METAL5_348000_2713000 METAL5_348000_2769000 0.224
R_VDD1_304 METAL5_348000_2769000 METAL5_348000_2781000 0.048
R_VDD1_305 METAL5_348000_2781000 METAL4_348000_2781000 0.1
R_VDD1_306 METAL4_348000_2781000 METAL4_348000_2793000 0.096
R_VDD1_307 METAL4_348000_2793000 METAL4_348000_2805000 0.096
R_VDD1_308 METAL4_348000_2805000 METAL5_348000_2805000 0.1
R_VDD1_309 METAL5_348000_2805000 METAL5_350000_2805000 0.008
R_VDD1_310 METAL5_350000_2805000 METAL5_352000_2805000 0.008
R_VDD1_311 METAL5_352000_2805000 METAL5_354000_2805000 0.008
R_VDD1_312 METAL5_354000_2805000 METAL5_360000_2805000 0.024
R_VDD1_313 METAL5_360000_2805000 METAL5_362000_2805000 0.008
R_VDD1_314 METAL5_362000_2805000 METAL5_362000_2807000 0.008
R_VDD1_315 METAL5_362000_2807000 METAL5_362000_2817000 0.04
R_VDD1_316 METAL5_362000_2817000 METAL5_362000_2941000 0.496
R_VDD1_317 METAL5_362000_2941000 METAL5_362000_2953000 0.048
R_VDD1_318 METAL5_362000_2953000 METAL5_362000_2965000 0.048
R_VDD1_319 METAL5_362000_2965000 METAL5_362000_2977000 0.048
R_VDD1_320 METAL5_362000_2977000 METAL5_362000_2989000 0.048
R_VDD1_321 METAL5_362000_2989000 METAL5_362000_3001000 0.048
R_VDD1_322 METAL5_362000_3001000 METAL5_362000_3053000 0.208
R_VDD1_323 METAL5_362000_3053000 METAL5_362000_3065000 0.048
R_VDD1_324 METAL5_362000_3065000 METAL5_362000_3077000 0.048
R_VDD1_325 METAL5_362000_3077000 METAL5_362000_3089000 0.048
R_VDD1_326 METAL5_362000_3089000 METAL5_362000_3101000 0.048
R_VDD1_327 METAL5_362000_3101000 METAL5_362000_3153000 0.208
R_VDD1_328 METAL5_362000_3153000 METAL5_362000_3165000 0.048
R_VDD1_329 METAL5_362000_3165000 METAL5_362000_3177000 0.048
R_VDD1_330 METAL5_362000_3177000 METAL5_362000_3189000 0.048
R_VDD1_331 METAL5_362000_3189000 METAL5_362000_3253000 0.256
R_VDD1_332 METAL5_362000_3253000 METAL5_362000_3265000 0.048
R_VDD1_333 METAL5_362000_3265000 METAL5_364000_3265000 0.008
R_VDD1_334 METAL5_364000_3265000 METAL5_366000_3265000 0.008
R_VDD1_335 METAL5_366000_3265000 METAL5_372000_3265000 0.024
R_VDD1_336 METAL5_372000_3265000 METAL5_372000_3277000 0.048
R_VDD1_337 METAL5_372000_3277000 METAL5_372000_3289000 0.048
R_VDD1_338 METAL5_372000_3289000 METAL5_372000_3341000 0.208
R_VDD1_339 METAL5_372000_3341000 METAL5_372000_3353000 0.048
R_VDD1_340 METAL5_372000_3353000 METAL5_372000_3365000 0.048
R_VDD1_341 METAL5_372000_3365000 METAL5_374000_3365000 0.008
R_VDD1_342 METAL5_374000_3365000 METAL4_374000_3365000 0.1
R_VDD1_343 METAL4_374000_3365000 METAL4_376000_3365000 0.016
R_VDD1_344 METAL4_376000_3365000 METAL4_378000_3365000 0.016
R_VDD1_345 METAL4_378000_3365000 METAL4_384000_3365000 0.048
R_VDD1_346 METAL4_384000_3365000 METAL4_384000_3377000 0.096
R_VDD1_347 METAL4_384000_3377000 METAL4_384000_3389000 0.096
R_VDD1_348 METAL4_384000_3389000 METAL4_384000_3401000 0.096
R_VDD1_349 METAL4_384000_3401000 METAL4_384000_3413000 0.096
R_VDD1_350 METAL4_384000_3413000 METAL5_384000_3413000 0.1
R_VDD1_351 METAL5_384000_3413000 METAL5_384000_3425000 0.048
R_VDD1_352 METAL5_384000_3425000 METAL5_384000_3481000 0.224
R_VDD1_353 METAL5_384000_3481000 METAL5_384000_3493000 0.048
R_VDD1_354 METAL5_384000_3493000 METAL5_384000_3495000 0.008
R_VDD1_355 METAL5_384000_3495000 METAL5_384000_3505000 0.04
R_VDD1_356 METAL5_384000_3505000 METAL5_384000_3507000 0.008
R_VDD1_357 METAL5_384000_3507000 METAL5_384000_3519000 0.048
R_VDD1_358 METAL5_384000_3519000 METAL5_384000_3641000 0.488
R_VDD1_359 METAL5_384000_3641000 METAL5_384000_3653000 0.048
R_VDD1_360 METAL5_384000_3653000 METAL5_384000_3665000 0.048
R_VDD1_361 METAL5_384000_3665000 METAL5_384000_3677000 0.048
R_VDD1_362 METAL5_384000_3677000 METAL5_384000_3689000 0.048
R_VDD1_363 METAL5_384000_3689000 METAL5_384000_3753000 0.256
R_VDD1_364 METAL5_384000_3753000 METAL5_384000_3765000 0.048
R_VDD1_365 METAL5_384000_3765000 METAL5_384000_3777000 0.048
R_VDD1_366 METAL5_384000_3777000 METAL5_384000_3789000 0.048
R_VDD1_367 METAL5_384000_3789000 METAL5_384000_3853000 0.256
R_VDD1_368 METAL5_384000_3853000 METAL5_384000_3865000 0.048
R_VDD1_369 METAL5_384000_3865000 METAL5_384000_3877000 0.048
R_VDD1_370 METAL5_384000_3877000 METAL5_384000_3941000 0.256
R_VDD1_371 METAL5_384000_3941000 METAL5_384000_3953000 0.048
R_VDD1_372 METAL5_384000_3953000 METAL5_384000_3965000 0.048
R_VDD1_373 METAL5_384000_3965000 METAL5_384000_3977000 0.048
R_VDD1_374 METAL5_384000_3977000 METAL5_384000_4029000 0.208
R_VDD1_375 METAL5_384000_4029000 METAL5_384000_4041000 0.048
R_VDD1_376 METAL5_384000_4041000 METAL5_384000_4053000 0.048
R_VDD1_377 METAL5_384000_4053000 METAL5_384000_4065000 0.048
R_VDD1_378 METAL5_384000_4065000 METAL4_384000_4065000 0.1
R_VDD1_379 METAL4_384000_4065000 METAL4_384000_4077000 0.096
R_VDD1_380 METAL4_384000_4077000 METAL4_384000_4089000 0.096
R_VDD1_381 METAL4_384000_4089000 METAL5_384000_4089000 0.1
R_VDD1_382 METAL5_384000_4089000 METAL5_384000_4101000 0.048
R_VDD1_383 METAL5_384000_4101000 METAL5_384000_4145000 0.176
R_VDD1_384 METAL5_384000_4145000 METAL4_384000_4145000 0.1
R_VDD1_385 METAL4_384000_4145000 METAL4_384000_4157000 0.096
R_VDD1_386 METAL4_384000_4157000 METAL4_384000_4169000 0.096
R_VDD1_387 METAL4_384000_4169000 METAL4_384000_4181000 0.096
R_VDD1_388 METAL4_384000_4181000 METAL4_384000_4193000 0.096
R_VDD1_389 METAL4_384000_4193000 METAL4_384000_4195000 0.016
R_VDD1_390 METAL4_384000_4195000 METAL4_384000_4205000 0.08
R_VDD1_391 METAL4_384000_4205000 METAL5_384000_4205000 0.1
R_VDD1_392 METAL5_384000_4205000 METAL5_384000_4207000 0.008
R_VDD1_393 METAL5_384000_4207000 METAL5_384000_4219000 0.048
R_VDD1_394 METAL5_384000_4219000 METAL5_384000_4329000 0.44
R_VDD1_395 METAL5_384000_4329000 METAL5_384000_4341000 0.048
R_VDD1_396 METAL5_384000_4341000 METAL5_384000_4353000 0.048
R_VDD1_397 METAL5_384000_4353000 METAL5_384000_4365000 0.048
R_VDD1_398 METAL5_384000_4365000 METAL5_384000_4377000 0.048
R_VDD1_399 METAL5_384000_4377000 METAL5_384000_4389000 0.048
R_VDD1_400 METAL5_384000_4389000 METAL5_384000_4453000 0.256
R_VDD1_401 METAL5_384000_4453000 METAL5_384000_4465000 0.048
R_VDD1_402 METAL5_384000_4465000 METAL5_384000_4477000 0.048
R_VDD1_403 METAL5_384000_4477000 METAL5_384000_4489000 0.048
R_VDD1_404 METAL5_384000_4489000 METAL5_384000_4553000 0.256
R_VDD1_405 METAL5_384000_4553000 METAL5_384000_4565000 0.048
R_VDD1_406 METAL5_384000_4565000 METAL5_384000_4577000 0.048
R_VDD1_407 METAL5_384000_4577000 METAL5_384000_4605000 0.112
R_VDD1_408 METAL5_384000_4605000 METAL5_384000_4617000 0.048
R_VDD1_409 METAL5_384000_4617000 METAL5_384000_4629000 0.048
R_VDD1_410 METAL5_384000_4629000 METAL5_384000_4641000 0.048
R_VDD1_411 METAL5_384000_4641000 METAL5_384000_4653000 0.048
R_VDD1_412 METAL5_384000_4653000 METAL5_384000_4665000 0.048
R_VDD1_413 METAL5_384000_4665000 METAL5_384000_4677000 0.048
R_VDD1_414 METAL5_384000_4677000 METAL5_384000_4689000 0.048
R_VDD1_415 METAL5_384000_4689000 METAL5_384000_4701000 0.048
R_VDD1_416 METAL5_384000_4701000 METAL5_384000_4729000 0.112
R_VDD1_417 METAL5_384000_4729000 METAL5_384000_4741000 0.048
R_VDD1_418 METAL5_384000_4741000 METAL5_384000_4753000 0.048
R_VDD1_419 METAL5_384000_4753000 METAL5_384000_4765000 0.048
R_VDD1_420 METAL5_384000_4765000 METAL5_386000_4765000 0.008
R_VDD1_421 METAL5_386000_4765000 METAL5_388000_4765000 0.008
R_VDD1_422 METAL5_388000_4765000 METAL5_390000_4765000 0.008
R_VDD1_423 METAL5_390000_4765000 METAL4_390000_4765000 0.1
R_VDD1_424 METAL4_390000_4765000 METAL4_390000_4777000 0.096
R_VDD1_425 METAL4_390000_4777000 METAL4_390000_4789000 0.096
R_VDD1_426 METAL4_390000_4789000 METAL5_390000_4789000 0.1
R_VDD1_427 METAL5_390000_4789000 METAL5_390000_4801000 0.048
R_VDD1_428 METAL5_390000_4801000 METAL5_390000_4893000 0.368
R_VDD1_429 METAL5_390000_4893000 METAL5_390000_4907000 0.056
R_VDD1_430 METAL5_390000_4907000 METAL5_390000_5041000 0.536
R_VDD1_431 METAL5_390000_5041000 METAL5_390000_5053000 0.048
R_VDD1_432 METAL5_390000_5053000 METAL5_390000_5065000 0.048
R_VDD1_433 METAL5_390000_5065000 METAL5_390000_5077000 0.048
R_VDD1_434 METAL5_390000_5077000 METAL5_390000_5089000 0.048
R_VDD1_435 METAL5_390000_5089000 METAL5_390000_5153000 0.256
R_VDD1_436 METAL5_390000_5153000 METAL5_390000_5165000 0.048
R_VDD1_437 METAL5_390000_5165000 METAL5_390000_5177000 0.048
R_VDD1_438 METAL5_390000_5177000 METAL5_390000_5229000 0.208
R_VDD1_439 METAL5_390000_5229000 METAL5_390000_5241000 0.048
R_VDD1_440 METAL5_390000_5241000 METAL5_390000_5253000 0.048
R_VDD1_441 METAL5_390000_5253000 METAL5_390000_5265000 0.048
R_VDD1_442 METAL5_390000_5265000 METAL5_390000_5277000 0.048
R_VDD1_443 METAL5_390000_5277000 METAL5_390000_5329000 0.208
R_VDD1_444 METAL5_390000_5329000 METAL5_390000_5341000 0.048
R_VDD1_445 METAL5_390000_5341000 METAL5_390000_5353000 0.048
R_VDD1_446 METAL5_390000_5353000 METAL5_390000_5365000 0.048
R_VDD1_447 METAL5_390000_5365000 METAL5_390000_5377000 0.048
R_VDD1_448 METAL5_390000_5377000 METAL5_390000_5389000 0.048
R_VDD1_449 METAL5_390000_5389000 METAL5_390000_5429000 0.16
R_VDD1_450 METAL5_390000_5429000 METAL5_396000_5429000 0.024
R_VDD1_451 METAL5_396000_5429000 METAL5_398000_5429000 0.008
R_VDD1_452 METAL5_398000_5429000 METAL5_400000_5429000 0.008
R_VDD1_453 METAL5_400000_5429000 METAL5_402000_5429000 0.008
R_VDD1_454 METAL5_402000_5429000 METAL5_408000_5429000 0.024
R_VDD1_455 METAL5_408000_5429000 METAL5_410000_5429000 0.008
R_VDD1_456 METAL5_410000_5429000 METAL5_410000_5441000 0.048
R_VDD1_457 METAL5_410000_5441000 METAL5_412000_5441000 0.008
R_VDD1_458 METAL5_412000_5441000 METAL5_414000_5441000 0.008
R_VDD1_459 METAL5_414000_5441000 METAL5_416000_5441000 0.008
R_VDD1_460 METAL5_416000_5441000 METAL5_420000_5441000 0.016
R_VDD1_461 METAL5_420000_5441000 METAL5_422000_5441000 0.008
R_VDD1_462 METAL5_422000_5441000 METAL4_422000_5441000 0.1
R_VDD1_463 METAL4_422000_5441000 METAL4_424000_5441000 0.016
R_VDD1_464 METAL4_424000_5441000 METAL4_426000_5441000 0.016
R_VDD1_465 METAL4_426000_5441000 METAL4_428000_5441000 0.016
R_VDD1_466 METAL4_428000_5441000 METAL4_432000_5441000 0.032
R_VDD1_467 METAL4_432000_5441000 METAL4_434000_5441000 0.016
R_VDD1_468 METAL4_434000_5441000 METAL4_436000_5441000 0.016
R_VDD1_469 METAL4_436000_5441000 METAL4_438000_5441000 0.016
R_VDD1_470 METAL4_438000_5441000 METAL4_440000_5441000 0.016
R_VDD1_471 METAL4_440000_5441000 METAL4_444000_5441000 0.032
R_VDD1_472 METAL4_444000_5441000 METAL4_446000_5441000 0.016
R_VDD1_473 METAL4_446000_5441000 METAL5_446000_5441000 0.1
R_VDD1_474 METAL5_446000_5441000 METAL5_446000_5453000 0.048
R_VDD1_475 METAL5_446000_5453000 METAL5_446000_5465000 0.048
R_VDD1_476 METAL5_446000_5465000 METAL5_446000_5477000 0.048
R_VDD1_477 METAL5_446000_5477000 METAL6_446000_5477000 0.1
R_VDD1_478 METAL6_446000_5477000 METAL6_446000_5489000 0.024
R_VDD1_479 METAL6_446000_5489000 METAL6_446000_5501000 0.024
R_VDD1_480 METAL6_446000_5501000 METAL6_446000_5581000 0.16
R_VDD1_481 METAL6_446000_5581000 METAL6_446000_5593000 0.024
R_VDD1_482 METAL6_446000_5593000 METAL6_446000_5595000 0.004
R_VDD1_483 METAL6_446000_5595000 METAL6_446000_5605000 0.02
R_VDD1_484 METAL6_446000_5605000 METAL6_448000_5605000 0.004
R_VDD1_485 METAL6_448000_5605000 METAL6_450000_5605000 0.004
R_VDD1_486 METAL6_450000_5605000 METAL6_450000_5607000 0.004
R_VDD1_487 METAL6_450000_5607000 METAL6_450000_5619000 0.024
R_VDD1_488 METAL6_450000_5619000 METAL6_450000_5753000 0.268
R_VDD1_489 METAL6_450000_5753000 METAL6_450000_5765000 0.024
R_VDD1_490 METAL6_450000_5765000 METAL6_450000_5777000 0.024
R_VDD1_491 METAL6_450000_5777000 METAL6_450000_5853000 0.152
R_VDD1_492 METAL6_450000_5853000 METAL6_450000_5865000 0.024
R_VDD1_493 METAL6_450000_5865000 METAL6_450000_5877000 0.024
R_VDD1_494 METAL6_450000_5877000 METAL6_450000_5941000 0.128
R_VDD1_495 METAL6_450000_5941000 METAL6_450000_5953000 0.024
R_VDD1_496 METAL6_450000_5953000 METAL5_450000_5953000 0.1
R_VDD1_497 METAL5_450000_5953000 METAL5_450000_5965000 0.048
R_VDD1_498 METAL5_450000_5965000 METAL5_450000_5977000 0.048
R_VDD1_499 METAL5_450000_5977000 METAL6_450000_5977000 0.1
R_VDD1_500 METAL6_450000_5977000 METAL6_450000_6041000 0.128
R_VDD1_501 METAL6_450000_6041000 METAL6_450000_6053000 0.024
R_VDD1_502 METAL6_450000_6053000 METAL6_452000_6053000 0.004
R_VDD1_503 METAL6_452000_6053000 METAL6_458000_6053000 0.012
R_VDD1_504 METAL6_458000_6053000 METAL6_460000_6053000 0.004
R_VDD1_505 METAL6_460000_6053000 METAL6_462000_6053000 0.004
R_VDD1_506 METAL6_462000_6053000 METAL6_464000_6053000 0.004
R_VDD1_507 METAL6_464000_6053000 METAL6_470000_6053000 0.012
R_VDD1_508 METAL6_470000_6053000 METAL6_472000_6053000 0.004
R_VDD1_509 METAL6_472000_6053000 METAL6_474000_6053000 0.004
R_VDD1_510 METAL6_474000_6053000 METAL6_476000_6053000 0.004
R_VDD1_511 METAL6_476000_6053000 METAL5_476000_6053000 0.1
R_VDD1_512 METAL5_476000_6053000 METAL5_476000_6065000 0.048
R_VDD1_513 METAL5_476000_6065000 METAL5_476000_6077000 0.048
R_VDD1_514 METAL5_476000_6077000 METAL6_476000_6077000 0.1
R_VDD1_515 METAL6_476000_6077000 METAL6_476000_6089000 0.024
R_VDD1_516 METAL6_476000_6089000 METAL6_476000_6153000 0.128
R_VDD1_517 METAL6_476000_6153000 METAL6_476000_6165000 0.024
R_VDD1_518 METAL6_476000_6165000 METAL6_476000_6177000 0.024
R_VDD1_519 METAL6_476000_6177000 METAL6_476000_6293000 0.232
R_VDD1_520 METAL6_476000_6293000 METAL6_476000_6307000 0.028
R_VDD1_521 METAL6_476000_6307000 METAL6_476000_6453000 0.292
R_VDD1_522 METAL6_476000_6453000 METAL6_476000_6465000 0.024
R_VDD1_523 METAL6_476000_6465000 METAL6_482000_6465000 0.012
R_VDD1_524 METAL6_482000_6465000 METAL6_483000_6465000 0.002
R_VDD1_525 METAL6_483000_6465000 METAL6_484000_6465000 0.002
R_VDD1_526 METAL6_484000_6465000 METAL6_486000_6465000 0.004
R_VDD1_527 METAL6_486000_6465000 METAL6_488000_6465000 0.004
R_VDD1_528 METAL6_488000_6465000 METAL6_494000_6465000 0.012
R_VDD1_529 METAL6_494000_6465000 METAL6_495000_6465000 0.002
R_VDD1_530 METAL6_495000_6465000 METAL6_496000_6465000 0.002
R_VDD1_531 METAL6_496000_6465000 METAL6_498000_6465000 0.004
R_VDD1_532 METAL6_498000_6465000 METAL6_500000_6465000 0.004
R_VDD1_533 METAL6_500000_6465000 METAL6_507000_6465000 0.014
R_VDD1_534 METAL6_507000_6465000 METAL6_508000_6465000 0.002
R_VDD1_535 METAL6_508000_6465000 METAL6_510000_6465000 0.004
R_VDD1_536 METAL6_510000_6465000 METAL6_512000_6465000 0.004
R_VDD1_537 METAL6_512000_6465000 METAL6_519000_6465000 0.014
R_VDD1_538 METAL6_519000_6465000 METAL5_519000_6465000 0.1
R_VDD1_539 METAL5_519000_6465000 METAL5_522000_6465000 0.012
R_VDD1_540 METAL5_522000_6465000 METAL5_524000_6465000 0.008
R_VDD1_541 METAL5_524000_6465000 METAL5_531000_6465000 0.028
R_VDD1_542 METAL5_531000_6465000 METAL5_536000_6465000 0.02
R_VDD1_543 METAL5_536000_6465000 METAL5_543000_6465000 0.028
R_VDD1_544 METAL5_543000_6465000 METAL6_543000_6465000 0.1
R_VDD1_545 METAL6_555000_6465000 METAL6_543000_6465000 0.024
R_VDD1_546 METAL6_245000_6465000 METAL6_257000_6465000 0.024
R_VDD1_547 METAL6_446000_5581000 METAL5_446000_5581000 0.1
R_VDD1_548 METAL5_446000_5581000 METAL5_444000_5581000 0.008
R_VDD1_549 METAL5_444000_5581000 METAL5_440000_5581000 0.016
R_VDD1_550 METAL5_440000_5581000 METAL5_438000_5581000 0.008
R_VDD1_551 METAL5_438000_5581000 METAL5_436000_5581000 0.008
R_VDD1_552 METAL5_436000_5581000 METAL5_434000_5581000 0.008
R_VDD1_553 METAL5_434000_5581000 METAL5_432000_5581000 0.008
R_VDD1_554 METAL5_432000_5581000 METAL5_428000_5581000 0.016
R_VDD1_555 METAL5_428000_5581000 METAL5_426000_5581000 0.008
R_VDD1_556 METAL5_426000_5581000 METAL5_424000_5581000 0.008
R_VDD1_557 METAL5_424000_5581000 METAL5_422000_5581000 0.008
R_VDD1_558 METAL5_422000_5581000 METAL5_420000_5581000 0.008
R_VDD1_559 METAL5_420000_5581000 METAL5_416000_5581000 0.016
R_VDD1_560 METAL5_416000_5581000 METAL5_414000_5581000 0.008
R_VDD1_561 METAL5_414000_5581000 METAL5_412000_5581000 0.008
R_VDD1_562 METAL5_412000_5581000 METAL5_410000_5581000 0.008
R_VDD1_563 METAL5_410000_5581000 METAL5_408000_5581000 0.008
R_VDD1_564 METAL5_408000_5581000 METAL5_402000_5581000 0.024
R_VDD1_565 METAL5_402000_5581000 METAL5_400000_5581000 0.008
R_VDD1_566 METAL5_400000_5581000 METAL5_398000_5581000 0.008
R_VDD1_567 METAL5_398000_5581000 METAL5_396000_5581000 0.008
R_VDD1_568 METAL5_396000_5581000 METAL5_390000_5581000 0.024
R_VDD1_569 METAL5_390000_5581000 METAL5_388000_5581000 0.008
R_VDD1_570 METAL5_388000_5581000 METAL5_386000_5581000 0.008
R_VDD1_571 METAL5_386000_5581000 METAL5_384000_5581000 0.008
R_VDD1_572 METAL5_384000_5581000 METAL5_378000_5581000 0.024
R_VDD1_573 METAL5_378000_5581000 METAL5_376000_5581000 0.008
R_VDD1_574 METAL5_376000_5581000 METAL5_374000_5581000 0.008
R_VDD1_575 METAL5_374000_5581000 METAL5_372000_5581000 0.008
R_VDD1_576 METAL5_372000_5581000 METAL5_366000_5581000 0.024
R_VDD1_577 METAL5_366000_5581000 METAL5_364000_5581000 0.008
R_VDD1_578 METAL5_364000_5581000 METAL5_362000_5581000 0.008
R_VDD1_579 METAL5_362000_5581000 METAL5_360000_5581000 0.008
R_VDD1_580 METAL5_360000_5581000 METAL5_354000_5581000 0.024
R_VDD1_581 METAL5_354000_5581000 METAL5_352000_5581000 0.008
R_VDD1_582 METAL5_352000_5581000 METAL5_350000_5581000 0.008
R_VDD1_583 METAL5_350000_5581000 METAL5_348000_5581000 0.008
R_VDD1_584 METAL5_348000_5581000 METAL5_342000_5581000 0.024
R_VDD1_585 METAL5_342000_5581000 METAL5_340000_5581000 0.008
R_VDD1_586 METAL5_340000_5581000 METAL5_338000_5581000 0.008
R_VDD1_587 METAL5_338000_5581000 METAL5_336000_5581000 0.008
R_VDD1_588 METAL5_336000_5581000 METAL5_330000_5581000 0.024
R_VDD1_589 METAL5_330000_5581000 METAL5_329000_5581000 0.004
R_VDD1_590 METAL5_329000_5581000 METAL5_328000_5581000 0.004
R_VDD1_591 METAL5_328000_5581000 METAL5_326000_5581000 0.008
R_VDD1_592 METAL5_326000_5581000 METAL5_324000_5581000 0.008
R_VDD1_593 METAL5_324000_5581000 METAL5_318000_5581000 0.024
R_VDD1_594 METAL5_318000_5581000 METAL5_317000_5581000 0.004
R_VDD1_595 METAL5_317000_5581000 METAL5_316000_5581000 0.004
R_VDD1_596 METAL5_316000_5581000 METAL5_314000_5581000 0.008
R_VDD1_597 METAL5_314000_5581000 METAL5_312000_5581000 0.008
R_VDD1_598 METAL5_312000_5581000 METAL5_306000_5581000 0.024
R_VDD1_599 METAL5_306000_5581000 METAL5_305000_5581000 0.004
R_VDD1_600 METAL5_305000_5581000 METAL5_304000_5581000 0.004
R_VDD1_601 METAL5_304000_5581000 METAL5_302000_5581000 0.008
R_VDD1_602 METAL5_302000_5581000 METAL5_300000_5581000 0.008
R_VDD1_603 METAL5_300000_5581000 METAL6_300000_5581000 0.1
R_VDD1_604 METAL6_300000_5581000 METAL6_300000_5593000 0.024
R_VDD1_605 METAL6_300000_5593000 METAL6_300000_5595000 0.004
R_VDD1_606 METAL6_300000_5595000 METAL6_300000_5605000 0.02
R_VDD1_607 METAL6_300000_5605000 METAL6_300000_5607000 0.004
R_VDD1_608 METAL6_300000_5607000 METAL6_300000_5617000 0.02
R_VDD1_609 METAL6_300000_5617000 METAL6_300000_5619000 0.004
R_VDD1_610 METAL6_300000_5619000 METAL6_300000_5753000 0.268
R_VDD1_611 METAL6_300000_5753000 METAL6_300000_5765000 0.024
R_VDD1_612 METAL6_300000_5765000 METAL6_300000_5777000 0.024
R_VDD1_613 METAL6_300000_5777000 METAL6_300000_5853000 0.152
R_VDD1_614 METAL6_300000_5853000 METAL6_300000_5865000 0.024
R_VDD1_615 METAL6_300000_5865000 METAL6_300000_5877000 0.024
R_VDD1_616 METAL6_300000_5877000 METAL6_300000_5941000 0.128
R_VDD1_617 METAL6_300000_5941000 METAL6_300000_5953000 0.024
R_VDD1_618 METAL6_300000_5953000 METAL5_300000_5953000 0.1
R_VDD1_619 METAL5_300000_5953000 METAL5_302000_5953000 0.008
R_VDD1_620 METAL5_302000_5953000 METAL5_304000_5953000 0.008
R_VDD1_621 METAL5_304000_5953000 METAL5_305000_5953000 0.004
R_VDD1_622 METAL5_305000_5953000 METAL5_306000_5953000 0.004
R_VDD1_623 METAL5_306000_5953000 METAL5_312000_5953000 0.024
R_VDD1_624 METAL5_312000_5953000 METAL5_312000_5965000 0.048
R_VDD1_625 METAL5_312000_5965000 METAL5_312000_5977000 0.048
R_VDD1_626 METAL5_312000_5977000 METAL5_312000_5989000 0.048
R_VDD1_627 METAL5_312000_5989000 METAL5_312000_6041000 0.208
R_VDD1_628 METAL5_312000_6041000 METAL5_312000_6053000 0.048
R_VDD1_629 METAL5_312000_6053000 METAL5_312000_6065000 0.048
R_VDD1_630 METAL5_312000_6065000 METAL5_312000_6077000 0.048
R_VDD1_631 METAL5_312000_6077000 METAL6_312000_6077000 0.1
R_VDD1_632 METAL6_312000_6077000 METAL6_312000_6089000 0.024
R_VDD1_633 METAL6_312000_6089000 METAL6_312000_6153000 0.128
R_VDD1_634 METAL6_312000_6153000 METAL6_312000_6165000 0.024
R_VDD1_635 METAL6_312000_6165000 METAL6_312000_6177000 0.024
R_VDD1_636 METAL6_312000_6177000 METAL6_312000_6293000 0.232
R_VDD1_637 METAL6_312000_6293000 METAL6_312000_6307000 0.028
R_VDD1_638 METAL6_312000_6307000 METAL6_312000_6453000 0.292
R_VDD1_639 METAL6_312000_6453000 METAL6_312000_6465000 0.024
R_VDD1_640 METAL6_312000_6465000 METAL6_306000_6465000 0.012
R_VDD1_641 METAL6_306000_6465000 METAL6_305000_6465000 0.002
R_VDD1_642 METAL6_305000_6465000 METAL6_304000_6465000 0.002
R_VDD1_643 METAL6_304000_6465000 METAL6_302000_6465000 0.004
R_VDD1_644 METAL6_302000_6465000 METAL6_300000_6465000 0.004
R_VDD1_645 METAL6_300000_6465000 METAL6_294000_6465000 0.012
R_VDD1_646 METAL6_294000_6465000 METAL6_293000_6465000 0.002
R_VDD1_647 METAL6_293000_6465000 METAL6_292000_6465000 0.002
R_VDD1_648 METAL6_292000_6465000 METAL6_290000_6465000 0.004
R_VDD1_649 METAL6_290000_6465000 METAL6_288000_6465000 0.004
R_VDD1_650 METAL6_288000_6465000 METAL6_282000_6465000 0.012
R_VDD1_651 METAL6_282000_6465000 METAL6_281000_6465000 0.002
R_VDD1_652 METAL6_281000_6465000 METAL5_281000_6465000 0.1
R_VDD1_653 METAL5_281000_6465000 METAL5_280000_6465000 0.004
R_VDD1_654 METAL5_280000_6465000 METAL5_278000_6465000 0.008
R_VDD1_655 METAL5_278000_6465000 METAL5_276000_6465000 0.008
R_VDD1_656 METAL5_276000_6465000 METAL5_270000_6465000 0.024
R_VDD1_657 METAL5_270000_6465000 METAL5_269000_6465000 0.004
R_VDD1_658 METAL5_269000_6465000 METAL5_266000_6465000 0.012
R_VDD1_659 METAL5_266000_6465000 METAL5_264000_6465000 0.008
R_VDD1_660 METAL5_264000_6465000 METAL5_258000_6465000 0.024
R_VDD1_661 METAL5_258000_6465000 METAL5_257000_6465000 0.004
R_VDD1_662 METAL5_257000_6465000 METAL6_257000_6465000 0.1
R_VDD1_663 METAL6_555000_5765000 METAL6_543000_5765000 0.024
R_VDD1_664 METAL5_390000_5581000 METAL5_390000_5569000 0.048
R_VDD1_665 METAL5_390000_5569000 METAL5_396000_5569000 0.024
R_VDD1_666 METAL5_396000_5569000 METAL5_398000_5569000 0.008
R_VDD1_667 METAL5_398000_5569000 METAL5_400000_5569000 0.008
R_VDD1_668 METAL5_400000_5569000 METAL5_402000_5569000 0.008
R_VDD1_669 METAL5_402000_5569000 METAL5_408000_5569000 0.024
R_VDD1_670 METAL5_408000_5569000 METAL5_410000_5569000 0.008
R_VDD1_671 METAL5_410000_5569000 METAL5_412000_5569000 0.008
R_VDD1_672 METAL5_412000_5569000 METAL5_414000_5569000 0.008
R_VDD1_673 METAL5_414000_5569000 METAL5_416000_5569000 0.008
R_VDD1_674 METAL5_416000_5569000 METAL5_420000_5569000 0.016
R_VDD1_675 METAL5_420000_5569000 METAL5_422000_5569000 0.008
R_VDD1_676 METAL5_422000_5569000 METAL5_424000_5569000 0.008
R_VDD1_677 METAL5_424000_5569000 METAL5_426000_5569000 0.008
R_VDD1_678 METAL5_426000_5569000 METAL5_428000_5569000 0.008
R_VDD1_679 METAL5_428000_5569000 METAL5_432000_5569000 0.016
R_VDD1_680 METAL5_432000_5569000 METAL5_434000_5569000 0.008
R_VDD1_681 METAL5_434000_5569000 METAL5_436000_5569000 0.008
R_VDD1_682 METAL5_436000_5569000 METAL5_438000_5569000 0.008
R_VDD1_683 METAL5_438000_5569000 METAL5_440000_5569000 0.008
R_VDD1_684 METAL5_440000_5569000 METAL5_444000_5569000 0.016
R_VDD1_685 METAL5_444000_5569000 METAL5_446000_5569000 0.008
R_VDD1_686 METAL5_446000_5569000 METAL5_448000_5569000 0.008
R_VDD1_687 METAL5_448000_5569000 METAL5_450000_5569000 0.008
R_VDD1_688 METAL5_450000_5569000 METAL5_452000_5569000 0.008
R_VDD1_689 METAL5_452000_5569000 METAL5_458000_5569000 0.024
R_VDD1_690 METAL5_458000_5569000 METAL5_460000_5569000 0.008
R_VDD1_691 METAL5_460000_5569000 METAL5_462000_5569000 0.008
R_VDD1_692 METAL5_462000_5569000 METAL5_464000_5569000 0.008
R_VDD1_693 METAL5_464000_5569000 METAL5_470000_5569000 0.024
R_VDD1_694 METAL5_470000_5569000 METAL5_472000_5569000 0.008
R_VDD1_695 METAL5_472000_5569000 METAL5_474000_5569000 0.008
R_VDD1_696 METAL5_474000_5569000 METAL5_476000_5569000 0.008
R_VDD1_697 METAL5_476000_5569000 METAL5_482000_5569000 0.024
R_VDD1_698 METAL5_482000_5569000 METAL5_483000_5569000 0.004
R_VDD1_699 METAL5_483000_5569000 METAL5_484000_5569000 0.004
R_VDD1_700 METAL5_484000_5569000 METAL5_486000_5569000 0.008
R_VDD1_701 METAL5_486000_5569000 METAL5_488000_5569000 0.008
R_VDD1_702 METAL5_488000_5569000 METAL5_494000_5569000 0.024
R_VDD1_703 METAL5_494000_5569000 METAL5_495000_5569000 0.004
R_VDD1_704 METAL5_495000_5569000 METAL5_496000_5569000 0.004
R_VDD1_705 METAL5_496000_5569000 METAL5_498000_5569000 0.008
R_VDD1_706 METAL5_498000_5569000 METAL5_500000_5569000 0.008
R_VDD1_707 METAL5_500000_5569000 METAL5_507000_5569000 0.028
R_VDD1_708 METAL5_507000_5569000 METAL5_508000_5569000 0.004
R_VDD1_709 METAL5_508000_5569000 METAL5_510000_5569000 0.008
R_VDD1_710 METAL5_510000_5569000 METAL5_512000_5569000 0.008
R_VDD1_711 METAL5_512000_5569000 METAL5_519000_5569000 0.028
R_VDD1_712 METAL5_519000_5569000 METAL5_522000_5569000 0.012
R_VDD1_713 METAL5_522000_5569000 METAL5_524000_5569000 0.008
R_VDD1_714 METAL5_524000_5569000 METAL5_531000_5569000 0.028
R_VDD1_715 METAL5_531000_5569000 METAL5_536000_5569000 0.02
R_VDD1_716 METAL5_536000_5569000 METAL5_543000_5569000 0.028
R_VDD1_717 METAL5_543000_5569000 METAL6_543000_5569000 0.1
R_VDD1_718 METAL6_543000_5569000 METAL6_543000_5581000 0.024
R_VDD1_719 METAL6_543000_5581000 METAL6_543000_5593000 0.024
R_VDD1_720 METAL6_543000_5593000 METAL6_543000_5595000 0.004
R_VDD1_721 METAL6_543000_5595000 METAL6_543000_5605000 0.02
R_VDD1_722 METAL6_543000_5605000 METAL6_543000_5607000 0.004
R_VDD1_723 METAL6_543000_5607000 METAL6_543000_5617000 0.02
R_VDD1_724 METAL6_543000_5617000 METAL6_543000_5619000 0.004
R_VDD1_725 METAL6_543000_5619000 METAL6_543000_5753000 0.268
R_VDD1_726 METAL6_543000_5753000 METAL6_543000_5765000 0.024
R_VDD1_727 METAL6_245000_5765000 METAL6_257000_5765000 0.024
R_VDD1_728 METAL5_396000_5569000 METAL5_396000_5557000 0.048
R_VDD1_729 METAL5_396000_5557000 METAL5_390000_5557000 0.024
R_VDD1_730 METAL5_390000_5557000 METAL5_388000_5557000 0.008
R_VDD1_731 METAL5_388000_5557000 METAL5_386000_5557000 0.008
R_VDD1_732 METAL5_386000_5557000 METAL5_384000_5557000 0.008
R_VDD1_733 METAL5_384000_5557000 METAL5_378000_5557000 0.024
R_VDD1_734 METAL5_378000_5557000 METAL5_376000_5557000 0.008
R_VDD1_735 METAL5_376000_5557000 METAL5_374000_5557000 0.008
R_VDD1_736 METAL5_374000_5557000 METAL5_372000_5557000 0.008
R_VDD1_737 METAL5_372000_5557000 METAL5_366000_5557000 0.024
R_VDD1_738 METAL5_366000_5557000 METAL5_364000_5557000 0.008
R_VDD1_739 METAL5_364000_5557000 METAL5_362000_5557000 0.008
R_VDD1_740 METAL5_362000_5557000 METAL5_360000_5557000 0.008
R_VDD1_741 METAL5_360000_5557000 METAL5_354000_5557000 0.024
R_VDD1_742 METAL5_354000_5557000 METAL5_352000_5557000 0.008
R_VDD1_743 METAL5_352000_5557000 METAL5_350000_5557000 0.008
R_VDD1_744 METAL5_350000_5557000 METAL5_348000_5557000 0.008
R_VDD1_745 METAL5_348000_5557000 METAL5_342000_5557000 0.024
R_VDD1_746 METAL5_342000_5557000 METAL5_340000_5557000 0.008
R_VDD1_747 METAL5_340000_5557000 METAL5_338000_5557000 0.008
R_VDD1_748 METAL5_338000_5557000 METAL5_336000_5557000 0.008
R_VDD1_749 METAL5_336000_5557000 METAL5_330000_5557000 0.024
R_VDD1_750 METAL5_330000_5557000 METAL5_329000_5557000 0.004
R_VDD1_751 METAL5_329000_5557000 METAL5_328000_5557000 0.004
R_VDD1_752 METAL5_328000_5557000 METAL5_326000_5557000 0.008
R_VDD1_753 METAL5_326000_5557000 METAL5_324000_5557000 0.008
R_VDD1_754 METAL5_324000_5557000 METAL5_318000_5557000 0.024
R_VDD1_755 METAL5_318000_5557000 METAL5_317000_5557000 0.004
R_VDD1_756 METAL5_317000_5557000 METAL5_316000_5557000 0.004
R_VDD1_757 METAL5_316000_5557000 METAL5_314000_5557000 0.008
R_VDD1_758 METAL5_314000_5557000 METAL5_312000_5557000 0.008
R_VDD1_759 METAL5_312000_5557000 METAL5_306000_5557000 0.024
R_VDD1_760 METAL5_306000_5557000 METAL5_305000_5557000 0.004
R_VDD1_761 METAL5_305000_5557000 METAL5_304000_5557000 0.004
R_VDD1_762 METAL5_304000_5557000 METAL5_302000_5557000 0.008
R_VDD1_763 METAL5_302000_5557000 METAL5_300000_5557000 0.008
R_VDD1_764 METAL5_300000_5557000 METAL5_294000_5557000 0.024
R_VDD1_765 METAL5_294000_5557000 METAL5_293000_5557000 0.004
R_VDD1_766 METAL5_293000_5557000 METAL5_292000_5557000 0.004
R_VDD1_767 METAL5_292000_5557000 METAL5_290000_5557000 0.008
R_VDD1_768 METAL5_290000_5557000 METAL5_288000_5557000 0.008
R_VDD1_769 METAL5_288000_5557000 METAL5_282000_5557000 0.024
R_VDD1_770 METAL5_282000_5557000 METAL5_281000_5557000 0.004
R_VDD1_771 METAL5_281000_5557000 METAL5_280000_5557000 0.004
R_VDD1_772 METAL5_280000_5557000 METAL5_278000_5557000 0.008
R_VDD1_773 METAL5_278000_5557000 METAL5_276000_5557000 0.008
R_VDD1_774 METAL5_276000_5557000 METAL5_270000_5557000 0.024
R_VDD1_775 METAL5_270000_5557000 METAL5_269000_5557000 0.004
R_VDD1_776 METAL5_269000_5557000 METAL5_266000_5557000 0.012
R_VDD1_777 METAL5_266000_5557000 METAL5_264000_5557000 0.008
R_VDD1_778 METAL5_264000_5557000 METAL5_258000_5557000 0.024
R_VDD1_779 METAL5_258000_5557000 METAL5_257000_5557000 0.004
R_VDD1_780 METAL5_257000_5557000 METAL6_257000_5557000 0.1
R_VDD1_781 METAL6_257000_5557000 METAL6_257000_5569000 0.024
R_VDD1_782 METAL6_257000_5569000 METAL6_257000_5581000 0.024
R_VDD1_783 METAL6_257000_5581000 METAL6_257000_5593000 0.024
R_VDD1_784 METAL6_257000_5593000 METAL6_257000_5595000 0.004
R_VDD1_785 METAL6_257000_5595000 METAL6_257000_5605000 0.02
R_VDD1_786 METAL6_257000_5605000 METAL6_257000_5607000 0.004
R_VDD1_787 METAL6_257000_5607000 METAL6_257000_5617000 0.02
R_VDD1_788 METAL6_257000_5617000 METAL6_257000_5619000 0.004
R_VDD1_789 METAL6_257000_5619000 METAL6_257000_5753000 0.268
R_VDD1_790 METAL6_257000_5753000 METAL6_257000_5765000 0.024
R_VDD1_791 METAL6_555000_5065000 METAL6_543000_5065000 0.024
R_VDD1_792 METAL5_312000_681000 METAL4_312000_681000 0.1
R_VDD1_793 METAL4_312000_681000 METAL4_312000_693000 0.096
R_VDD1_794 METAL4_312000_693000 METAL4_312000_705000 0.096
R_VDD1_795 METAL4_312000_705000 METAL4_314000_705000 0.016
R_VDD1_796 METAL4_314000_705000 METAL4_316000_705000 0.016
R_VDD1_797 METAL4_316000_705000 METAL4_316000_707000 0.016
R_VDD1_798 METAL4_316000_707000 METAL4_316000_717000 0.08
R_VDD1_799 METAL4_316000_717000 METAL4_316000_729000 0.096
R_VDD1_800 METAL4_316000_729000 METAL4_316000_757000 0.224
R_VDD1_801 METAL4_316000_757000 METAL4_316000_769000 0.096
R_VDD1_802 METAL4_316000_769000 METAL4_316000_781000 0.096
R_VDD1_803 METAL4_316000_781000 METAL4_316000_793000 0.096
R_VDD1_804 METAL4_316000_793000 METAL4_317000_793000 0.008
R_VDD1_805 METAL4_317000_793000 METAL4_318000_793000 0.008
R_VDD1_806 METAL4_318000_793000 METAL4_324000_793000 0.048
R_VDD1_807 METAL4_324000_793000 METAL4_326000_793000 0.016
R_VDD1_808 METAL4_326000_793000 METAL4_328000_793000 0.016
R_VDD1_809 METAL4_328000_793000 METAL4_329000_793000 0.008
R_VDD1_810 METAL4_329000_793000 METAL4_330000_793000 0.008
R_VDD1_811 METAL4_330000_793000 METAL4_336000_793000 0.048
R_VDD1_812 METAL4_336000_793000 METAL4_338000_793000 0.016
R_VDD1_813 METAL4_338000_793000 METAL4_338000_805000 0.096
R_VDD1_814 METAL4_338000_805000 METAL4_338000_817000 0.096
R_VDD1_815 METAL4_338000_817000 METAL4_338000_829000 0.096
R_VDD1_816 METAL4_338000_829000 METAL4_338000_841000 0.096
R_VDD1_817 METAL4_338000_841000 METAL4_338000_853000 0.096
R_VDD1_818 METAL4_338000_853000 METAL4_338000_857000 0.032
R_VDD1_819 METAL4_338000_857000 METAL4_340000_857000 0.016
R_VDD1_820 METAL4_340000_857000 METAL4_342000_857000 0.016
R_VDD1_821 METAL4_342000_857000 METAL4_348000_857000 0.048
R_VDD1_822 METAL4_348000_857000 METAL4_350000_857000 0.016
R_VDD1_823 METAL4_350000_857000 METAL4_350000_865000 0.064
R_VDD1_824 METAL4_350000_865000 METAL4_350000_869000 0.032
R_VDD1_825 METAL4_350000_869000 METAL4_350000_877000 0.064
R_VDD1_826 METAL4_350000_877000 METAL4_350000_881000 0.032
R_VDD1_827 METAL4_350000_881000 METAL4_352000_881000 0.016
R_VDD1_828 METAL4_352000_881000 METAL4_354000_881000 0.016
R_VDD1_829 METAL4_354000_881000 METAL4_360000_881000 0.048
R_VDD1_830 METAL4_360000_881000 METAL4_362000_881000 0.016
R_VDD1_831 METAL4_362000_881000 METAL4_364000_881000 0.016
R_VDD1_832 METAL4_364000_881000 METAL4_366000_881000 0.016
R_VDD1_833 METAL4_366000_881000 METAL4_372000_881000 0.048
R_VDD1_834 METAL4_372000_881000 METAL4_374000_881000 0.016
R_VDD1_835 METAL4_374000_881000 METAL4_374000_889000 0.064
R_VDD1_836 METAL4_374000_889000 METAL4_374000_893000 0.032
R_VDD1_837 METAL4_374000_893000 METAL4_374000_901000 0.064
R_VDD1_838 METAL4_374000_901000 METAL4_374000_905000 0.032
R_VDD1_839 METAL4_374000_905000 METAL4_374000_913000 0.064
R_VDD1_840 METAL4_374000_913000 METAL4_374000_917000 0.032
R_VDD1_841 METAL4_374000_917000 METAL4_374000_929000 0.096
R_VDD1_842 METAL4_374000_929000 METAL4_374000_941000 0.096
R_VDD1_843 METAL4_374000_941000 METAL4_374000_953000 0.096
R_VDD1_844 METAL4_374000_953000 METAL4_374000_965000 0.096
R_VDD1_845 METAL4_374000_965000 METAL4_374000_977000 0.096
R_VDD1_846 METAL4_374000_977000 METAL4_374000_989000 0.096
R_VDD1_847 METAL4_374000_989000 METAL4_374000_1001000 0.096
R_VDD1_848 METAL4_374000_1001000 METAL4_374000_1013000 0.096
R_VDD1_849 METAL4_374000_1013000 METAL5_374000_1013000 0.1
R_VDD1_850 METAL5_374000_1013000 METAL5_374000_1025000 0.048
R_VDD1_851 METAL5_374000_1025000 METAL5_374000_1041000 0.064
R_VDD1_852 METAL5_374000_1041000 METAL5_374000_1053000 0.048
R_VDD1_853 METAL5_374000_1053000 METAL5_374000_1065000 0.048
R_VDD1_854 METAL5_374000_1065000 METAL4_374000_1065000 0.1
R_VDD1_855 METAL4_374000_1065000 METAL4_374000_1077000 0.096
R_VDD1_856 METAL4_374000_1077000 METAL4_374000_1089000 0.096
R_VDD1_857 METAL4_374000_1089000 METAL5_374000_1089000 0.1
R_VDD1_858 METAL5_374000_1089000 METAL5_374000_1101000 0.048
R_VDD1_859 METAL5_374000_1101000 METAL5_374000_1113000 0.048
R_VDD1_860 METAL5_374000_1113000 METAL5_374000_1153000 0.16
R_VDD1_861 METAL5_374000_1153000 METAL4_374000_1153000 0.1
R_VDD1_862 METAL4_374000_1153000 METAL4_374000_1165000 0.096
R_VDD1_863 METAL4_374000_1165000 METAL4_374000_1177000 0.096
R_VDD1_864 METAL4_374000_1177000 METAL4_374000_1189000 0.096
R_VDD1_865 METAL4_374000_1189000 METAL4_374000_1201000 0.096
R_VDD1_866 METAL4_374000_1201000 METAL4_374000_1205000 0.032
R_VDD1_867 METAL4_374000_1205000 METAL4_374000_1217000 0.096
R_VDD1_868 METAL4_374000_1217000 METAL4_374000_1229000 0.096
R_VDD1_869 METAL4_374000_1229000 METAL4_376000_1229000 0.016
R_VDD1_870 METAL4_376000_1229000 METAL4_378000_1229000 0.016
R_VDD1_871 METAL4_378000_1229000 METAL4_384000_1229000 0.048
R_VDD1_872 METAL4_384000_1229000 METAL4_386000_1229000 0.016
R_VDD1_873 METAL4_386000_1229000 METAL4_386000_1241000 0.096
R_VDD1_874 METAL4_386000_1241000 METAL4_388000_1241000 0.016
R_VDD1_875 METAL4_388000_1241000 METAL4_390000_1241000 0.016
R_VDD1_876 METAL4_390000_1241000 METAL4_396000_1241000 0.048
R_VDD1_877 METAL4_396000_1241000 METAL4_398000_1241000 0.016
R_VDD1_878 METAL4_398000_1241000 METAL4_398000_1253000 0.096
R_VDD1_879 METAL4_398000_1253000 METAL4_398000_1265000 0.096
R_VDD1_880 METAL4_398000_1265000 METAL4_398000_1277000 0.096
R_VDD1_881 METAL4_398000_1277000 METAL4_398000_1289000 0.096
R_VDD1_882 METAL4_398000_1289000 METAL5_398000_1289000 0.1
R_VDD1_883 METAL5_398000_1289000 METAL5_398000_1301000 0.048
R_VDD1_884 METAL5_398000_1301000 METAL5_398000_1333000 0.128
R_VDD1_885 METAL5_398000_1333000 METAL5_398000_1345000 0.048
R_VDD1_886 METAL5_398000_1345000 METAL5_398000_1357000 0.048
R_VDD1_887 METAL5_398000_1357000 METAL5_398000_1369000 0.048
R_VDD1_888 METAL5_398000_1369000 METAL5_398000_1381000 0.048
R_VDD1_889 METAL5_398000_1381000 METAL5_398000_1393000 0.048
R_VDD1_890 METAL5_398000_1393000 METAL5_396000_1393000 0.008
R_VDD1_891 METAL5_396000_1393000 METAL5_390000_1393000 0.024
R_VDD1_892 METAL5_390000_1393000 METAL5_388000_1393000 0.008
R_VDD1_893 METAL5_388000_1393000 METAL5_386000_1393000 0.008
R_VDD1_894 METAL5_386000_1393000 METAL4_386000_1393000 0.1
R_VDD1_895 METAL4_386000_1393000 METAL4_386000_1405000 0.096
R_VDD1_896 METAL4_386000_1405000 METAL4_386000_1407000 0.016
R_VDD1_897 METAL4_386000_1407000 METAL4_386000_1417000 0.08
R_VDD1_898 METAL4_386000_1417000 METAL5_386000_1417000 0.1
R_VDD1_899 METAL5_386000_1417000 METAL5_386000_1429000 0.048
R_VDD1_900 METAL5_386000_1429000 METAL5_386000_1505000 0.304
R_VDD1_901 METAL5_386000_1505000 METAL5_386000_1517000 0.048
R_VDD1_902 METAL5_386000_1517000 METAL5_386000_1529000 0.048
R_VDD1_903 METAL5_386000_1529000 METAL5_386000_1541000 0.048
R_VDD1_904 METAL5_386000_1541000 METAL4_386000_1541000 0.1
R_VDD1_905 METAL4_386000_1541000 METAL4_386000_1553000 0.096
R_VDD1_906 METAL4_386000_1553000 METAL4_386000_1565000 0.096
R_VDD1_907 METAL4_386000_1565000 METAL5_386000_1565000 0.1
R_VDD1_908 METAL5_386000_1565000 METAL5_386000_1577000 0.048
R_VDD1_909 METAL5_386000_1577000 METAL5_386000_1589000 0.048
R_VDD1_910 METAL5_386000_1589000 METAL5_386000_1605000 0.064
R_VDD1_911 METAL5_386000_1605000 METAL5_386000_1617000 0.048
R_VDD1_912 METAL5_386000_1617000 METAL5_386000_1629000 0.048
R_VDD1_913 METAL5_386000_1629000 METAL5_386000_1641000 0.048
R_VDD1_914 METAL5_386000_1641000 METAL4_386000_1641000 0.1
R_VDD1_915 METAL4_386000_1641000 METAL4_386000_1653000 0.096
R_VDD1_916 METAL4_386000_1653000 METAL4_386000_1665000 0.096
R_VDD1_917 METAL4_386000_1665000 METAL4_386000_1677000 0.096
R_VDD1_918 METAL4_386000_1677000 METAL4_386000_1689000 0.096
R_VDD1_919 METAL4_386000_1689000 METAL4_386000_1701000 0.096
R_VDD1_920 METAL4_386000_1701000 METAL4_386000_1753000 0.416
R_VDD1_921 METAL4_386000_1753000 METAL4_386000_1765000 0.096
R_VDD1_922 METAL4_386000_1765000 METAL4_386000_1777000 0.096
R_VDD1_923 METAL4_386000_1777000 METAL4_386000_1789000 0.096
R_VDD1_924 METAL4_386000_1789000 METAL4_386000_1793000 0.032
R_VDD1_925 METAL4_386000_1793000 METAL4_386000_1805000 0.096
R_VDD1_926 METAL4_386000_1805000 METAL4_386000_1817000 0.096
R_VDD1_927 METAL4_386000_1817000 METAL4_386000_1829000 0.096
R_VDD1_928 METAL4_386000_1829000 METAL4_386000_1841000 0.096
R_VDD1_929 METAL4_386000_1841000 METAL4_386000_1853000 0.096
R_VDD1_930 METAL4_386000_1853000 METAL4_386000_1865000 0.096
R_VDD1_931 METAL4_386000_1865000 METAL4_386000_1877000 0.096
R_VDD1_932 METAL4_386000_1877000 METAL4_386000_1905000 0.224
R_VDD1_933 METAL4_386000_1905000 METAL4_386000_1917000 0.096
R_VDD1_934 METAL4_386000_1917000 METAL4_386000_1929000 0.096
R_VDD1_935 METAL4_386000_1929000 METAL4_386000_1941000 0.096
R_VDD1_936 METAL4_386000_1941000 METAL4_386000_1953000 0.096
R_VDD1_937 METAL4_386000_1953000 METAL4_386000_1965000 0.096
R_VDD1_938 METAL4_386000_1965000 METAL4_386000_1977000 0.096
R_VDD1_939 METAL4_386000_1977000 METAL4_386000_1989000 0.096
R_VDD1_940 METAL4_386000_1989000 METAL4_386000_2001000 0.096
R_VDD1_941 METAL4_386000_2001000 METAL4_388000_2001000 0.016
R_VDD1_942 METAL4_388000_2001000 METAL4_390000_2001000 0.016
R_VDD1_943 METAL4_390000_2001000 METAL4_396000_2001000 0.048
R_VDD1_944 METAL4_396000_2001000 METAL4_398000_2001000 0.016
R_VDD1_945 METAL4_398000_2001000 METAL4_400000_2001000 0.016
R_VDD1_946 METAL4_400000_2001000 METAL4_402000_2001000 0.016
R_VDD1_947 METAL4_402000_2001000 METAL4_408000_2001000 0.048
R_VDD1_948 METAL4_408000_2001000 METAL4_410000_2001000 0.016
R_VDD1_949 METAL4_410000_2001000 METAL4_412000_2001000 0.016
R_VDD1_950 METAL4_412000_2001000 METAL4_414000_2001000 0.016
R_VDD1_951 METAL4_414000_2001000 METAL4_416000_2001000 0.016
R_VDD1_952 METAL4_416000_2001000 METAL4_420000_2001000 0.032
R_VDD1_953 METAL4_420000_2001000 METAL4_422000_2001000 0.016
R_VDD1_954 METAL4_422000_2001000 METAL4_424000_2001000 0.016
R_VDD1_955 METAL4_424000_2001000 METAL4_426000_2001000 0.016
R_VDD1_956 METAL4_426000_2001000 METAL4_428000_2001000 0.016
R_VDD1_957 METAL4_428000_2001000 METAL4_432000_2001000 0.032
R_VDD1_958 METAL4_432000_2001000 METAL4_434000_2001000 0.016
R_VDD1_959 METAL4_434000_2001000 METAL4_436000_2001000 0.016
R_VDD1_960 METAL4_436000_2001000 METAL4_438000_2001000 0.016
R_VDD1_961 METAL4_438000_2001000 METAL4_440000_2001000 0.016
R_VDD1_962 METAL4_440000_2001000 METAL4_444000_2001000 0.032
R_VDD1_963 METAL4_444000_2001000 METAL4_446000_2001000 0.016
R_VDD1_964 METAL4_446000_2001000 METAL5_446000_2001000 0.1
R_VDD1_965 METAL5_446000_2001000 METAL5_446000_2013000 0.048
R_VDD1_966 METAL5_446000_2013000 METAL5_446000_2093000 0.32
R_VDD1_967 METAL5_446000_2093000 METAL5_446000_2107000 0.056
R_VDD1_968 METAL5_446000_2107000 METAL5_446000_2217000 0.44
R_VDD1_969 METAL5_446000_2217000 METAL5_446000_2229000 0.048
R_VDD1_970 METAL5_446000_2229000 METAL5_446000_2241000 0.048
R_VDD1_971 METAL5_446000_2241000 METAL5_446000_2253000 0.048
R_VDD1_972 METAL5_446000_2253000 METAL5_446000_2265000 0.048
R_VDD1_973 METAL5_446000_2265000 METAL5_446000_2277000 0.048
R_VDD1_974 METAL5_446000_2277000 METAL5_446000_2289000 0.048
R_VDD1_975 METAL5_446000_2289000 METAL5_446000_2341000 0.208
R_VDD1_976 METAL5_446000_2341000 METAL5_446000_2353000 0.048
R_VDD1_977 METAL5_446000_2353000 METAL5_446000_2365000 0.048
R_VDD1_978 METAL5_446000_2365000 METAL5_446000_2377000 0.048
R_VDD1_979 METAL5_446000_2377000 METAL5_446000_2389000 0.048
R_VDD1_980 METAL5_446000_2389000 METAL5_446000_2401000 0.048
R_VDD1_981 METAL5_446000_2401000 METAL5_446000_2453000 0.208
R_VDD1_982 METAL5_446000_2453000 METAL5_446000_2465000 0.048
R_VDD1_983 METAL5_446000_2465000 METAL5_446000_2477000 0.048
R_VDD1_984 METAL5_446000_2477000 METAL5_446000_2489000 0.048
R_VDD1_985 METAL5_446000_2489000 METAL5_446000_2553000 0.256
R_VDD1_986 METAL5_446000_2553000 METAL5_446000_2565000 0.048
R_VDD1_987 METAL5_446000_2565000 METAL5_446000_2577000 0.048
R_VDD1_988 METAL5_446000_2577000 METAL5_446000_2593000 0.064
R_VDD1_989 METAL5_446000_2593000 METAL5_446000_2605000 0.048
R_VDD1_990 METAL5_446000_2605000 METAL5_446000_2617000 0.048
R_VDD1_991 METAL5_446000_2617000 METAL5_446000_2629000 0.048
R_VDD1_992 METAL5_446000_2629000 METAL5_446000_2641000 0.048
R_VDD1_993 METAL5_446000_2641000 METAL5_448000_2641000 0.008
R_VDD1_994 METAL5_448000_2641000 METAL5_450000_2641000 0.008
R_VDD1_995 METAL5_450000_2641000 METAL5_452000_2641000 0.008
R_VDD1_996 METAL5_452000_2641000 METAL5_458000_2641000 0.024
R_VDD1_997 METAL5_458000_2641000 METAL4_458000_2641000 0.1
R_VDD1_998 METAL4_458000_2641000 METAL4_460000_2641000 0.016
R_VDD1_999 METAL4_460000_2641000 METAL4_462000_2641000 0.016
R_VDD1_1000 METAL4_462000_2641000 METAL4_464000_2641000 0.016
R_VDD1_1001 METAL4_464000_2641000 METAL4_470000_2641000 0.048
R_VDD1_1002 METAL4_470000_2641000 METAL4_472000_2641000 0.016
R_VDD1_1003 METAL4_472000_2641000 METAL4_474000_2641000 0.016
R_VDD1_1004 METAL4_474000_2641000 METAL4_476000_2641000 0.016
R_VDD1_1005 METAL4_476000_2641000 METAL4_476000_2653000 0.096
R_VDD1_1006 METAL4_476000_2653000 METAL4_476000_2665000 0.096
R_VDD1_1007 METAL4_476000_2665000 METAL4_476000_2677000 0.096
R_VDD1_1008 METAL4_476000_2677000 METAL4_476000_2689000 0.096
R_VDD1_1009 METAL4_476000_2689000 METAL4_476000_2701000 0.096
R_VDD1_1010 METAL4_476000_2701000 METAL5_476000_2701000 0.1
R_VDD1_1011 METAL5_476000_2701000 METAL5_476000_2713000 0.048
R_VDD1_1012 METAL5_476000_2713000 METAL5_476000_2769000 0.224
R_VDD1_1013 METAL5_476000_2769000 METAL5_476000_2781000 0.048
R_VDD1_1014 METAL5_476000_2781000 METAL5_476000_2793000 0.048
R_VDD1_1015 METAL5_476000_2793000 METAL5_482000_2793000 0.024
R_VDD1_1016 METAL5_482000_2793000 METAL5_482000_2805000 0.048
R_VDD1_1017 METAL5_482000_2805000 METAL5_482000_2807000 0.008
R_VDD1_1018 METAL5_482000_2807000 METAL5_482000_2817000 0.04
R_VDD1_1019 METAL5_482000_2817000 METAL5_482000_2941000 0.496
R_VDD1_1020 METAL5_482000_2941000 METAL4_482000_2941000 0.1
R_VDD1_1021 METAL4_482000_2941000 METAL4_476000_2941000 0.048
R_VDD1_1022 METAL4_476000_2941000 METAL4_474000_2941000 0.016
R_VDD1_1023 METAL4_474000_2941000 METAL4_472000_2941000 0.016
R_VDD1_1024 METAL4_472000_2941000 METAL4_470000_2941000 0.016
R_VDD1_1025 METAL4_470000_2941000 METAL4_464000_2941000 0.048
R_VDD1_1026 METAL4_464000_2941000 METAL4_462000_2941000 0.016
R_VDD1_1027 METAL4_462000_2941000 METAL4_460000_2941000 0.016
R_VDD1_1028 METAL4_460000_2941000 METAL4_458000_2941000 0.016
R_VDD1_1029 METAL4_458000_2941000 METAL4_452000_2941000 0.048
R_VDD1_1030 METAL4_452000_2941000 METAL4_450000_2941000 0.016
R_VDD1_1031 METAL4_450000_2941000 METAL4_448000_2941000 0.016
R_VDD1_1032 METAL4_448000_2941000 METAL4_446000_2941000 0.016
R_VDD1_1033 METAL4_446000_2941000 METAL4_444000_2941000 0.016
R_VDD1_1034 METAL4_444000_2941000 METAL4_440000_2941000 0.032
R_VDD1_1035 METAL4_440000_2941000 METAL4_438000_2941000 0.016
R_VDD1_1036 METAL4_438000_2941000 METAL4_436000_2941000 0.016
R_VDD1_1037 METAL4_436000_2941000 METAL4_434000_2941000 0.016
R_VDD1_1038 METAL4_434000_2941000 METAL5_434000_2941000 0.1
R_VDD1_1039 METAL5_434000_2941000 METAL5_434000_2953000 0.048
R_VDD1_1040 METAL5_434000_2953000 METAL5_434000_2965000 0.048
R_VDD1_1041 METAL5_434000_2965000 METAL5_434000_2977000 0.048
R_VDD1_1042 METAL5_434000_2977000 METAL5_434000_2989000 0.048
R_VDD1_1043 METAL5_434000_2989000 METAL5_434000_3001000 0.048
R_VDD1_1044 METAL5_434000_3001000 METAL5_434000_3053000 0.208
R_VDD1_1045 METAL5_434000_3053000 METAL5_434000_3065000 0.048
R_VDD1_1046 METAL5_434000_3065000 METAL5_434000_3077000 0.048
R_VDD1_1047 METAL5_434000_3077000 METAL5_434000_3089000 0.048
R_VDD1_1048 METAL5_434000_3089000 METAL5_434000_3101000 0.048
R_VDD1_1049 METAL5_434000_3101000 METAL5_434000_3153000 0.208
R_VDD1_1050 METAL5_434000_3153000 METAL5_434000_3165000 0.048
R_VDD1_1051 METAL5_434000_3165000 METAL5_434000_3177000 0.048
R_VDD1_1052 METAL5_434000_3177000 METAL5_434000_3189000 0.048
R_VDD1_1053 METAL5_434000_3189000 METAL5_434000_3253000 0.256
R_VDD1_1054 METAL5_434000_3253000 METAL5_434000_3265000 0.048
R_VDD1_1055 METAL5_434000_3265000 METAL5_434000_3277000 0.048
R_VDD1_1056 METAL5_434000_3277000 METAL5_434000_3289000 0.048
R_VDD1_1057 METAL5_434000_3289000 METAL5_434000_3341000 0.208
R_VDD1_1058 METAL5_434000_3341000 METAL5_434000_3353000 0.048
R_VDD1_1059 METAL5_434000_3353000 METAL5_434000_3365000 0.048
R_VDD1_1060 METAL5_434000_3365000 METAL5_434000_3377000 0.048
R_VDD1_1061 METAL5_434000_3377000 METAL4_434000_3377000 0.1
R_VDD1_1062 METAL4_434000_3377000 METAL4_434000_3389000 0.096
R_VDD1_1063 METAL4_434000_3389000 METAL4_434000_3401000 0.096
R_VDD1_1064 METAL4_434000_3401000 METAL4_434000_3413000 0.096
R_VDD1_1065 METAL4_434000_3413000 METAL5_434000_3413000 0.1
R_VDD1_1066 METAL5_434000_3413000 METAL5_434000_3425000 0.048
R_VDD1_1067 METAL5_434000_3425000 METAL5_434000_3481000 0.224
R_VDD1_1068 METAL5_434000_3481000 METAL5_434000_3493000 0.048
R_VDD1_1069 METAL5_434000_3493000 METAL5_434000_3495000 0.008
R_VDD1_1070 METAL5_434000_3495000 METAL5_434000_3505000 0.04
R_VDD1_1071 METAL5_434000_3505000 METAL5_434000_3507000 0.008
R_VDD1_1072 METAL5_434000_3507000 METAL5_434000_3519000 0.048
R_VDD1_1073 METAL5_434000_3519000 METAL5_434000_3641000 0.488
R_VDD1_1074 METAL5_434000_3641000 METAL5_434000_3653000 0.048
R_VDD1_1075 METAL5_434000_3653000 METAL5_434000_3665000 0.048
R_VDD1_1076 METAL5_434000_3665000 METAL5_434000_3677000 0.048
R_VDD1_1077 METAL5_434000_3677000 METAL5_434000_3689000 0.048
R_VDD1_1078 METAL5_434000_3689000 METAL5_434000_3753000 0.256
R_VDD1_1079 METAL5_434000_3753000 METAL5_434000_3765000 0.048
R_VDD1_1080 METAL5_434000_3765000 METAL5_434000_3777000 0.048
R_VDD1_1081 METAL5_434000_3777000 METAL5_434000_3789000 0.048
R_VDD1_1082 METAL5_434000_3789000 METAL5_434000_3853000 0.256
R_VDD1_1083 METAL5_434000_3853000 METAL5_434000_3865000 0.048
R_VDD1_1084 METAL5_434000_3865000 METAL5_434000_3877000 0.048
R_VDD1_1085 METAL5_434000_3877000 METAL5_434000_3941000 0.256
R_VDD1_1086 METAL5_434000_3941000 METAL5_434000_3953000 0.048
R_VDD1_1087 METAL5_434000_3953000 METAL5_434000_3965000 0.048
R_VDD1_1088 METAL5_434000_3965000 METAL5_434000_3977000 0.048
R_VDD1_1089 METAL5_434000_3977000 METAL5_434000_4029000 0.208
R_VDD1_1090 METAL5_434000_4029000 METAL4_434000_4029000 0.1
R_VDD1_1091 METAL4_434000_4029000 METAL4_434000_4041000 0.096
R_VDD1_1092 METAL4_434000_4041000 METAL4_434000_4053000 0.096
R_VDD1_1093 METAL4_434000_4053000 METAL4_434000_4065000 0.096
R_VDD1_1094 METAL4_434000_4065000 METAL4_434000_4077000 0.096
R_VDD1_1095 METAL4_434000_4077000 METAL4_434000_4089000 0.096
R_VDD1_1096 METAL4_434000_4089000 METAL4_434000_4101000 0.096
R_VDD1_1097 METAL4_434000_4101000 METAL4_434000_4133000 0.256
R_VDD1_1098 METAL4_434000_4133000 METAL4_434000_4145000 0.096
R_VDD1_1099 METAL4_434000_4145000 METAL4_434000_4157000 0.096
R_VDD1_1100 METAL4_434000_4157000 METAL4_434000_4169000 0.096
R_VDD1_1101 METAL4_434000_4169000 METAL4_434000_4181000 0.096
R_VDD1_1102 METAL4_434000_4181000 METAL4_434000_4193000 0.096
R_VDD1_1103 METAL4_434000_4193000 METAL4_434000_4195000 0.016
R_VDD1_1104 METAL4_434000_4195000 METAL4_434000_4205000 0.08
R_VDD1_1105 METAL4_434000_4205000 METAL5_434000_4205000 0.1
R_VDD1_1106 METAL5_434000_4205000 METAL5_432000_4205000 0.008
R_VDD1_1107 METAL5_432000_4205000 METAL5_428000_4205000 0.016
R_VDD1_1108 METAL5_428000_4205000 METAL5_428000_4207000 0.008
R_VDD1_1109 METAL5_428000_4207000 METAL5_428000_4217000 0.04
R_VDD1_1110 METAL5_428000_4217000 METAL5_428000_4219000 0.008
R_VDD1_1111 METAL5_428000_4219000 METAL5_428000_4329000 0.44
R_VDD1_1112 METAL5_428000_4329000 METAL5_428000_4341000 0.048
R_VDD1_1113 METAL5_428000_4341000 METAL5_428000_4353000 0.048
R_VDD1_1114 METAL5_428000_4353000 METAL5_428000_4365000 0.048
R_VDD1_1115 METAL5_428000_4365000 METAL5_428000_4377000 0.048
R_VDD1_1116 METAL5_428000_4377000 METAL5_428000_4389000 0.048
R_VDD1_1117 METAL5_428000_4389000 METAL5_428000_4453000 0.256
R_VDD1_1118 METAL5_428000_4453000 METAL5_428000_4465000 0.048
R_VDD1_1119 METAL5_428000_4465000 METAL5_428000_4477000 0.048
R_VDD1_1120 METAL5_428000_4477000 METAL5_428000_4489000 0.048
R_VDD1_1121 METAL5_428000_4489000 METAL5_428000_4553000 0.256
R_VDD1_1122 METAL5_428000_4553000 METAL5_428000_4565000 0.048
R_VDD1_1123 METAL5_428000_4565000 METAL5_428000_4577000 0.048
R_VDD1_1124 METAL5_428000_4577000 METAL5_428000_4605000 0.112
R_VDD1_1125 METAL5_428000_4605000 METAL5_428000_4617000 0.048
R_VDD1_1126 METAL5_428000_4617000 METAL5_426000_4617000 0.008
R_VDD1_1127 METAL5_426000_4617000 METAL5_424000_4617000 0.008
R_VDD1_1128 METAL5_424000_4617000 METAL5_422000_4617000 0.008
R_VDD1_1129 METAL5_422000_4617000 METAL5_420000_4617000 0.008
R_VDD1_1130 METAL5_420000_4617000 METAL5_416000_4617000 0.016
R_VDD1_1131 METAL5_416000_4617000 METAL5_416000_4629000 0.048
R_VDD1_1132 METAL5_416000_4629000 METAL5_416000_4641000 0.048
R_VDD1_1133 METAL5_416000_4641000 METAL5_416000_4653000 0.048
R_VDD1_1134 METAL5_416000_4653000 METAL5_416000_4665000 0.048
R_VDD1_1135 METAL5_416000_4665000 METAL5_416000_4677000 0.048
R_VDD1_1136 METAL5_416000_4677000 METAL5_416000_4689000 0.048
R_VDD1_1137 METAL5_416000_4689000 METAL5_416000_4701000 0.048
R_VDD1_1138 METAL5_416000_4701000 METAL5_416000_4729000 0.112
R_VDD1_1139 METAL5_416000_4729000 METAL5_416000_4741000 0.048
R_VDD1_1140 METAL5_416000_4741000 METAL5_416000_4753000 0.048
R_VDD1_1141 METAL5_416000_4753000 METAL5_416000_4765000 0.048
R_VDD1_1142 METAL5_416000_4765000 METAL4_416000_4765000 0.1
R_VDD1_1143 METAL4_416000_4765000 METAL4_416000_4777000 0.096
R_VDD1_1144 METAL4_416000_4777000 METAL4_416000_4789000 0.096
R_VDD1_1145 METAL4_416000_4789000 METAL5_416000_4789000 0.1
R_VDD1_1146 METAL5_416000_4789000 METAL5_416000_4801000 0.048
R_VDD1_1147 METAL5_416000_4801000 METAL5_416000_4893000 0.368
R_VDD1_1148 METAL5_416000_4893000 METAL5_416000_4907000 0.056
R_VDD1_1149 METAL5_416000_4907000 METAL5_416000_5041000 0.536
R_VDD1_1150 METAL5_416000_5041000 METAL5_416000_5053000 0.048
R_VDD1_1151 METAL5_416000_5053000 METAL5_416000_5065000 0.048
R_VDD1_1152 METAL5_416000_5065000 METAL5_420000_5065000 0.016
R_VDD1_1153 METAL5_420000_5065000 METAL5_422000_5065000 0.008
R_VDD1_1154 METAL5_422000_5065000 METAL5_424000_5065000 0.008
R_VDD1_1155 METAL5_424000_5065000 METAL5_426000_5065000 0.008
R_VDD1_1156 METAL5_426000_5065000 METAL5_428000_5065000 0.008
R_VDD1_1157 METAL5_428000_5065000 METAL5_432000_5065000 0.016
R_VDD1_1158 METAL5_432000_5065000 METAL5_434000_5065000 0.008
R_VDD1_1159 METAL5_434000_5065000 METAL5_436000_5065000 0.008
R_VDD1_1160 METAL5_436000_5065000 METAL5_438000_5065000 0.008
R_VDD1_1161 METAL5_438000_5065000 METAL5_440000_5065000 0.008
R_VDD1_1162 METAL5_440000_5065000 METAL5_444000_5065000 0.016
R_VDD1_1163 METAL5_444000_5065000 METAL5_446000_5065000 0.008
R_VDD1_1164 METAL5_446000_5065000 METAL5_448000_5065000 0.008
R_VDD1_1165 METAL5_448000_5065000 METAL5_450000_5065000 0.008
R_VDD1_1166 METAL5_450000_5065000 METAL5_452000_5065000 0.008
R_VDD1_1167 METAL5_452000_5065000 METAL5_458000_5065000 0.024
R_VDD1_1168 METAL5_458000_5065000 METAL5_460000_5065000 0.008
R_VDD1_1169 METAL5_460000_5065000 METAL5_462000_5065000 0.008
R_VDD1_1170 METAL5_462000_5065000 METAL5_464000_5065000 0.008
R_VDD1_1171 METAL5_464000_5065000 METAL5_470000_5065000 0.024
R_VDD1_1172 METAL5_470000_5065000 METAL5_472000_5065000 0.008
R_VDD1_1173 METAL5_472000_5065000 METAL5_474000_5065000 0.008
R_VDD1_1174 METAL5_474000_5065000 METAL5_476000_5065000 0.008
R_VDD1_1175 METAL5_476000_5065000 METAL5_482000_5065000 0.024
R_VDD1_1176 METAL5_482000_5065000 METAL5_483000_5065000 0.004
R_VDD1_1177 METAL5_483000_5065000 METAL5_484000_5065000 0.004
R_VDD1_1178 METAL5_484000_5065000 METAL5_486000_5065000 0.008
R_VDD1_1179 METAL5_486000_5065000 METAL5_488000_5065000 0.008
R_VDD1_1180 METAL5_488000_5065000 METAL5_494000_5065000 0.024
R_VDD1_1181 METAL5_494000_5065000 METAL5_495000_5065000 0.004
R_VDD1_1182 METAL5_495000_5065000 METAL5_496000_5065000 0.004
R_VDD1_1183 METAL5_496000_5065000 METAL5_498000_5065000 0.008
R_VDD1_1184 METAL5_498000_5065000 METAL5_500000_5065000 0.008
R_VDD1_1185 METAL5_500000_5065000 METAL5_507000_5065000 0.028
R_VDD1_1186 METAL5_507000_5065000 METAL5_508000_5065000 0.004
R_VDD1_1187 METAL5_508000_5065000 METAL5_510000_5065000 0.008
R_VDD1_1188 METAL5_510000_5065000 METAL5_512000_5065000 0.008
R_VDD1_1189 METAL5_512000_5065000 METAL5_519000_5065000 0.028
R_VDD1_1190 METAL5_519000_5065000 METAL4_519000_5065000 0.1
R_VDD1_1191 METAL4_519000_5065000 METAL4_522000_5065000 0.024
R_VDD1_1192 METAL4_522000_5065000 METAL4_524000_5065000 0.016
R_VDD1_1193 METAL4_524000_5065000 METAL4_531000_5065000 0.056
R_VDD1_1194 METAL4_531000_5065000 METAL4_536000_5065000 0.04
R_VDD1_1195 METAL4_536000_5065000 METAL4_543000_5065000 0.056
R_VDD1_1196 METAL4_543000_5065000 METAL5_543000_5065000 0.1
R_VDD1_1197 METAL5_543000_5065000 METAL6_543000_5065000 0.1
R_VDD1_1198 METAL6_245000_5065000 METAL6_257000_5065000 0.024
R_VDD1_1199 METAL5_390000_4907000 METAL5_388000_4907000 0.008
R_VDD1_1200 METAL5_388000_4907000 METAL5_386000_4907000 0.008
R_VDD1_1201 METAL5_386000_4907000 METAL5_384000_4907000 0.008
R_VDD1_1202 METAL5_384000_4907000 METAL5_378000_4907000 0.024
R_VDD1_1203 METAL5_378000_4907000 METAL5_376000_4907000 0.008
R_VDD1_1204 METAL5_376000_4907000 METAL5_374000_4907000 0.008
R_VDD1_1205 METAL5_374000_4907000 METAL5_372000_4907000 0.008
R_VDD1_1206 METAL5_372000_4907000 METAL5_366000_4907000 0.024
R_VDD1_1207 METAL5_366000_4907000 METAL5_364000_4907000 0.008
R_VDD1_1208 METAL5_364000_4907000 METAL5_362000_4907000 0.008
R_VDD1_1209 METAL5_362000_4907000 METAL5_360000_4907000 0.008
R_VDD1_1210 METAL5_360000_4907000 METAL5_354000_4907000 0.024
R_VDD1_1211 METAL5_354000_4907000 METAL5_352000_4907000 0.008
R_VDD1_1212 METAL5_352000_4907000 METAL5_350000_4907000 0.008
R_VDD1_1213 METAL5_350000_4907000 METAL5_348000_4907000 0.008
R_VDD1_1214 METAL5_348000_4907000 METAL5_342000_4907000 0.024
R_VDD1_1215 METAL5_342000_4907000 METAL5_340000_4907000 0.008
R_VDD1_1216 METAL5_340000_4907000 METAL5_338000_4907000 0.008
R_VDD1_1217 METAL5_338000_4907000 METAL5_336000_4907000 0.008
R_VDD1_1218 METAL5_336000_4907000 METAL5_330000_4907000 0.024
R_VDD1_1219 METAL5_330000_4907000 METAL5_329000_4907000 0.004
R_VDD1_1220 METAL5_329000_4907000 METAL5_328000_4907000 0.004
R_VDD1_1221 METAL5_328000_4907000 METAL5_326000_4907000 0.008
R_VDD1_1222 METAL5_326000_4907000 METAL5_324000_4907000 0.008
R_VDD1_1223 METAL5_324000_4907000 METAL5_318000_4907000 0.024
R_VDD1_1224 METAL5_318000_4907000 METAL5_317000_4907000 0.004
R_VDD1_1225 METAL5_317000_4907000 METAL5_316000_4907000 0.004
R_VDD1_1226 METAL5_316000_4907000 METAL5_314000_4907000 0.008
R_VDD1_1227 METAL5_314000_4907000 METAL5_312000_4907000 0.008
R_VDD1_1228 METAL5_312000_4907000 METAL5_306000_4907000 0.024
R_VDD1_1229 METAL5_306000_4907000 METAL5_305000_4907000 0.004
R_VDD1_1230 METAL5_305000_4907000 METAL5_304000_4907000 0.004
R_VDD1_1231 METAL5_304000_4907000 METAL5_302000_4907000 0.008
R_VDD1_1232 METAL5_302000_4907000 METAL5_300000_4907000 0.008
R_VDD1_1233 METAL5_300000_4907000 METAL5_294000_4907000 0.024
R_VDD1_1234 METAL5_294000_4907000 METAL5_293000_4907000 0.004
R_VDD1_1235 METAL5_293000_4907000 METAL5_292000_4907000 0.004
R_VDD1_1236 METAL5_292000_4907000 METAL5_290000_4907000 0.008
R_VDD1_1237 METAL5_290000_4907000 METAL5_288000_4907000 0.008
R_VDD1_1238 METAL5_288000_4907000 METAL5_282000_4907000 0.024
R_VDD1_1239 METAL5_282000_4907000 METAL5_281000_4907000 0.004
R_VDD1_1240 METAL5_281000_4907000 METAL5_280000_4907000 0.004
R_VDD1_1241 METAL5_280000_4907000 METAL5_278000_4907000 0.008
R_VDD1_1242 METAL5_278000_4907000 METAL5_276000_4907000 0.008
R_VDD1_1243 METAL5_276000_4907000 METAL5_270000_4907000 0.024
R_VDD1_1244 METAL5_270000_4907000 METAL5_269000_4907000 0.004
R_VDD1_1245 METAL5_269000_4907000 METAL5_266000_4907000 0.012
R_VDD1_1246 METAL5_266000_4907000 METAL5_264000_4907000 0.008
R_VDD1_1247 METAL5_264000_4907000 METAL5_258000_4907000 0.024
R_VDD1_1248 METAL5_258000_4907000 METAL5_257000_4907000 0.004
R_VDD1_1249 METAL5_257000_4907000 METAL6_257000_4907000 0.1
R_VDD1_1250 METAL6_257000_4907000 METAL6_257000_5041000 0.268
R_VDD1_1251 METAL6_257000_5041000 METAL6_257000_5053000 0.024
R_VDD1_1252 METAL6_257000_5053000 METAL6_257000_5065000 0.024
R_VDD1_1253 METAL6_555000_4365000 METAL6_543000_4365000 0.024
R_VDD1_1254 METAL4_374000_1077000 METAL4_376000_1077000 0.016
R_VDD1_1255 METAL4_376000_1077000 METAL4_378000_1077000 0.016
R_VDD1_1256 METAL4_378000_1077000 METAL4_384000_1077000 0.048
R_VDD1_1257 METAL4_384000_1077000 METAL4_386000_1077000 0.016
R_VDD1_1258 METAL4_386000_1077000 METAL4_386000_1089000 0.096
R_VDD1_1259 METAL4_386000_1089000 METAL4_386000_1101000 0.096
R_VDD1_1260 METAL4_386000_1101000 METAL4_386000_1113000 0.096
R_VDD1_1261 METAL4_386000_1113000 METAL4_386000_1141000 0.224
R_VDD1_1262 METAL4_386000_1141000 METAL4_386000_1153000 0.096
R_VDD1_1263 METAL4_386000_1153000 METAL4_386000_1165000 0.096
R_VDD1_1264 METAL4_386000_1165000 METAL4_386000_1177000 0.096
R_VDD1_1265 METAL4_386000_1177000 METAL4_386000_1189000 0.096
R_VDD1_1266 METAL4_386000_1189000 METAL4_386000_1201000 0.096
R_VDD1_1267 METAL4_386000_1201000 METAL4_386000_1205000 0.032
R_VDD1_1268 METAL4_386000_1205000 METAL4_386000_1217000 0.096
R_VDD1_1269 METAL4_386000_1217000 METAL4_388000_1217000 0.016
R_VDD1_1270 METAL4_388000_1217000 METAL4_390000_1217000 0.016
R_VDD1_1271 METAL4_390000_1217000 METAL4_396000_1217000 0.048
R_VDD1_1272 METAL4_396000_1217000 METAL4_398000_1217000 0.016
R_VDD1_1273 METAL4_398000_1217000 METAL4_398000_1229000 0.096
R_VDD1_1274 METAL4_398000_1229000 METAL4_400000_1229000 0.016
R_VDD1_1275 METAL4_400000_1229000 METAL4_402000_1229000 0.016
R_VDD1_1276 METAL4_402000_1229000 METAL4_404000_1229000 0.016
R_VDD1_1277 METAL4_404000_1229000 METAL4_408000_1229000 0.032
R_VDD1_1278 METAL4_408000_1229000 METAL4_410000_1229000 0.016
R_VDD1_1279 METAL4_410000_1229000 METAL4_410000_1241000 0.096
R_VDD1_1280 METAL4_410000_1241000 METAL4_410000_1253000 0.096
R_VDD1_1281 METAL4_410000_1253000 METAL4_410000_1265000 0.096
R_VDD1_1282 METAL4_410000_1265000 METAL4_410000_1277000 0.096
R_VDD1_1283 METAL4_410000_1277000 METAL4_410000_1289000 0.096
R_VDD1_1284 METAL4_410000_1289000 METAL5_410000_1289000 0.1
R_VDD1_1285 METAL5_410000_1289000 METAL5_410000_1301000 0.048
R_VDD1_1286 METAL5_410000_1301000 METAL5_410000_1333000 0.128
R_VDD1_1287 METAL5_410000_1333000 METAL5_410000_1345000 0.048
R_VDD1_1288 METAL5_410000_1345000 METAL5_410000_1357000 0.048
R_VDD1_1289 METAL5_410000_1357000 METAL5_410000_1369000 0.048
R_VDD1_1290 METAL5_410000_1369000 METAL5_410000_1381000 0.048
R_VDD1_1291 METAL5_410000_1381000 METAL5_410000_1393000 0.048
R_VDD1_1292 METAL5_410000_1393000 METAL4_410000_1393000 0.1
R_VDD1_1293 METAL4_410000_1393000 METAL4_410000_1405000 0.096
R_VDD1_1294 METAL4_410000_1405000 METAL4_410000_1407000 0.016
R_VDD1_1295 METAL4_410000_1407000 METAL4_410000_1417000 0.08
R_VDD1_1296 METAL4_410000_1417000 METAL4_410000_1429000 0.096
R_VDD1_1297 METAL4_410000_1429000 METAL4_410000_1505000 0.608
R_VDD1_1298 METAL4_410000_1505000 METAL4_410000_1517000 0.096
R_VDD1_1299 METAL4_410000_1517000 METAL4_410000_1529000 0.096
R_VDD1_1300 METAL4_410000_1529000 METAL4_410000_1541000 0.096
R_VDD1_1301 METAL4_410000_1541000 METAL4_410000_1553000 0.096
R_VDD1_1302 METAL4_410000_1553000 METAL4_410000_1565000 0.096
R_VDD1_1303 METAL4_410000_1565000 METAL4_410000_1577000 0.096
R_VDD1_1304 METAL4_410000_1577000 METAL4_410000_1589000 0.096
R_VDD1_1305 METAL4_410000_1589000 METAL4_410000_1605000 0.128
R_VDD1_1306 METAL4_410000_1605000 METAL4_410000_1617000 0.096
R_VDD1_1307 METAL4_410000_1617000 METAL4_410000_1629000 0.096
R_VDD1_1308 METAL4_410000_1629000 METAL4_410000_1641000 0.096
R_VDD1_1309 METAL4_410000_1641000 METAL4_410000_1653000 0.096
R_VDD1_1310 METAL4_410000_1653000 METAL4_410000_1665000 0.096
R_VDD1_1311 METAL4_410000_1665000 METAL4_410000_1677000 0.096
R_VDD1_1312 METAL4_410000_1677000 METAL4_410000_1689000 0.096
R_VDD1_1313 METAL4_410000_1689000 METAL4_410000_1701000 0.096
R_VDD1_1314 METAL4_410000_1701000 METAL4_410000_1753000 0.416
R_VDD1_1315 METAL4_410000_1753000 METAL4_410000_1765000 0.096
R_VDD1_1316 METAL4_410000_1765000 METAL4_410000_1777000 0.096
R_VDD1_1317 METAL4_410000_1777000 METAL4_410000_1789000 0.096
R_VDD1_1318 METAL4_410000_1789000 METAL4_412000_1789000 0.016
R_VDD1_1319 METAL4_412000_1789000 METAL4_414000_1789000 0.016
R_VDD1_1320 METAL4_414000_1789000 METAL4_416000_1789000 0.016
R_VDD1_1321 METAL4_416000_1789000 METAL4_420000_1789000 0.032
R_VDD1_1322 METAL4_420000_1789000 METAL4_422000_1789000 0.016
R_VDD1_1323 METAL4_422000_1789000 METAL4_424000_1789000 0.016
R_VDD1_1324 METAL4_424000_1789000 METAL4_426000_1789000 0.016
R_VDD1_1325 METAL4_426000_1789000 METAL4_428000_1789000 0.016
R_VDD1_1326 METAL4_428000_1789000 METAL4_432000_1789000 0.032
R_VDD1_1327 METAL4_432000_1789000 METAL4_434000_1789000 0.016
R_VDD1_1328 METAL4_434000_1789000 METAL4_436000_1789000 0.016
R_VDD1_1329 METAL4_436000_1789000 METAL4_438000_1789000 0.016
R_VDD1_1330 METAL4_438000_1789000 METAL4_440000_1789000 0.016
R_VDD1_1331 METAL4_440000_1789000 METAL4_444000_1789000 0.032
R_VDD1_1332 METAL4_444000_1789000 METAL4_446000_1789000 0.016
R_VDD1_1333 METAL4_446000_1789000 METAL4_448000_1789000 0.016
R_VDD1_1334 METAL4_448000_1789000 METAL4_450000_1789000 0.016
R_VDD1_1335 METAL4_450000_1789000 METAL4_452000_1789000 0.016
R_VDD1_1336 METAL4_452000_1789000 METAL4_458000_1789000 0.048
R_VDD1_1337 METAL4_458000_1789000 METAL4_460000_1789000 0.016
R_VDD1_1338 METAL4_460000_1789000 METAL4_462000_1789000 0.016
R_VDD1_1339 METAL4_462000_1789000 METAL4_464000_1789000 0.016
R_VDD1_1340 METAL4_464000_1789000 METAL4_470000_1789000 0.048
R_VDD1_1341 METAL4_470000_1789000 METAL4_472000_1789000 0.016
R_VDD1_1342 METAL4_472000_1789000 METAL4_474000_1789000 0.016
R_VDD1_1343 METAL4_474000_1789000 METAL4_476000_1789000 0.016
R_VDD1_1344 METAL4_476000_1789000 METAL4_482000_1789000 0.048
R_VDD1_1345 METAL4_482000_1789000 METAL4_483000_1789000 0.008
R_VDD1_1346 METAL4_483000_1789000 METAL4_484000_1789000 0.008
R_VDD1_1347 METAL4_484000_1789000 METAL4_486000_1789000 0.016
R_VDD1_1348 METAL4_486000_1789000 METAL4_488000_1789000 0.016
R_VDD1_1349 METAL4_488000_1789000 METAL4_494000_1789000 0.048
R_VDD1_1350 METAL4_494000_1789000 METAL4_495000_1789000 0.008
R_VDD1_1351 METAL4_495000_1789000 METAL4_496000_1789000 0.008
R_VDD1_1352 METAL4_496000_1789000 METAL4_498000_1789000 0.016
R_VDD1_1353 METAL4_498000_1789000 METAL4_500000_1789000 0.016
R_VDD1_1354 METAL4_500000_1789000 METAL4_507000_1789000 0.056
R_VDD1_1355 METAL4_507000_1789000 METAL4_508000_1789000 0.008
R_VDD1_1356 METAL4_508000_1789000 METAL4_510000_1789000 0.016
R_VDD1_1357 METAL4_510000_1789000 METAL4_512000_1789000 0.016
R_VDD1_1358 METAL4_512000_1789000 METAL4_519000_1789000 0.056
R_VDD1_1359 METAL4_519000_1789000 METAL4_522000_1789000 0.024
R_VDD1_1360 METAL4_522000_1789000 METAL4_524000_1789000 0.016
R_VDD1_1361 METAL4_524000_1789000 METAL4_531000_1789000 0.056
R_VDD1_1362 METAL4_531000_1789000 METAL5_531000_1789000 0.1
R_VDD1_1363 METAL5_531000_1789000 METAL5_531000_1793000 0.016
R_VDD1_1364 METAL5_531000_1793000 METAL5_531000_1805000 0.048
R_VDD1_1365 METAL5_531000_1805000 METAL5_531000_1817000 0.048
R_VDD1_1366 METAL5_531000_1817000 METAL5_531000_1829000 0.048
R_VDD1_1367 METAL5_531000_1829000 METAL5_531000_1841000 0.048
R_VDD1_1368 METAL5_531000_1841000 METAL5_531000_1853000 0.048
R_VDD1_1369 METAL5_531000_1853000 METAL5_531000_1865000 0.048
R_VDD1_1370 METAL5_531000_1865000 METAL5_531000_1877000 0.048
R_VDD1_1371 METAL5_531000_1877000 METAL5_531000_1905000 0.112
R_VDD1_1372 METAL5_531000_1905000 METAL5_531000_1917000 0.048
R_VDD1_1373 METAL5_531000_1917000 METAL5_531000_1929000 0.048
R_VDD1_1374 METAL5_531000_1929000 METAL4_531000_1929000 0.1
R_VDD1_1375 METAL4_531000_1929000 METAL4_531000_1941000 0.096
R_VDD1_1376 METAL4_531000_1941000 METAL4_531000_1953000 0.096
R_VDD1_1377 METAL4_531000_1953000 METAL4_531000_1965000 0.096
R_VDD1_1378 METAL4_531000_1965000 METAL4_531000_1977000 0.096
R_VDD1_1379 METAL4_531000_1977000 METAL4_531000_1989000 0.096
R_VDD1_1380 METAL4_531000_1989000 METAL4_531000_2001000 0.096
R_VDD1_1381 METAL4_531000_2001000 METAL4_524000_2001000 0.056
R_VDD1_1382 METAL4_524000_2001000 METAL4_522000_2001000 0.016
R_VDD1_1383 METAL4_522000_2001000 METAL4_519000_2001000 0.024
R_VDD1_1384 METAL4_519000_2001000 METAL4_512000_2001000 0.056
R_VDD1_1385 METAL4_512000_2001000 METAL4_510000_2001000 0.016
R_VDD1_1386 METAL4_510000_2001000 METAL4_508000_2001000 0.016
R_VDD1_1387 METAL4_508000_2001000 METAL4_507000_2001000 0.008
R_VDD1_1388 METAL4_507000_2001000 METAL4_500000_2001000 0.056
R_VDD1_1389 METAL4_500000_2001000 METAL4_498000_2001000 0.016
R_VDD1_1390 METAL4_498000_2001000 METAL4_496000_2001000 0.016
R_VDD1_1391 METAL4_496000_2001000 METAL4_495000_2001000 0.008
R_VDD1_1392 METAL4_495000_2001000 METAL4_494000_2001000 0.008
R_VDD1_1393 METAL4_494000_2001000 METAL4_488000_2001000 0.048
R_VDD1_1394 METAL4_488000_2001000 METAL4_486000_2001000 0.016
R_VDD1_1395 METAL4_486000_2001000 METAL4_484000_2001000 0.016
R_VDD1_1396 METAL4_484000_2001000 METAL4_483000_2001000 0.008
R_VDD1_1397 METAL4_483000_2001000 METAL4_482000_2001000 0.008
R_VDD1_1398 METAL4_482000_2001000 METAL4_476000_2001000 0.048
R_VDD1_1399 METAL4_476000_2001000 METAL4_474000_2001000 0.016
R_VDD1_1400 METAL4_474000_2001000 METAL4_472000_2001000 0.016
R_VDD1_1401 METAL4_472000_2001000 METAL4_470000_2001000 0.016
R_VDD1_1402 METAL4_470000_2001000 METAL4_464000_2001000 0.048
R_VDD1_1403 METAL4_464000_2001000 METAL4_462000_2001000 0.016
R_VDD1_1404 METAL4_462000_2001000 METAL4_460000_2001000 0.016
R_VDD1_1405 METAL4_460000_2001000 METAL4_458000_2001000 0.016
R_VDD1_1406 METAL4_458000_2001000 METAL5_458000_2001000 0.1
R_VDD1_1407 METAL5_458000_2001000 METAL5_458000_2013000 0.048
R_VDD1_1408 METAL5_458000_2013000 METAL5_458000_2093000 0.32
R_VDD1_1409 METAL5_458000_2093000 METAL5_458000_2107000 0.056
R_VDD1_1410 METAL5_458000_2107000 METAL5_458000_2217000 0.44
R_VDD1_1411 METAL5_458000_2217000 METAL5_458000_2229000 0.048
R_VDD1_1412 METAL5_458000_2229000 METAL5_458000_2241000 0.048
R_VDD1_1413 METAL5_458000_2241000 METAL5_458000_2253000 0.048
R_VDD1_1414 METAL5_458000_2253000 METAL5_458000_2265000 0.048
R_VDD1_1415 METAL5_458000_2265000 METAL5_458000_2277000 0.048
R_VDD1_1416 METAL5_458000_2277000 METAL5_458000_2289000 0.048
R_VDD1_1417 METAL5_458000_2289000 METAL5_458000_2341000 0.208
R_VDD1_1418 METAL5_458000_2341000 METAL5_458000_2353000 0.048
R_VDD1_1419 METAL5_458000_2353000 METAL5_458000_2365000 0.048
R_VDD1_1420 METAL5_458000_2365000 METAL5_458000_2377000 0.048
R_VDD1_1421 METAL5_458000_2377000 METAL5_458000_2389000 0.048
R_VDD1_1422 METAL5_458000_2389000 METAL5_458000_2401000 0.048
R_VDD1_1423 METAL5_458000_2401000 METAL5_458000_2453000 0.208
R_VDD1_1424 METAL5_458000_2453000 METAL5_458000_2465000 0.048
R_VDD1_1425 METAL5_458000_2465000 METAL5_458000_2477000 0.048
R_VDD1_1426 METAL5_458000_2477000 METAL5_458000_2489000 0.048
R_VDD1_1427 METAL5_458000_2489000 METAL5_458000_2553000 0.256
R_VDD1_1428 METAL5_458000_2553000 METAL5_458000_2565000 0.048
R_VDD1_1429 METAL5_458000_2565000 METAL5_458000_2577000 0.048
R_VDD1_1430 METAL5_458000_2577000 METAL5_458000_2593000 0.064
R_VDD1_1431 METAL5_458000_2593000 METAL5_458000_2605000 0.048
R_VDD1_1432 METAL5_458000_2605000 METAL5_458000_2617000 0.048
R_VDD1_1433 METAL5_458000_2617000 METAL5_458000_2629000 0.048
R_VDD1_1434 METAL5_458000_2629000 METAL4_458000_2629000 0.1
R_VDD1_1435 METAL4_458000_2629000 METAL4_460000_2629000 0.016
R_VDD1_1436 METAL4_460000_2629000 METAL4_462000_2629000 0.016
R_VDD1_1437 METAL4_462000_2629000 METAL4_464000_2629000 0.016
R_VDD1_1438 METAL4_464000_2629000 METAL4_470000_2629000 0.048
R_VDD1_1439 METAL4_470000_2629000 METAL4_472000_2629000 0.016
R_VDD1_1440 METAL4_472000_2629000 METAL4_474000_2629000 0.016
R_VDD1_1441 METAL4_474000_2629000 METAL4_476000_2629000 0.016
R_VDD1_1442 METAL4_476000_2629000 METAL4_482000_2629000 0.048
R_VDD1_1443 METAL4_482000_2629000 METAL4_483000_2629000 0.008
R_VDD1_1444 METAL4_483000_2629000 METAL4_484000_2629000 0.008
R_VDD1_1445 METAL4_484000_2629000 METAL4_486000_2629000 0.016
R_VDD1_1446 METAL4_486000_2629000 METAL4_488000_2629000 0.016
R_VDD1_1447 METAL4_488000_2629000 METAL4_488000_2641000 0.096
R_VDD1_1448 METAL4_488000_2641000 METAL4_488000_2653000 0.096
R_VDD1_1449 METAL4_488000_2653000 METAL4_488000_2665000 0.096
R_VDD1_1450 METAL4_488000_2665000 METAL4_488000_2677000 0.096
R_VDD1_1451 METAL4_488000_2677000 METAL4_488000_2689000 0.096
R_VDD1_1452 METAL4_488000_2689000 METAL4_488000_2701000 0.096
R_VDD1_1453 METAL4_488000_2701000 METAL5_488000_2701000 0.1
R_VDD1_1454 METAL5_488000_2701000 METAL5_488000_2713000 0.048
R_VDD1_1455 METAL5_488000_2713000 METAL5_488000_2769000 0.224
R_VDD1_1456 METAL5_488000_2769000 METAL5_488000_2781000 0.048
R_VDD1_1457 METAL5_488000_2781000 METAL5_494000_2781000 0.024
R_VDD1_1458 METAL5_494000_2781000 METAL5_494000_2793000 0.048
R_VDD1_1459 METAL5_494000_2793000 METAL5_494000_2805000 0.048
R_VDD1_1460 METAL5_494000_2805000 METAL5_494000_2807000 0.008
R_VDD1_1461 METAL5_494000_2807000 METAL5_494000_2817000 0.04
R_VDD1_1462 METAL5_494000_2817000 METAL5_494000_2929000 0.448
R_VDD1_1463 METAL5_494000_2929000 METAL5_494000_2941000 0.048
R_VDD1_1464 METAL5_494000_2941000 METAL5_494000_2953000 0.048
R_VDD1_1465 METAL5_494000_2953000 METAL5_494000_2965000 0.048
R_VDD1_1466 METAL5_494000_2965000 METAL5_488000_2965000 0.024
R_VDD1_1467 METAL5_488000_2965000 METAL5_486000_2965000 0.008
R_VDD1_1468 METAL5_486000_2965000 METAL5_484000_2965000 0.008
R_VDD1_1469 METAL5_484000_2965000 METAL5_483000_2965000 0.004
R_VDD1_1470 METAL5_483000_2965000 METAL4_483000_2965000 0.1
R_VDD1_1471 METAL4_483000_2965000 METAL4_483000_2977000 0.096
R_VDD1_1472 METAL4_483000_2977000 METAL4_483000_2989000 0.096
R_VDD1_1473 METAL4_483000_2989000 METAL5_483000_2989000 0.1
R_VDD1_1474 METAL5_483000_2989000 METAL5_483000_3001000 0.048
R_VDD1_1475 METAL5_483000_3001000 METAL5_483000_3053000 0.208
R_VDD1_1476 METAL5_483000_3053000 METAL5_483000_3065000 0.048
R_VDD1_1477 METAL5_483000_3065000 METAL4_483000_3065000 0.1
R_VDD1_1478 METAL4_483000_3065000 METAL4_483000_3077000 0.096
R_VDD1_1479 METAL4_483000_3077000 METAL4_483000_3089000 0.096
R_VDD1_1480 METAL4_483000_3089000 METAL5_483000_3089000 0.1
R_VDD1_1481 METAL5_483000_3089000 METAL5_483000_3101000 0.048
R_VDD1_1482 METAL5_483000_3101000 METAL5_483000_3153000 0.208
R_VDD1_1483 METAL5_483000_3153000 METAL5_483000_3165000 0.048
R_VDD1_1484 METAL5_483000_3165000 METAL5_483000_3177000 0.048
R_VDD1_1485 METAL5_483000_3177000 METAL5_483000_3189000 0.048
R_VDD1_1486 METAL5_483000_3189000 METAL5_483000_3253000 0.256
R_VDD1_1487 METAL5_483000_3253000 METAL5_483000_3265000 0.048
R_VDD1_1488 METAL5_483000_3265000 METAL5_483000_3277000 0.048
R_VDD1_1489 METAL5_483000_3277000 METAL5_483000_3289000 0.048
R_VDD1_1490 METAL5_483000_3289000 METAL5_483000_3341000 0.208
R_VDD1_1491 METAL5_483000_3341000 METAL5_483000_3353000 0.048
R_VDD1_1492 METAL5_483000_3353000 METAL4_483000_3353000 0.1
R_VDD1_1493 METAL4_483000_3353000 METAL4_483000_3365000 0.096
R_VDD1_1494 METAL4_483000_3365000 METAL4_483000_3377000 0.096
R_VDD1_1495 METAL4_483000_3377000 METAL4_483000_3389000 0.096
R_VDD1_1496 METAL4_483000_3389000 METAL4_483000_3401000 0.096
R_VDD1_1497 METAL4_483000_3401000 METAL4_483000_3413000 0.096
R_VDD1_1498 METAL4_483000_3413000 METAL5_483000_3413000 0.1
R_VDD1_1499 METAL5_483000_3413000 METAL5_483000_3425000 0.048
R_VDD1_1500 METAL5_483000_3425000 METAL5_483000_3481000 0.224
R_VDD1_1501 METAL5_483000_3481000 METAL5_483000_3493000 0.048
R_VDD1_1502 METAL5_483000_3493000 METAL5_483000_3495000 0.008
R_VDD1_1503 METAL5_483000_3495000 METAL5_483000_3505000 0.04
R_VDD1_1504 METAL5_483000_3505000 METAL5_483000_3507000 0.008
R_VDD1_1505 METAL5_483000_3507000 METAL5_483000_3519000 0.048
R_VDD1_1506 METAL5_483000_3519000 METAL5_483000_3641000 0.488
R_VDD1_1507 METAL5_483000_3641000 METAL5_483000_3653000 0.048
R_VDD1_1508 METAL5_483000_3653000 METAL5_483000_3665000 0.048
R_VDD1_1509 METAL5_483000_3665000 METAL5_483000_3677000 0.048
R_VDD1_1510 METAL5_483000_3677000 METAL5_483000_3689000 0.048
R_VDD1_1511 METAL5_483000_3689000 METAL5_483000_3753000 0.256
R_VDD1_1512 METAL5_483000_3753000 METAL5_483000_3765000 0.048
R_VDD1_1513 METAL5_483000_3765000 METAL5_483000_3777000 0.048
R_VDD1_1514 METAL5_483000_3777000 METAL5_483000_3789000 0.048
R_VDD1_1515 METAL5_483000_3789000 METAL5_483000_3853000 0.256
R_VDD1_1516 METAL5_483000_3853000 METAL5_483000_3865000 0.048
R_VDD1_1517 METAL5_483000_3865000 METAL5_483000_3877000 0.048
R_VDD1_1518 METAL5_483000_3877000 METAL5_483000_3941000 0.256
R_VDD1_1519 METAL5_483000_3941000 METAL5_482000_3941000 0.004
R_VDD1_1520 METAL5_482000_3941000 METAL5_476000_3941000 0.024
R_VDD1_1521 METAL5_476000_3941000 METAL5_474000_3941000 0.008
R_VDD1_1522 METAL5_474000_3941000 METAL5_472000_3941000 0.008
R_VDD1_1523 METAL5_472000_3941000 METAL5_470000_3941000 0.008
R_VDD1_1524 METAL5_470000_3941000 METAL5_464000_3941000 0.024
R_VDD1_1525 METAL5_464000_3941000 METAL5_462000_3941000 0.008
R_VDD1_1526 METAL5_462000_3941000 METAL5_460000_3941000 0.008
R_VDD1_1527 METAL5_460000_3941000 METAL5_458000_3941000 0.008
R_VDD1_1528 METAL5_458000_3941000 METAL5_452000_3941000 0.024
R_VDD1_1529 METAL5_452000_3941000 METAL5_452000_3953000 0.048
R_VDD1_1530 METAL5_452000_3953000 METAL5_452000_3965000 0.048
R_VDD1_1531 METAL5_452000_3965000 METAL5_452000_3977000 0.048
R_VDD1_1532 METAL5_452000_3977000 METAL5_452000_4017000 0.16
R_VDD1_1533 METAL5_452000_4017000 METAL5_452000_4029000 0.048
R_VDD1_1534 METAL5_452000_4029000 METAL5_458000_4029000 0.024
R_VDD1_1535 METAL5_458000_4029000 METAL5_460000_4029000 0.008
R_VDD1_1536 METAL5_460000_4029000 METAL5_462000_4029000 0.008
R_VDD1_1537 METAL5_462000_4029000 METAL5_464000_4029000 0.008
R_VDD1_1538 METAL5_464000_4029000 METAL5_470000_4029000 0.024
R_VDD1_1539 METAL5_470000_4029000 METAL5_472000_4029000 0.008
R_VDD1_1540 METAL5_472000_4029000 METAL5_474000_4029000 0.008
R_VDD1_1541 METAL5_474000_4029000 METAL5_476000_4029000 0.008
R_VDD1_1542 METAL5_476000_4029000 METAL5_476000_4041000 0.048
R_VDD1_1543 METAL5_476000_4041000 METAL5_476000_4053000 0.048
R_VDD1_1544 METAL5_476000_4053000 METAL4_476000_4053000 0.1
R_VDD1_1545 METAL4_476000_4053000 METAL4_476000_4065000 0.096
R_VDD1_1546 METAL4_476000_4065000 METAL4_476000_4077000 0.096
R_VDD1_1547 METAL4_476000_4077000 METAL4_476000_4089000 0.096
R_VDD1_1548 METAL4_476000_4089000 METAL4_476000_4101000 0.096
R_VDD1_1549 METAL4_476000_4101000 METAL5_476000_4101000 0.1
R_VDD1_1550 METAL5_476000_4101000 METAL5_476000_4133000 0.128
R_VDD1_1551 METAL5_476000_4133000 METAL5_476000_4145000 0.048
R_VDD1_1552 METAL5_476000_4145000 METAL5_482000_4145000 0.024
R_VDD1_1553 METAL5_482000_4145000 METAL5_483000_4145000 0.004
R_VDD1_1554 METAL5_483000_4145000 METAL5_484000_4145000 0.004
R_VDD1_1555 METAL5_484000_4145000 METAL5_486000_4145000 0.008
R_VDD1_1556 METAL5_486000_4145000 METAL5_488000_4145000 0.008
R_VDD1_1557 METAL5_488000_4145000 METAL5_494000_4145000 0.024
R_VDD1_1558 METAL5_494000_4145000 METAL5_495000_4145000 0.004
R_VDD1_1559 METAL5_495000_4145000 METAL5_496000_4145000 0.004
R_VDD1_1560 METAL5_496000_4145000 METAL5_498000_4145000 0.008
R_VDD1_1561 METAL5_498000_4145000 METAL5_500000_4145000 0.008
R_VDD1_1562 METAL5_500000_4145000 METAL5_507000_4145000 0.028
R_VDD1_1563 METAL5_507000_4145000 METAL5_508000_4145000 0.004
R_VDD1_1564 METAL5_508000_4145000 METAL5_510000_4145000 0.008
R_VDD1_1565 METAL5_510000_4145000 METAL5_512000_4145000 0.008
R_VDD1_1566 METAL5_512000_4145000 METAL5_512000_4157000 0.048
R_VDD1_1567 METAL5_512000_4157000 METAL5_512000_4169000 0.048
R_VDD1_1568 METAL5_512000_4169000 METAL5_512000_4181000 0.048
R_VDD1_1569 METAL5_512000_4181000 METAL5_519000_4181000 0.028
R_VDD1_1570 METAL5_519000_4181000 METAL5_522000_4181000 0.012
R_VDD1_1571 METAL5_522000_4181000 METAL5_524000_4181000 0.008
R_VDD1_1572 METAL5_524000_4181000 METAL5_531000_4181000 0.028
R_VDD1_1573 METAL5_531000_4181000 METAL5_531000_4193000 0.048
R_VDD1_1574 METAL5_531000_4193000 METAL5_536000_4193000 0.02
R_VDD1_1575 METAL5_536000_4193000 METAL5_543000_4193000 0.028
R_VDD1_1576 METAL5_543000_4193000 METAL5_543000_4195000 0.008
R_VDD1_1577 METAL5_543000_4195000 METAL5_543000_4205000 0.04
R_VDD1_1578 METAL5_543000_4205000 METAL5_543000_4207000 0.008
R_VDD1_1579 METAL5_543000_4207000 METAL5_543000_4217000 0.04
R_VDD1_1580 METAL5_543000_4217000 METAL5_543000_4219000 0.008
R_VDD1_1581 METAL5_543000_4219000 METAL5_543000_4329000 0.44
R_VDD1_1582 METAL5_543000_4329000 METAL5_543000_4341000 0.048
R_VDD1_1583 METAL5_543000_4341000 METAL4_543000_4341000 0.1
R_VDD1_1584 METAL4_543000_4341000 METAL4_543000_4353000 0.096
R_VDD1_1585 METAL4_543000_4353000 METAL4_543000_4365000 0.096
R_VDD1_1586 METAL4_543000_4365000 METAL5_543000_4365000 0.1
R_VDD1_1587 METAL5_543000_4365000 METAL6_543000_4365000 0.1
R_VDD1_1588 METAL6_245000_4365000 METAL6_257000_4365000 0.024
R_VDD1_1589 METAL4_386000_1989000 METAL5_386000_1989000 0.1
R_VDD1_1590 METAL5_386000_1989000 METAL5_386000_2001000 0.048
R_VDD1_1591 METAL5_386000_2001000 METAL5_386000_2013000 0.048
R_VDD1_1592 METAL5_386000_2013000 METAL5_386000_2093000 0.32
R_VDD1_1593 METAL5_386000_2093000 METAL5_386000_2107000 0.056
R_VDD1_1594 METAL5_386000_2107000 METAL5_386000_2217000 0.44
R_VDD1_1595 METAL5_386000_2217000 METAL5_386000_2229000 0.048
R_VDD1_1596 METAL5_386000_2229000 METAL5_386000_2241000 0.048
R_VDD1_1597 METAL5_386000_2241000 METAL5_386000_2253000 0.048
R_VDD1_1598 METAL5_386000_2253000 METAL5_386000_2265000 0.048
R_VDD1_1599 METAL5_386000_2265000 METAL5_386000_2277000 0.048
R_VDD1_1600 METAL5_386000_2277000 METAL4_386000_2277000 0.1
R_VDD1_1601 METAL4_386000_2277000 METAL4_384000_2277000 0.016
R_VDD1_1602 METAL4_384000_2277000 METAL4_378000_2277000 0.048
R_VDD1_1603 METAL4_378000_2277000 METAL4_376000_2277000 0.016
R_VDD1_1604 METAL4_376000_2277000 METAL4_374000_2277000 0.016
R_VDD1_1605 METAL4_374000_2277000 METAL4_372000_2277000 0.016
R_VDD1_1606 METAL4_372000_2277000 METAL4_366000_2277000 0.048
R_VDD1_1607 METAL4_366000_2277000 METAL4_364000_2277000 0.016
R_VDD1_1608 METAL4_364000_2277000 METAL4_362000_2277000 0.016
R_VDD1_1609 METAL4_362000_2277000 METAL4_360000_2277000 0.016
R_VDD1_1610 METAL4_360000_2277000 METAL4_354000_2277000 0.048
R_VDD1_1611 METAL4_354000_2277000 METAL4_352000_2277000 0.016
R_VDD1_1612 METAL4_352000_2277000 METAL4_350000_2277000 0.016
R_VDD1_1613 METAL4_350000_2277000 METAL4_348000_2277000 0.016
R_VDD1_1614 METAL4_348000_2277000 METAL4_342000_2277000 0.048
R_VDD1_1615 METAL4_342000_2277000 METAL4_340000_2277000 0.016
R_VDD1_1616 METAL4_340000_2277000 METAL4_338000_2277000 0.016
R_VDD1_1617 METAL4_338000_2277000 METAL4_336000_2277000 0.016
R_VDD1_1618 METAL4_336000_2277000 METAL4_330000_2277000 0.048
R_VDD1_1619 METAL4_330000_2277000 METAL4_329000_2277000 0.008
R_VDD1_1620 METAL4_329000_2277000 METAL4_328000_2277000 0.008
R_VDD1_1621 METAL4_328000_2277000 METAL4_326000_2277000 0.016
R_VDD1_1622 METAL4_326000_2277000 METAL4_324000_2277000 0.016
R_VDD1_1623 METAL4_324000_2277000 METAL4_318000_2277000 0.048
R_VDD1_1624 METAL4_318000_2277000 METAL4_317000_2277000 0.008
R_VDD1_1625 METAL4_317000_2277000 METAL4_316000_2277000 0.008
R_VDD1_1626 METAL4_316000_2277000 METAL4_314000_2277000 0.016
R_VDD1_1627 METAL4_314000_2277000 METAL4_312000_2277000 0.016
R_VDD1_1628 METAL4_312000_2277000 METAL5_312000_2277000 0.1
R_VDD1_1629 METAL5_312000_2277000 METAL5_312000_2289000 0.048
R_VDD1_1630 METAL5_312000_2289000 METAL5_312000_2341000 0.208
R_VDD1_1631 METAL5_312000_2341000 METAL5_312000_2353000 0.048
R_VDD1_1632 METAL5_312000_2353000 METAL5_312000_2365000 0.048
R_VDD1_1633 METAL5_312000_2365000 METAL5_312000_2377000 0.048
R_VDD1_1634 METAL5_312000_2377000 METAL5_312000_2389000 0.048
R_VDD1_1635 METAL5_312000_2389000 METAL5_312000_2401000 0.048
R_VDD1_1636 METAL5_312000_2401000 METAL5_312000_2453000 0.208
R_VDD1_1637 METAL5_312000_2453000 METAL5_312000_2465000 0.048
R_VDD1_1638 METAL5_312000_2465000 METAL5_312000_2477000 0.048
R_VDD1_1639 METAL5_312000_2477000 METAL5_312000_2489000 0.048
R_VDD1_1640 METAL5_312000_2489000 METAL5_312000_2553000 0.256
R_VDD1_1641 METAL5_312000_2553000 METAL5_312000_2565000 0.048
R_VDD1_1642 METAL5_312000_2565000 METAL5_312000_2577000 0.048
R_VDD1_1643 METAL5_312000_2577000 METAL5_312000_2593000 0.064
R_VDD1_1644 METAL5_312000_2593000 METAL5_312000_2605000 0.048
R_VDD1_1645 METAL5_312000_2605000 METAL5_312000_2617000 0.048
R_VDD1_1646 METAL5_312000_2617000 METAL5_306000_2617000 0.024
R_VDD1_1647 METAL5_306000_2617000 METAL5_305000_2617000 0.004
R_VDD1_1648 METAL5_305000_2617000 METAL5_304000_2617000 0.004
R_VDD1_1649 METAL5_304000_2617000 METAL5_302000_2617000 0.008
R_VDD1_1650 METAL5_302000_2617000 METAL5_300000_2617000 0.008
R_VDD1_1651 METAL5_300000_2617000 METAL4_300000_2617000 0.1
R_VDD1_1652 METAL4_300000_2617000 METAL4_294000_2617000 0.048
R_VDD1_1653 METAL4_294000_2617000 METAL4_293000_2617000 0.008
R_VDD1_1654 METAL4_293000_2617000 METAL4_292000_2617000 0.008
R_VDD1_1655 METAL4_292000_2617000 METAL4_290000_2617000 0.016
R_VDD1_1656 METAL4_290000_2617000 METAL4_288000_2617000 0.016
R_VDD1_1657 METAL4_288000_2617000 METAL4_282000_2617000 0.048
R_VDD1_1658 METAL4_282000_2617000 METAL4_281000_2617000 0.008
R_VDD1_1659 METAL4_281000_2617000 METAL4_280000_2617000 0.008
R_VDD1_1660 METAL4_280000_2617000 METAL4_278000_2617000 0.016
R_VDD1_1661 METAL4_278000_2617000 METAL4_276000_2617000 0.016
R_VDD1_1662 METAL4_276000_2617000 METAL4_276000_2629000 0.096
R_VDD1_1663 METAL4_276000_2629000 METAL4_276000_2641000 0.096
R_VDD1_1664 METAL4_276000_2641000 METAL4_276000_2653000 0.096
R_VDD1_1665 METAL4_276000_2653000 METAL5_276000_2653000 0.1
R_VDD1_1666 METAL5_276000_2653000 METAL5_276000_2665000 0.048
R_VDD1_1667 METAL5_276000_2665000 METAL5_276000_2677000 0.048
R_VDD1_1668 METAL5_276000_2677000 METAL5_276000_2689000 0.048
R_VDD1_1669 METAL5_276000_2689000 METAL5_276000_2701000 0.048
R_VDD1_1670 METAL5_276000_2701000 METAL5_276000_2713000 0.048
R_VDD1_1671 METAL5_276000_2713000 METAL5_276000_2769000 0.224
R_VDD1_1672 METAL5_276000_2769000 METAL5_276000_2781000 0.048
R_VDD1_1673 METAL5_276000_2781000 METAL5_270000_2781000 0.024
R_VDD1_1674 METAL5_270000_2781000 METAL5_269000_2781000 0.004
R_VDD1_1675 METAL5_269000_2781000 METAL4_269000_2781000 0.1
R_VDD1_1676 METAL4_269000_2781000 METAL4_269000_2793000 0.096
R_VDD1_1677 METAL4_269000_2793000 METAL4_269000_2805000 0.096
R_VDD1_1678 METAL4_269000_2805000 METAL5_269000_2805000 0.1
R_VDD1_1679 METAL5_269000_2805000 METAL5_269000_2807000 0.008
R_VDD1_1680 METAL5_269000_2807000 METAL5_269000_2817000 0.04
R_VDD1_1681 METAL5_269000_2817000 METAL5_269000_2929000 0.448
R_VDD1_1682 METAL5_269000_2929000 METAL5_269000_2941000 0.048
R_VDD1_1683 METAL5_269000_2941000 METAL4_269000_2941000 0.1
R_VDD1_1684 METAL4_269000_2941000 METAL4_269000_2953000 0.096
R_VDD1_1685 METAL4_269000_2953000 METAL4_269000_2965000 0.096
R_VDD1_1686 METAL4_269000_2965000 METAL4_270000_2965000 0.008
R_VDD1_1687 METAL4_270000_2965000 METAL4_276000_2965000 0.048
R_VDD1_1688 METAL4_276000_2965000 METAL4_278000_2965000 0.016
R_VDD1_1689 METAL4_278000_2965000 METAL4_280000_2965000 0.016
R_VDD1_1690 METAL4_280000_2965000 METAL4_281000_2965000 0.008
R_VDD1_1691 METAL4_281000_2965000 METAL4_282000_2965000 0.008
R_VDD1_1692 METAL4_282000_2965000 METAL4_288000_2965000 0.048
R_VDD1_1693 METAL4_288000_2965000 METAL4_290000_2965000 0.016
R_VDD1_1694 METAL4_290000_2965000 METAL4_292000_2965000 0.016
R_VDD1_1695 METAL4_292000_2965000 METAL4_293000_2965000 0.008
R_VDD1_1696 METAL4_293000_2965000 METAL4_294000_2965000 0.008
R_VDD1_1697 METAL4_294000_2965000 METAL4_300000_2965000 0.048
R_VDD1_1698 METAL4_300000_2965000 METAL4_302000_2965000 0.016
R_VDD1_1699 METAL4_302000_2965000 METAL4_304000_2965000 0.016
R_VDD1_1700 METAL4_304000_2965000 METAL4_305000_2965000 0.008
R_VDD1_1701 METAL4_305000_2965000 METAL4_305000_2977000 0.096
R_VDD1_1702 METAL4_305000_2977000 METAL4_305000_2989000 0.096
R_VDD1_1703 METAL4_305000_2989000 METAL5_305000_2989000 0.1
R_VDD1_1704 METAL5_305000_2989000 METAL5_305000_3001000 0.048
R_VDD1_1705 METAL5_305000_3001000 METAL5_305000_3053000 0.208
R_VDD1_1706 METAL5_305000_3053000 METAL5_305000_3065000 0.048
R_VDD1_1707 METAL5_305000_3065000 METAL5_305000_3077000 0.048
R_VDD1_1708 METAL5_305000_3077000 METAL5_305000_3089000 0.048
R_VDD1_1709 METAL5_305000_3089000 METAL5_305000_3101000 0.048
R_VDD1_1710 METAL5_305000_3101000 METAL5_305000_3153000 0.208
R_VDD1_1711 METAL5_305000_3153000 METAL5_305000_3165000 0.048
R_VDD1_1712 METAL5_305000_3165000 METAL5_305000_3177000 0.048
R_VDD1_1713 METAL5_305000_3177000 METAL5_305000_3189000 0.048
R_VDD1_1714 METAL5_305000_3189000 METAL5_305000_3253000 0.256
R_VDD1_1715 METAL5_305000_3253000 METAL5_305000_3265000 0.048
R_VDD1_1716 METAL5_305000_3265000 METAL5_305000_3277000 0.048
R_VDD1_1717 METAL5_305000_3277000 METAL5_305000_3289000 0.048
R_VDD1_1718 METAL5_305000_3289000 METAL5_305000_3341000 0.208
R_VDD1_1719 METAL5_305000_3341000 METAL4_305000_3341000 0.1
R_VDD1_1720 METAL4_305000_3341000 METAL4_305000_3353000 0.096
R_VDD1_1721 METAL4_305000_3353000 METAL4_305000_3365000 0.096
R_VDD1_1722 METAL4_305000_3365000 METAL4_305000_3377000 0.096
R_VDD1_1723 METAL4_305000_3377000 METAL4_305000_3389000 0.096
R_VDD1_1724 METAL4_305000_3389000 METAL5_305000_3389000 0.1
R_VDD1_1725 METAL5_305000_3389000 METAL5_305000_3401000 0.048
R_VDD1_1726 METAL5_305000_3401000 METAL5_305000_3413000 0.048
R_VDD1_1727 METAL5_305000_3413000 METAL5_305000_3425000 0.048
R_VDD1_1728 METAL5_305000_3425000 METAL5_305000_3481000 0.224
R_VDD1_1729 METAL5_305000_3481000 METAL5_305000_3493000 0.048
R_VDD1_1730 METAL5_305000_3493000 METAL5_305000_3495000 0.008
R_VDD1_1731 METAL5_305000_3495000 METAL5_305000_3505000 0.04
R_VDD1_1732 METAL5_305000_3505000 METAL5_305000_3507000 0.008
R_VDD1_1733 METAL5_305000_3507000 METAL5_305000_3519000 0.048
R_VDD1_1734 METAL5_305000_3519000 METAL5_305000_3641000 0.488
R_VDD1_1735 METAL5_305000_3641000 METAL5_305000_3653000 0.048
R_VDD1_1736 METAL5_305000_3653000 METAL5_305000_3665000 0.048
R_VDD1_1737 METAL5_305000_3665000 METAL5_305000_3677000 0.048
R_VDD1_1738 METAL5_305000_3677000 METAL5_305000_3689000 0.048
R_VDD1_1739 METAL5_305000_3689000 METAL5_305000_3753000 0.256
R_VDD1_1740 METAL5_305000_3753000 METAL5_305000_3765000 0.048
R_VDD1_1741 METAL5_305000_3765000 METAL4_305000_3765000 0.1
R_VDD1_1742 METAL4_305000_3765000 METAL4_305000_3777000 0.096
R_VDD1_1743 METAL4_305000_3777000 METAL4_305000_3789000 0.096
R_VDD1_1744 METAL4_305000_3789000 METAL5_305000_3789000 0.1
R_VDD1_1745 METAL5_305000_3789000 METAL5_305000_3853000 0.256
R_VDD1_1746 METAL5_305000_3853000 METAL5_305000_3865000 0.048
R_VDD1_1747 METAL5_305000_3865000 METAL5_305000_3877000 0.048
R_VDD1_1748 METAL5_305000_3877000 METAL5_305000_3929000 0.208
R_VDD1_1749 METAL5_305000_3929000 METAL5_305000_3941000 0.048
R_VDD1_1750 METAL5_305000_3941000 METAL5_304000_3941000 0.004
R_VDD1_1751 METAL5_304000_3941000 METAL5_302000_3941000 0.008
R_VDD1_1752 METAL5_302000_3941000 METAL5_302000_3953000 0.048
R_VDD1_1753 METAL5_302000_3953000 METAL4_302000_3953000 0.1
R_VDD1_1754 METAL4_302000_3953000 METAL4_302000_3965000 0.096
R_VDD1_1755 METAL4_302000_3965000 METAL4_302000_3977000 0.096
R_VDD1_1756 METAL4_302000_3977000 METAL5_302000_3977000 0.1
R_VDD1_1757 METAL5_302000_3977000 METAL5_302000_4017000 0.16
R_VDD1_1758 METAL5_302000_4017000 METAL5_302000_4029000 0.048
R_VDD1_1759 METAL5_302000_4029000 METAL5_302000_4041000 0.048
R_VDD1_1760 METAL5_302000_4041000 METAL5_302000_4053000 0.048
R_VDD1_1761 METAL5_302000_4053000 METAL4_302000_4053000 0.1
R_VDD1_1762 METAL4_302000_4053000 METAL4_302000_4065000 0.096
R_VDD1_1763 METAL4_302000_4065000 METAL4_302000_4077000 0.096
R_VDD1_1764 METAL4_302000_4077000 METAL5_302000_4077000 0.1
R_VDD1_1765 METAL5_302000_4077000 METAL5_300000_4077000 0.008
R_VDD1_1766 METAL5_300000_4077000 METAL5_300000_4089000 0.048
R_VDD1_1767 METAL5_300000_4089000 METAL5_300000_4101000 0.048
R_VDD1_1768 METAL5_300000_4101000 METAL5_300000_4113000 0.048
R_VDD1_1769 METAL5_300000_4113000 METAL5_300000_4133000 0.08
R_VDD1_1770 METAL5_300000_4133000 METAL5_300000_4145000 0.048
R_VDD1_1771 METAL5_300000_4145000 METAL4_300000_4145000 0.1
R_VDD1_1772 METAL4_300000_4145000 METAL4_300000_4157000 0.096
R_VDD1_1773 METAL4_300000_4157000 METAL4_300000_4169000 0.096
R_VDD1_1774 METAL4_300000_4169000 METAL5_300000_4169000 0.1
R_VDD1_1775 METAL5_300000_4169000 METAL5_300000_4181000 0.048
R_VDD1_1776 METAL5_300000_4181000 METAL5_300000_4193000 0.048
R_VDD1_1777 METAL5_300000_4193000 METAL5_294000_4193000 0.024
R_VDD1_1778 METAL5_294000_4193000 METAL5_294000_4195000 0.008
R_VDD1_1779 METAL5_294000_4195000 METAL5_294000_4205000 0.04
R_VDD1_1780 METAL5_294000_4205000 METAL5_294000_4207000 0.008
R_VDD1_1781 METAL5_294000_4207000 METAL5_294000_4217000 0.04
R_VDD1_1782 METAL5_294000_4217000 METAL5_294000_4219000 0.008
R_VDD1_1783 METAL5_294000_4219000 METAL5_294000_4329000 0.44
R_VDD1_1784 METAL5_294000_4329000 METAL5_294000_4341000 0.048
R_VDD1_1785 METAL5_294000_4341000 METAL5_294000_4353000 0.048
R_VDD1_1786 METAL5_294000_4353000 METAL5_294000_4365000 0.048
R_VDD1_1787 METAL5_294000_4365000 METAL5_293000_4365000 0.004
R_VDD1_1788 METAL5_293000_4365000 METAL5_292000_4365000 0.004
R_VDD1_1789 METAL5_292000_4365000 METAL5_290000_4365000 0.008
R_VDD1_1790 METAL5_290000_4365000 METAL5_288000_4365000 0.008
R_VDD1_1791 METAL5_288000_4365000 METAL5_282000_4365000 0.024
R_VDD1_1792 METAL5_282000_4365000 METAL5_281000_4365000 0.004
R_VDD1_1793 METAL5_281000_4365000 METAL4_281000_4365000 0.1
R_VDD1_1794 METAL4_281000_4365000 METAL4_280000_4365000 0.008
R_VDD1_1795 METAL4_280000_4365000 METAL4_278000_4365000 0.016
R_VDD1_1796 METAL4_278000_4365000 METAL4_276000_4365000 0.016
R_VDD1_1797 METAL4_276000_4365000 METAL4_270000_4365000 0.048
R_VDD1_1798 METAL4_270000_4365000 METAL4_269000_4365000 0.008
R_VDD1_1799 METAL4_269000_4365000 METAL4_266000_4365000 0.024
R_VDD1_1800 METAL4_266000_4365000 METAL4_264000_4365000 0.016
R_VDD1_1801 METAL4_264000_4365000 METAL4_258000_4365000 0.048
R_VDD1_1802 METAL4_258000_4365000 METAL4_257000_4365000 0.008
R_VDD1_1803 METAL4_257000_4365000 METAL5_257000_4365000 0.1
R_VDD1_1804 METAL5_257000_4365000 METAL6_257000_4365000 0.1
R_VDD1_1805 METAL6_555000_3665000 METAL6_543000_3665000 0.024
R_VDD1_1806 METAL4_488000_2001000 METAL4_488000_2013000 0.096
R_VDD1_1807 METAL4_488000_2013000 METAL4_494000_2013000 0.048
R_VDD1_1808 METAL4_494000_2013000 METAL4_495000_2013000 0.008
R_VDD1_1809 METAL4_495000_2013000 METAL4_496000_2013000 0.008
R_VDD1_1810 METAL4_496000_2013000 METAL4_498000_2013000 0.016
R_VDD1_1811 METAL4_498000_2013000 METAL4_500000_2013000 0.016
R_VDD1_1812 METAL4_500000_2013000 METAL4_506000_2013000 0.048
R_VDD1_1813 METAL4_506000_2013000 METAL4_507000_2013000 0.008
R_VDD1_1814 METAL4_507000_2013000 METAL4_508000_2013000 0.008
R_VDD1_1815 METAL4_508000_2013000 METAL4_510000_2013000 0.016
R_VDD1_1816 METAL4_510000_2013000 METAL4_512000_2013000 0.016
R_VDD1_1817 METAL4_512000_2013000 METAL4_519000_2013000 0.056
R_VDD1_1818 METAL4_519000_2013000 METAL4_522000_2013000 0.024
R_VDD1_1819 METAL4_522000_2013000 METAL4_524000_2013000 0.016
R_VDD1_1820 METAL4_524000_2013000 METAL4_531000_2013000 0.056
R_VDD1_1821 METAL4_531000_2013000 METAL5_531000_2013000 0.1
R_VDD1_1822 METAL5_531000_2013000 METAL5_531000_2093000 0.32
R_VDD1_1823 METAL5_531000_2093000 METAL5_531000_2107000 0.056
R_VDD1_1824 METAL5_531000_2107000 METAL5_531000_2217000 0.44
R_VDD1_1825 METAL5_531000_2217000 METAL5_531000_2229000 0.048
R_VDD1_1826 METAL5_531000_2229000 METAL5_531000_2241000 0.048
R_VDD1_1827 METAL5_531000_2241000 METAL4_531000_2241000 0.1
R_VDD1_1828 METAL4_531000_2241000 METAL4_531000_2253000 0.096
R_VDD1_1829 METAL4_531000_2253000 METAL4_531000_2265000 0.096
R_VDD1_1830 METAL4_531000_2265000 METAL4_524000_2265000 0.056
R_VDD1_1831 METAL4_524000_2265000 METAL4_522000_2265000 0.016
R_VDD1_1832 METAL4_522000_2265000 METAL4_519000_2265000 0.024
R_VDD1_1833 METAL4_519000_2265000 METAL4_512000_2265000 0.056
R_VDD1_1834 METAL4_512000_2265000 METAL4_510000_2265000 0.016
R_VDD1_1835 METAL4_510000_2265000 METAL4_508000_2265000 0.016
R_VDD1_1836 METAL4_508000_2265000 METAL4_507000_2265000 0.008
R_VDD1_1837 METAL4_507000_2265000 METAL4_507000_2277000 0.096
R_VDD1_1838 METAL4_507000_2277000 METAL4_507000_2289000 0.096
R_VDD1_1839 METAL4_507000_2289000 METAL4_507000_2341000 0.416
R_VDD1_1840 METAL4_507000_2341000 METAL4_507000_2353000 0.096
R_VDD1_1841 METAL4_507000_2353000 METAL4_506000_2353000 0.008
R_VDD1_1842 METAL4_506000_2353000 METAL4_500000_2353000 0.048
R_VDD1_1843 METAL4_500000_2353000 METAL4_498000_2353000 0.016
R_VDD1_1844 METAL4_498000_2353000 METAL4_496000_2353000 0.016
R_VDD1_1845 METAL4_496000_2353000 METAL4_495000_2353000 0.008
R_VDD1_1846 METAL4_495000_2353000 METAL4_495000_2365000 0.096
R_VDD1_1847 METAL4_495000_2365000 METAL4_495000_2377000 0.096
R_VDD1_1848 METAL4_495000_2377000 METAL4_495000_2389000 0.096
R_VDD1_1849 METAL4_495000_2389000 METAL4_495000_2401000 0.096
R_VDD1_1850 METAL4_495000_2401000 METAL4_496000_2401000 0.008
R_VDD1_1851 METAL4_496000_2401000 METAL4_498000_2401000 0.016
R_VDD1_1852 METAL4_498000_2401000 METAL4_500000_2401000 0.016
R_VDD1_1853 METAL4_500000_2401000 METAL4_506000_2401000 0.048
R_VDD1_1854 METAL4_506000_2401000 METAL4_507000_2401000 0.008
R_VDD1_1855 METAL4_507000_2401000 METAL4_508000_2401000 0.008
R_VDD1_1856 METAL4_508000_2401000 METAL4_510000_2401000 0.016
R_VDD1_1857 METAL4_510000_2401000 METAL4_512000_2401000 0.016
R_VDD1_1858 METAL4_512000_2401000 METAL4_519000_2401000 0.056
R_VDD1_1859 METAL4_519000_2401000 METAL5_519000_2401000 0.1
R_VDD1_1860 METAL5_519000_2401000 METAL5_519000_2453000 0.208
R_VDD1_1861 METAL5_519000_2453000 METAL5_519000_2465000 0.048
R_VDD1_1862 METAL5_519000_2465000 METAL5_519000_2477000 0.048
R_VDD1_1863 METAL5_519000_2477000 METAL5_519000_2489000 0.048
R_VDD1_1864 METAL5_519000_2489000 METAL5_519000_2553000 0.256
R_VDD1_1865 METAL5_519000_2553000 METAL5_519000_2565000 0.048
R_VDD1_1866 METAL5_519000_2565000 METAL5_519000_2577000 0.048
R_VDD1_1867 METAL5_519000_2577000 METAL5_519000_2593000 0.064
R_VDD1_1868 METAL5_519000_2593000 METAL5_519000_2605000 0.048
R_VDD1_1869 METAL5_519000_2605000 METAL5_519000_2617000 0.048
R_VDD1_1870 METAL5_519000_2617000 METAL5_519000_2629000 0.048
R_VDD1_1871 METAL5_519000_2629000 METAL5_519000_2641000 0.048
R_VDD1_1872 METAL5_519000_2641000 METAL5_519000_2653000 0.048
R_VDD1_1873 METAL5_519000_2653000 METAL4_519000_2653000 0.1
R_VDD1_1874 METAL4_519000_2653000 METAL4_519000_2665000 0.096
R_VDD1_1875 METAL4_519000_2665000 METAL4_519000_2677000 0.096
R_VDD1_1876 METAL4_519000_2677000 METAL4_519000_2689000 0.096
R_VDD1_1877 METAL4_519000_2689000 METAL4_519000_2701000 0.096
R_VDD1_1878 METAL4_519000_2701000 METAL5_519000_2701000 0.1
R_VDD1_1879 METAL5_519000_2701000 METAL5_519000_2713000 0.048
R_VDD1_1880 METAL5_519000_2713000 METAL5_519000_2769000 0.224
R_VDD1_1881 METAL5_519000_2769000 METAL5_519000_2781000 0.048
R_VDD1_1882 METAL5_519000_2781000 METAL5_519000_2793000 0.048
R_VDD1_1883 METAL5_519000_2793000 METAL5_519000_2805000 0.048
R_VDD1_1884 METAL5_519000_2805000 METAL5_519000_2807000 0.008
R_VDD1_1885 METAL5_519000_2807000 METAL5_519000_2817000 0.04
R_VDD1_1886 METAL5_519000_2817000 METAL5_519000_2929000 0.448
R_VDD1_1887 METAL5_519000_2929000 METAL5_519000_2941000 0.048
R_VDD1_1888 METAL5_519000_2941000 METAL5_519000_2953000 0.048
R_VDD1_1889 METAL5_519000_2953000 METAL5_519000_2965000 0.048
R_VDD1_1890 METAL5_519000_2965000 METAL5_519000_2977000 0.048
R_VDD1_1891 METAL5_519000_2977000 METAL5_519000_2989000 0.048
R_VDD1_1892 METAL5_519000_2989000 METAL5_519000_3001000 0.048
R_VDD1_1893 METAL5_519000_3001000 METAL5_519000_3053000 0.208
R_VDD1_1894 METAL5_519000_3053000 METAL4_519000_3053000 0.1
R_VDD1_1895 METAL4_519000_3053000 METAL4_512000_3053000 0.056
R_VDD1_1896 METAL4_512000_3053000 METAL4_510000_3053000 0.016
R_VDD1_1897 METAL4_510000_3053000 METAL4_508000_3053000 0.016
R_VDD1_1898 METAL4_508000_3053000 METAL4_507000_3053000 0.008
R_VDD1_1899 METAL4_507000_3053000 METAL4_506000_3053000 0.008
R_VDD1_1900 METAL4_506000_3053000 METAL4_500000_3053000 0.048
R_VDD1_1901 METAL4_500000_3053000 METAL4_498000_3053000 0.016
R_VDD1_1902 METAL4_498000_3053000 METAL4_496000_3053000 0.016
R_VDD1_1903 METAL4_496000_3053000 METAL4_495000_3053000 0.008
R_VDD1_1904 METAL4_495000_3053000 METAL4_495000_3065000 0.096
R_VDD1_1905 METAL4_495000_3065000 METAL4_495000_3077000 0.096
R_VDD1_1906 METAL4_495000_3077000 METAL4_495000_3089000 0.096
R_VDD1_1907 METAL4_495000_3089000 METAL5_495000_3089000 0.1
R_VDD1_1908 METAL5_495000_3089000 METAL5_495000_3101000 0.048
R_VDD1_1909 METAL5_495000_3101000 METAL5_495000_3153000 0.208
R_VDD1_1910 METAL5_495000_3153000 METAL5_495000_3165000 0.048
R_VDD1_1911 METAL5_495000_3165000 METAL5_495000_3177000 0.048
R_VDD1_1912 METAL5_495000_3177000 METAL5_495000_3189000 0.048
R_VDD1_1913 METAL5_495000_3189000 METAL5_495000_3253000 0.256
R_VDD1_1914 METAL5_495000_3253000 METAL5_495000_3265000 0.048
R_VDD1_1915 METAL5_495000_3265000 METAL5_495000_3277000 0.048
R_VDD1_1916 METAL5_495000_3277000 METAL5_495000_3289000 0.048
R_VDD1_1917 METAL5_495000_3289000 METAL5_495000_3329000 0.16
R_VDD1_1918 METAL5_495000_3329000 METAL5_495000_3341000 0.048
R_VDD1_1919 METAL5_495000_3341000 METAL5_495000_3353000 0.048
R_VDD1_1920 METAL5_495000_3353000 METAL4_495000_3353000 0.1
R_VDD1_1921 METAL4_495000_3353000 METAL4_495000_3365000 0.096
R_VDD1_1922 METAL4_495000_3365000 METAL4_495000_3377000 0.096
R_VDD1_1923 METAL4_495000_3377000 METAL4_495000_3389000 0.096
R_VDD1_1924 METAL4_495000_3389000 METAL4_495000_3401000 0.096
R_VDD1_1925 METAL4_495000_3401000 METAL4_495000_3413000 0.096
R_VDD1_1926 METAL4_495000_3413000 METAL5_495000_3413000 0.1
R_VDD1_1927 METAL5_495000_3413000 METAL5_495000_3425000 0.048
R_VDD1_1928 METAL5_495000_3425000 METAL5_495000_3481000 0.224
R_VDD1_1929 METAL5_495000_3481000 METAL5_495000_3493000 0.048
R_VDD1_1930 METAL5_495000_3493000 METAL5_495000_3495000 0.008
R_VDD1_1931 METAL5_495000_3495000 METAL5_495000_3505000 0.04
R_VDD1_1932 METAL5_495000_3505000 METAL5_495000_3507000 0.008
R_VDD1_1933 METAL5_495000_3507000 METAL5_495000_3519000 0.048
R_VDD1_1934 METAL5_495000_3519000 METAL5_495000_3641000 0.488
R_VDD1_1935 METAL5_495000_3641000 METAL5_495000_3653000 0.048
R_VDD1_1936 METAL5_495000_3653000 METAL5_495000_3665000 0.048
R_VDD1_1937 METAL5_495000_3665000 METAL5_496000_3665000 0.004
R_VDD1_1938 METAL5_496000_3665000 METAL5_498000_3665000 0.008
R_VDD1_1939 METAL5_498000_3665000 METAL5_500000_3665000 0.008
R_VDD1_1940 METAL5_500000_3665000 METAL5_506000_3665000 0.024
R_VDD1_1941 METAL5_506000_3665000 METAL5_507000_3665000 0.004
R_VDD1_1942 METAL5_507000_3665000 METAL4_507000_3665000 0.1
R_VDD1_1943 METAL4_507000_3665000 METAL4_508000_3665000 0.008
R_VDD1_1944 METAL4_508000_3665000 METAL4_510000_3665000 0.016
R_VDD1_1945 METAL4_510000_3665000 METAL4_512000_3665000 0.016
R_VDD1_1946 METAL4_512000_3665000 METAL4_519000_3665000 0.056
R_VDD1_1947 METAL4_519000_3665000 METAL4_522000_3665000 0.024
R_VDD1_1948 METAL4_522000_3665000 METAL4_524000_3665000 0.016
R_VDD1_1949 METAL4_524000_3665000 METAL4_531000_3665000 0.056
R_VDD1_1950 METAL4_531000_3665000 METAL4_536000_3665000 0.04
R_VDD1_1951 METAL4_536000_3665000 METAL4_543000_3665000 0.056
R_VDD1_1952 METAL4_543000_3665000 METAL5_543000_3665000 0.1
R_VDD1_1953 METAL5_543000_3665000 METAL6_543000_3665000 0.1
R_VDD1_1954 METAL6_245000_3665000 METAL6_257000_3665000 0.024
R_VDD1_1955 METAL4_386000_1989000 METAL4_384000_1989000 0.016
R_VDD1_1956 METAL4_384000_1989000 METAL4_378000_1989000 0.048
R_VDD1_1957 METAL4_378000_1989000 METAL4_376000_1989000 0.016
R_VDD1_1958 METAL4_376000_1989000 METAL4_374000_1989000 0.016
R_VDD1_1959 METAL4_374000_1989000 METAL4_374000_2001000 0.096
R_VDD1_1960 METAL4_374000_2001000 METAL4_374000_2013000 0.096
R_VDD1_1961 METAL4_374000_2013000 METAL4_372000_2013000 0.016
R_VDD1_1962 METAL4_372000_2013000 METAL4_366000_2013000 0.048
R_VDD1_1963 METAL4_366000_2013000 METAL4_364000_2013000 0.016
R_VDD1_1964 METAL4_364000_2013000 METAL4_362000_2013000 0.016
R_VDD1_1965 METAL4_362000_2013000 METAL4_360000_2013000 0.016
R_VDD1_1966 METAL4_360000_2013000 METAL4_354000_2013000 0.048
R_VDD1_1967 METAL4_354000_2013000 METAL4_352000_2013000 0.016
R_VDD1_1968 METAL4_352000_2013000 METAL4_350000_2013000 0.016
R_VDD1_1969 METAL4_350000_2013000 METAL4_348000_2013000 0.016
R_VDD1_1970 METAL4_348000_2013000 METAL4_342000_2013000 0.048
R_VDD1_1971 METAL4_342000_2013000 METAL4_340000_2013000 0.016
R_VDD1_1972 METAL4_340000_2013000 METAL4_338000_2013000 0.016
R_VDD1_1973 METAL4_338000_2013000 METAL4_336000_2013000 0.016
R_VDD1_1974 METAL4_336000_2013000 METAL4_330000_2013000 0.048
R_VDD1_1975 METAL4_330000_2013000 METAL4_329000_2013000 0.008
R_VDD1_1976 METAL4_329000_2013000 METAL4_328000_2013000 0.008
R_VDD1_1977 METAL4_328000_2013000 METAL4_326000_2013000 0.016
R_VDD1_1978 METAL4_326000_2013000 METAL4_324000_2013000 0.016
R_VDD1_1979 METAL4_324000_2013000 METAL5_324000_2013000 0.1
R_VDD1_1980 METAL5_324000_2013000 METAL5_324000_2025000 0.048
R_VDD1_1981 METAL5_324000_2025000 METAL5_324000_2093000 0.272
R_VDD1_1982 METAL5_324000_2093000 METAL5_324000_2107000 0.056
R_VDD1_1983 METAL5_324000_2107000 METAL5_324000_2217000 0.44
R_VDD1_1984 METAL5_324000_2217000 METAL5_324000_2229000 0.048
R_VDD1_1985 METAL5_324000_2229000 METAL5_324000_2241000 0.048
R_VDD1_1986 METAL5_324000_2241000 METAL4_324000_2241000 0.1
R_VDD1_1987 METAL4_324000_2241000 METAL4_324000_2253000 0.096
R_VDD1_1988 METAL4_324000_2253000 METAL4_324000_2265000 0.096
R_VDD1_1989 METAL4_324000_2265000 METAL4_318000_2265000 0.048
R_VDD1_1990 METAL4_318000_2265000 METAL4_317000_2265000 0.008
R_VDD1_1991 METAL4_317000_2265000 METAL4_316000_2265000 0.008
R_VDD1_1992 METAL4_316000_2265000 METAL4_314000_2265000 0.016
R_VDD1_1993 METAL4_314000_2265000 METAL4_312000_2265000 0.016
R_VDD1_1994 METAL4_312000_2265000 METAL4_306000_2265000 0.048
R_VDD1_1995 METAL4_306000_2265000 METAL4_305000_2265000 0.008
R_VDD1_1996 METAL4_305000_2265000 METAL4_304000_2265000 0.008
R_VDD1_1997 METAL4_304000_2265000 METAL4_302000_2265000 0.016
R_VDD1_1998 METAL4_302000_2265000 METAL4_300000_2265000 0.016
R_VDD1_1999 METAL4_300000_2265000 METAL4_300000_2277000 0.096
R_VDD1_2000 METAL4_300000_2277000 METAL5_300000_2277000 0.1
R_VDD1_2001 METAL5_300000_2277000 METAL5_300000_2289000 0.048
R_VDD1_2002 METAL5_300000_2289000 METAL5_300000_2341000 0.208
R_VDD1_2003 METAL5_300000_2341000 METAL5_300000_2353000 0.048
R_VDD1_2004 METAL5_300000_2353000 METAL5_300000_2365000 0.048
R_VDD1_2005 METAL5_300000_2365000 METAL5_300000_2377000 0.048
R_VDD1_2006 METAL5_300000_2377000 METAL5_300000_2389000 0.048
R_VDD1_2007 METAL5_300000_2389000 METAL5_300000_2401000 0.048
R_VDD1_2008 METAL5_300000_2401000 METAL5_300000_2413000 0.048
R_VDD1_2009 METAL5_300000_2413000 METAL5_300000_2453000 0.16
R_VDD1_2010 METAL5_300000_2453000 METAL5_300000_2465000 0.048
R_VDD1_2011 METAL5_300000_2465000 METAL5_300000_2477000 0.048
R_VDD1_2012 METAL5_300000_2477000 METAL5_300000_2489000 0.048
R_VDD1_2013 METAL5_300000_2489000 METAL5_300000_2553000 0.256
R_VDD1_2014 METAL5_300000_2553000 METAL5_300000_2565000 0.048
R_VDD1_2015 METAL5_300000_2565000 METAL5_300000_2577000 0.048
R_VDD1_2016 METAL5_300000_2577000 METAL5_300000_2593000 0.064
R_VDD1_2017 METAL5_300000_2593000 METAL4_300000_2593000 0.1
R_VDD1_2018 METAL4_300000_2593000 METAL4_302000_2593000 0.016
R_VDD1_2019 METAL4_302000_2593000 METAL4_304000_2593000 0.016
R_VDD1_2020 METAL4_304000_2593000 METAL4_305000_2593000 0.008
R_VDD1_2021 METAL4_305000_2593000 METAL4_306000_2593000 0.008
R_VDD1_2022 METAL4_306000_2593000 METAL4_312000_2593000 0.048
R_VDD1_2023 METAL4_312000_2593000 METAL4_314000_2593000 0.016
R_VDD1_2024 METAL4_314000_2593000 METAL4_316000_2593000 0.016
R_VDD1_2025 METAL4_316000_2593000 METAL4_317000_2593000 0.008
R_VDD1_2026 METAL4_317000_2593000 METAL4_318000_2593000 0.008
R_VDD1_2027 METAL4_318000_2593000 METAL4_324000_2593000 0.048
R_VDD1_2028 METAL4_324000_2593000 METAL4_326000_2593000 0.016
R_VDD1_2029 METAL4_326000_2593000 METAL4_328000_2593000 0.016
R_VDD1_2030 METAL4_328000_2593000 METAL4_329000_2593000 0.008
R_VDD1_2031 METAL4_329000_2593000 METAL4_330000_2593000 0.008
R_VDD1_2032 METAL4_330000_2593000 METAL4_336000_2593000 0.048
R_VDD1_2033 METAL4_336000_2593000 METAL4_338000_2593000 0.016
R_VDD1_2034 METAL4_338000_2593000 METAL4_340000_2593000 0.016
R_VDD1_2035 METAL4_340000_2593000 METAL4_342000_2593000 0.016
R_VDD1_2036 METAL4_342000_2593000 METAL4_348000_2593000 0.048
R_VDD1_2037 METAL4_348000_2593000 METAL4_350000_2593000 0.016
R_VDD1_2038 METAL4_350000_2593000 METAL4_352000_2593000 0.016
R_VDD1_2039 METAL4_352000_2593000 METAL4_354000_2593000 0.016
R_VDD1_2040 METAL4_354000_2593000 METAL4_360000_2593000 0.048
R_VDD1_2041 METAL4_360000_2593000 METAL4_360000_2605000 0.096
R_VDD1_2042 METAL4_360000_2605000 METAL4_360000_2617000 0.096
R_VDD1_2043 METAL4_360000_2617000 METAL4_360000_2629000 0.096
R_VDD1_2044 METAL4_360000_2629000 METAL4_360000_2641000 0.096
R_VDD1_2045 METAL4_360000_2641000 METAL4_360000_2653000 0.096
R_VDD1_2046 METAL4_360000_2653000 METAL4_360000_2665000 0.096
R_VDD1_2047 METAL4_360000_2665000 METAL4_360000_2677000 0.096
R_VDD1_2048 METAL4_360000_2677000 METAL5_360000_2677000 0.1
R_VDD1_2049 METAL5_360000_2677000 METAL5_360000_2689000 0.048
R_VDD1_2050 METAL5_360000_2689000 METAL5_360000_2701000 0.048
R_VDD1_2051 METAL5_360000_2701000 METAL5_360000_2713000 0.048
R_VDD1_2052 METAL5_360000_2713000 METAL5_360000_2769000 0.224
R_VDD1_2053 METAL5_360000_2769000 METAL5_360000_2781000 0.048
R_VDD1_2054 METAL5_360000_2781000 METAL4_360000_2781000 0.1
R_VDD1_2055 METAL4_360000_2781000 METAL4_360000_2793000 0.096
R_VDD1_2056 METAL4_360000_2793000 METAL4_360000_2805000 0.096
R_VDD1_2057 METAL4_360000_2805000 METAL4_360000_2807000 0.016
R_VDD1_2058 METAL4_360000_2807000 METAL4_360000_2817000 0.08
R_VDD1_2059 METAL4_360000_2817000 METAL4_354000_2817000 0.048
R_VDD1_2060 METAL4_354000_2817000 METAL4_352000_2817000 0.016
R_VDD1_2061 METAL4_352000_2817000 METAL4_350000_2817000 0.016
R_VDD1_2062 METAL4_350000_2817000 METAL5_350000_2817000 0.1
R_VDD1_2063 METAL5_350000_2817000 METAL5_350000_2929000 0.448
R_VDD1_2064 METAL5_350000_2929000 METAL5_350000_2941000 0.048
R_VDD1_2065 METAL5_350000_2941000 METAL5_350000_2953000 0.048
R_VDD1_2066 METAL5_350000_2953000 METAL5_350000_2965000 0.048
R_VDD1_2067 METAL5_350000_2965000 METAL5_350000_2977000 0.048
R_VDD1_2068 METAL5_350000_2977000 METAL5_350000_2989000 0.048
R_VDD1_2069 METAL5_350000_2989000 METAL5_350000_3001000 0.048
R_VDD1_2070 METAL5_350000_3001000 METAL5_350000_3041000 0.16
R_VDD1_2071 METAL5_350000_3041000 METAL5_350000_3053000 0.048
R_VDD1_2072 METAL5_350000_3053000 METAL5_350000_3065000 0.048
R_VDD1_2073 METAL5_350000_3065000 METAL5_350000_3077000 0.048
R_VDD1_2074 METAL5_350000_3077000 METAL5_350000_3089000 0.048
R_VDD1_2075 METAL5_350000_3089000 METAL5_350000_3101000 0.048
R_VDD1_2076 METAL5_350000_3101000 METAL5_350000_3153000 0.208
R_VDD1_2077 METAL5_350000_3153000 METAL5_350000_3165000 0.048
R_VDD1_2078 METAL5_350000_3165000 METAL5_348000_3165000 0.008
R_VDD1_2079 METAL5_348000_3165000 METAL4_348000_3165000 0.1
R_VDD1_2080 METAL4_348000_3165000 METAL4_342000_3165000 0.048
R_VDD1_2081 METAL4_342000_3165000 METAL4_340000_3165000 0.016
R_VDD1_2082 METAL4_340000_3165000 METAL4_338000_3165000 0.016
R_VDD1_2083 METAL4_338000_3165000 METAL4_336000_3165000 0.016
R_VDD1_2084 METAL4_336000_3165000 METAL4_330000_3165000 0.048
R_VDD1_2085 METAL4_330000_3165000 METAL4_329000_3165000 0.008
R_VDD1_2086 METAL4_329000_3165000 METAL4_328000_3165000 0.008
R_VDD1_2087 METAL4_328000_3165000 METAL4_326000_3165000 0.016
R_VDD1_2088 METAL4_326000_3165000 METAL4_324000_3165000 0.016
R_VDD1_2089 METAL4_324000_3165000 METAL4_318000_3165000 0.048
R_VDD1_2090 METAL4_318000_3165000 METAL4_317000_3165000 0.008
R_VDD1_2091 METAL4_317000_3165000 METAL4_316000_3165000 0.008
R_VDD1_2092 METAL4_316000_3165000 METAL4_314000_3165000 0.016
R_VDD1_2093 METAL4_314000_3165000 METAL4_312000_3165000 0.016
R_VDD1_2094 METAL4_312000_3165000 METAL4_306000_3165000 0.048
R_VDD1_2095 METAL4_306000_3165000 METAL4_305000_3165000 0.008
R_VDD1_2096 METAL4_305000_3165000 METAL4_304000_3165000 0.008
R_VDD1_2097 METAL4_304000_3165000 METAL4_302000_3165000 0.016
R_VDD1_2098 METAL4_302000_3165000 METAL4_300000_3165000 0.016
R_VDD1_2099 METAL4_300000_3165000 METAL4_294000_3165000 0.048
R_VDD1_2100 METAL4_294000_3165000 METAL4_293000_3165000 0.008
R_VDD1_2101 METAL4_293000_3165000 METAL5_293000_3165000 0.1
R_VDD1_2102 METAL5_293000_3165000 METAL5_293000_3177000 0.048
R_VDD1_2103 METAL5_293000_3177000 METAL5_293000_3189000 0.048
R_VDD1_2104 METAL5_293000_3189000 METAL5_293000_3253000 0.256
R_VDD1_2105 METAL5_293000_3253000 METAL5_293000_3265000 0.048
R_VDD1_2106 METAL5_293000_3265000 METAL5_293000_3277000 0.048
R_VDD1_2107 METAL5_293000_3277000 METAL5_293000_3289000 0.048
R_VDD1_2108 METAL5_293000_3289000 METAL5_293000_3329000 0.16
R_VDD1_2109 METAL5_293000_3329000 METAL5_293000_3341000 0.048
R_VDD1_2110 METAL5_293000_3341000 METAL4_293000_3341000 0.1
R_VDD1_2111 METAL4_293000_3341000 METAL4_293000_3353000 0.096
R_VDD1_2112 METAL4_293000_3353000 METAL4_293000_3365000 0.096
R_VDD1_2113 METAL4_293000_3365000 METAL4_293000_3377000 0.096
R_VDD1_2114 METAL4_293000_3377000 METAL4_293000_3389000 0.096
R_VDD1_2115 METAL4_293000_3389000 METAL5_293000_3389000 0.1
R_VDD1_2116 METAL5_293000_3389000 METAL5_293000_3401000 0.048
R_VDD1_2117 METAL5_293000_3401000 METAL5_293000_3413000 0.048
R_VDD1_2118 METAL5_293000_3413000 METAL5_293000_3425000 0.048
R_VDD1_2119 METAL5_293000_3425000 METAL5_293000_3481000 0.224
R_VDD1_2120 METAL5_293000_3481000 METAL5_293000_3493000 0.048
R_VDD1_2121 METAL5_293000_3493000 METAL5_293000_3495000 0.008
R_VDD1_2122 METAL5_293000_3495000 METAL5_293000_3505000 0.04
R_VDD1_2123 METAL5_293000_3505000 METAL5_293000_3507000 0.008
R_VDD1_2124 METAL5_293000_3507000 METAL5_293000_3519000 0.048
R_VDD1_2125 METAL5_293000_3519000 METAL5_293000_3641000 0.488
R_VDD1_2126 METAL5_293000_3641000 METAL5_293000_3653000 0.048
R_VDD1_2127 METAL5_293000_3653000 METAL5_293000_3665000 0.048
R_VDD1_2128 METAL5_293000_3665000 METAL5_292000_3665000 0.004
R_VDD1_2129 METAL5_292000_3665000 METAL5_290000_3665000 0.008
R_VDD1_2130 METAL5_290000_3665000 METAL5_288000_3665000 0.008
R_VDD1_2131 METAL5_288000_3665000 METAL5_282000_3665000 0.024
R_VDD1_2132 METAL5_282000_3665000 METAL5_281000_3665000 0.004
R_VDD1_2133 METAL5_281000_3665000 METAL4_281000_3665000 0.1
R_VDD1_2134 METAL4_281000_3665000 METAL4_280000_3665000 0.008
R_VDD1_2135 METAL4_280000_3665000 METAL4_278000_3665000 0.016
R_VDD1_2136 METAL4_278000_3665000 METAL4_276000_3665000 0.016
R_VDD1_2137 METAL4_276000_3665000 METAL4_270000_3665000 0.048
R_VDD1_2138 METAL4_270000_3665000 METAL4_269000_3665000 0.008
R_VDD1_2139 METAL4_269000_3665000 METAL4_266000_3665000 0.024
R_VDD1_2140 METAL4_266000_3665000 METAL4_264000_3665000 0.016
R_VDD1_2141 METAL4_264000_3665000 METAL4_258000_3665000 0.048
R_VDD1_2142 METAL4_258000_3665000 METAL4_257000_3665000 0.008
R_VDD1_2143 METAL4_257000_3665000 METAL5_257000_3665000 0.1
R_VDD1_2144 METAL5_257000_3665000 METAL6_257000_3665000 0.1
R_VDD1_2145 METAL6_555000_2965000 METAL6_543000_2965000 0.024
R_VDD1_2146 METAL4_531000_2013000 METAL4_536000_2013000 0.04
R_VDD1_2147 METAL4_536000_2013000 METAL4_543000_2013000 0.056
R_VDD1_2148 METAL4_543000_2013000 METAL5_543000_2013000 0.1
R_VDD1_2149 METAL5_543000_2013000 METAL5_543000_2025000 0.048
R_VDD1_2150 METAL5_543000_2025000 METAL5_543000_2093000 0.272
R_VDD1_2151 METAL5_543000_2093000 METAL5_543000_2107000 0.056
R_VDD1_2152 METAL5_543000_2107000 METAL5_543000_2217000 0.44
R_VDD1_2153 METAL5_543000_2217000 METAL5_543000_2229000 0.048
R_VDD1_2154 METAL5_543000_2229000 METAL4_543000_2229000 0.1
R_VDD1_2155 METAL4_543000_2229000 METAL4_536000_2229000 0.056
R_VDD1_2156 METAL4_536000_2229000 METAL4_531000_2229000 0.04
R_VDD1_2157 METAL4_531000_2229000 METAL4_524000_2229000 0.056
R_VDD1_2158 METAL4_524000_2229000 METAL4_522000_2229000 0.016
R_VDD1_2159 METAL4_522000_2229000 METAL4_519000_2229000 0.024
R_VDD1_2160 METAL4_519000_2229000 METAL4_519000_2241000 0.096
R_VDD1_2161 METAL4_519000_2241000 METAL4_519000_2253000 0.096
R_VDD1_2162 METAL4_519000_2253000 METAL4_512000_2253000 0.056
R_VDD1_2163 METAL4_512000_2253000 METAL4_510000_2253000 0.016
R_VDD1_2164 METAL4_510000_2253000 METAL4_508000_2253000 0.016
R_VDD1_2165 METAL4_508000_2253000 METAL4_507000_2253000 0.008
R_VDD1_2166 METAL4_507000_2253000 METAL4_506000_2253000 0.008
R_VDD1_2167 METAL4_506000_2253000 METAL4_500000_2253000 0.048
R_VDD1_2168 METAL4_500000_2253000 METAL4_498000_2253000 0.016
R_VDD1_2169 METAL4_498000_2253000 METAL4_496000_2253000 0.016
R_VDD1_2170 METAL4_496000_2253000 METAL4_495000_2253000 0.008
R_VDD1_2171 METAL4_495000_2253000 METAL4_495000_2265000 0.096
R_VDD1_2172 METAL4_495000_2265000 METAL4_495000_2277000 0.096
R_VDD1_2173 METAL4_495000_2277000 METAL4_495000_2289000 0.096
R_VDD1_2174 METAL4_495000_2289000 METAL4_495000_2341000 0.416
R_VDD1_2175 METAL4_495000_2341000 METAL4_494000_2341000 0.008
R_VDD1_2176 METAL4_494000_2341000 METAL4_488000_2341000 0.048
R_VDD1_2177 METAL4_488000_2341000 METAL4_486000_2341000 0.016
R_VDD1_2178 METAL4_486000_2341000 METAL4_484000_2341000 0.016
R_VDD1_2179 METAL4_484000_2341000 METAL4_483000_2341000 0.008
R_VDD1_2180 METAL4_483000_2341000 METAL4_483000_2353000 0.096
R_VDD1_2181 METAL4_483000_2353000 METAL4_483000_2365000 0.096
R_VDD1_2182 METAL4_483000_2365000 METAL4_483000_2377000 0.096
R_VDD1_2183 METAL4_483000_2377000 METAL4_483000_2389000 0.096
R_VDD1_2184 METAL4_483000_2389000 METAL5_483000_2389000 0.1
R_VDD1_2185 METAL5_483000_2389000 METAL5_483000_2401000 0.048
R_VDD1_2186 METAL5_483000_2401000 METAL5_483000_2413000 0.048
R_VDD1_2187 METAL5_483000_2413000 METAL5_483000_2453000 0.16
R_VDD1_2188 METAL5_483000_2453000 METAL5_483000_2465000 0.048
R_VDD1_2189 METAL5_483000_2465000 METAL5_483000_2477000 0.048
R_VDD1_2190 METAL5_483000_2477000 METAL5_483000_2489000 0.048
R_VDD1_2191 METAL5_483000_2489000 METAL5_483000_2553000 0.256
R_VDD1_2192 METAL5_483000_2553000 METAL5_483000_2565000 0.048
R_VDD1_2193 METAL5_483000_2565000 METAL5_483000_2577000 0.048
R_VDD1_2194 METAL5_483000_2577000 METAL5_483000_2581000 0.016
R_VDD1_2195 METAL5_483000_2581000 METAL5_483000_2593000 0.048
R_VDD1_2196 METAL5_483000_2593000 METAL5_483000_2605000 0.048
R_VDD1_2197 METAL5_483000_2605000 METAL5_483000_2617000 0.048
R_VDD1_2198 METAL5_483000_2617000 METAL5_484000_2617000 0.004
R_VDD1_2199 METAL5_484000_2617000 METAL5_486000_2617000 0.008
R_VDD1_2200 METAL5_486000_2617000 METAL5_488000_2617000 0.008
R_VDD1_2201 METAL5_488000_2617000 METAL5_494000_2617000 0.024
R_VDD1_2202 METAL5_494000_2617000 METAL5_495000_2617000 0.004
R_VDD1_2203 METAL5_495000_2617000 METAL4_495000_2617000 0.1
R_VDD1_2204 METAL4_495000_2617000 METAL4_496000_2617000 0.008
R_VDD1_2205 METAL4_496000_2617000 METAL4_498000_2617000 0.016
R_VDD1_2206 METAL4_498000_2617000 METAL4_500000_2617000 0.016
R_VDD1_2207 METAL4_500000_2617000 METAL4_500000_2629000 0.096
R_VDD1_2208 METAL4_500000_2629000 METAL4_500000_2641000 0.096
R_VDD1_2209 METAL4_500000_2641000 METAL4_506000_2641000 0.048
R_VDD1_2210 METAL4_506000_2641000 METAL4_507000_2641000 0.008
R_VDD1_2211 METAL4_507000_2641000 METAL4_508000_2641000 0.008
R_VDD1_2212 METAL4_508000_2641000 METAL4_510000_2641000 0.016
R_VDD1_2213 METAL4_510000_2641000 METAL4_512000_2641000 0.016
R_VDD1_2214 METAL4_512000_2641000 METAL4_519000_2641000 0.056
R_VDD1_2215 METAL4_519000_2641000 METAL4_522000_2641000 0.024
R_VDD1_2216 METAL4_522000_2641000 METAL4_524000_2641000 0.016
R_VDD1_2217 METAL4_524000_2641000 METAL4_531000_2641000 0.056
R_VDD1_2218 METAL4_531000_2641000 METAL4_531000_2653000 0.096
R_VDD1_2219 METAL4_531000_2653000 METAL4_531000_2665000 0.096
R_VDD1_2220 METAL4_531000_2665000 METAL4_531000_2677000 0.096
R_VDD1_2221 METAL4_531000_2677000 METAL4_531000_2689000 0.096
R_VDD1_2222 METAL4_531000_2689000 METAL4_531000_2701000 0.096
R_VDD1_2223 METAL4_531000_2701000 METAL5_531000_2701000 0.1
R_VDD1_2224 METAL5_531000_2701000 METAL5_531000_2713000 0.048
R_VDD1_2225 METAL5_531000_2713000 METAL5_531000_2769000 0.224
R_VDD1_2226 METAL5_531000_2769000 METAL5_531000_2781000 0.048
R_VDD1_2227 METAL5_531000_2781000 METAL5_531000_2793000 0.048
R_VDD1_2228 METAL5_531000_2793000 METAL5_531000_2805000 0.048
R_VDD1_2229 METAL5_531000_2805000 METAL5_536000_2805000 0.02
R_VDD1_2230 METAL5_536000_2805000 METAL5_543000_2805000 0.028
R_VDD1_2231 METAL5_543000_2805000 METAL5_543000_2807000 0.008
R_VDD1_2232 METAL5_543000_2807000 METAL5_543000_2817000 0.04
R_VDD1_2233 METAL5_543000_2817000 METAL5_543000_2829000 0.048
R_VDD1_2234 METAL5_543000_2829000 METAL5_543000_2929000 0.4
R_VDD1_2235 METAL5_543000_2929000 METAL5_543000_2941000 0.048
R_VDD1_2236 METAL5_543000_2941000 METAL4_543000_2941000 0.1
R_VDD1_2237 METAL4_543000_2941000 METAL4_543000_2953000 0.096
R_VDD1_2238 METAL4_543000_2953000 METAL4_543000_2965000 0.096
R_VDD1_2239 METAL4_543000_2965000 METAL5_543000_2965000 0.1
R_VDD1_2240 METAL5_543000_2965000 METAL6_543000_2965000 0.1
R_VDD1_2241 METAL6_245000_2965000 METAL6_257000_2965000 0.024
R_VDD1_2242 METAL5_276000_2769000 METAL5_270000_2769000 0.024
R_VDD1_2243 METAL5_270000_2769000 METAL5_269000_2769000 0.004
R_VDD1_2244 METAL5_269000_2769000 METAL5_266000_2769000 0.012
R_VDD1_2245 METAL5_266000_2769000 METAL5_264000_2769000 0.008
R_VDD1_2246 METAL5_264000_2769000 METAL5_258000_2769000 0.024
R_VDD1_2247 METAL5_258000_2769000 METAL5_257000_2769000 0.004
R_VDD1_2248 METAL5_257000_2769000 METAL5_257000_2781000 0.048
R_VDD1_2249 METAL5_257000_2781000 METAL4_257000_2781000 0.1
R_VDD1_2250 METAL4_257000_2781000 METAL4_257000_2793000 0.096
R_VDD1_2251 METAL4_257000_2793000 METAL4_257000_2805000 0.096
R_VDD1_2252 METAL4_257000_2805000 METAL5_257000_2805000 0.1
R_VDD1_2253 METAL5_257000_2805000 METAL5_257000_2807000 0.008
R_VDD1_2254 METAL5_257000_2807000 METAL5_257000_2817000 0.04
R_VDD1_2255 METAL5_257000_2817000 METAL5_257000_2829000 0.048
R_VDD1_2256 METAL5_257000_2829000 METAL5_257000_2929000 0.4
R_VDD1_2257 METAL5_257000_2929000 METAL5_257000_2941000 0.048
R_VDD1_2258 METAL5_257000_2941000 METAL4_257000_2941000 0.1
R_VDD1_2259 METAL4_257000_2941000 METAL4_257000_2953000 0.096
R_VDD1_2260 METAL4_257000_2953000 METAL4_257000_2965000 0.096
R_VDD1_2261 METAL4_257000_2965000 METAL5_257000_2965000 0.1
R_VDD1_2262 METAL5_257000_2965000 METAL6_257000_2965000 0.1
R_VDD1_2263 METAL6_555000_2265000 METAL6_543000_2265000 0.024
R_VDD1_2264 METAL6_300000_8000 METAL5_300000_8000 0.1
R_VDD1_2265 METAL5_300000_8000 METAL5_294000_8000 0.024
R_VDD1_2266 METAL5_294000_8000 METAL5_293000_8000 0.004
R_VDD1_2267 METAL5_293000_8000 METAL5_292000_8000 0.004
R_VDD1_2268 METAL5_292000_8000 METAL5_290000_8000 0.008
R_VDD1_2269 METAL5_290000_8000 METAL5_288000_8000 0.008
R_VDD1_2270 METAL5_288000_8000 METAL5_282000_8000 0.024
R_VDD1_2271 METAL5_282000_8000 METAL5_281000_8000 0.004
R_VDD1_2272 METAL5_281000_8000 METAL5_280000_8000 0.004
R_VDD1_2273 METAL5_280000_8000 METAL5_278000_8000 0.008
R_VDD1_2274 METAL5_278000_8000 METAL5_276000_8000 0.008
R_VDD1_2275 METAL5_276000_8000 METAL5_270000_8000 0.024
R_VDD1_2276 METAL5_270000_8000 METAL5_270000_20000 0.048
R_VDD1_2277 METAL5_270000_20000 METAL5_270000_32000 0.048
R_VDD1_2278 METAL5_270000_32000 METAL5_270000_44000 0.048
R_VDD1_2279 METAL5_270000_44000 METAL5_276000_44000 0.024
R_VDD1_2280 METAL5_276000_44000 METAL5_278000_44000 0.008
R_VDD1_2281 METAL5_278000_44000 METAL5_280000_44000 0.008
R_VDD1_2282 METAL5_280000_44000 METAL5_280000_45000 0.004
R_VDD1_2283 METAL5_280000_45000 METAL5_280000_56000 0.044
R_VDD1_2284 METAL5_280000_56000 METAL5_281000_56000 0.004
R_VDD1_2285 METAL5_281000_56000 METAL5_282000_56000 0.004
R_VDD1_2286 METAL5_282000_56000 METAL5_282000_57000 0.004
R_VDD1_2287 METAL5_282000_57000 METAL5_282000_68000 0.044
R_VDD1_2288 METAL5_282000_68000 METAL5_282000_69000 0.004
R_VDD1_2289 METAL5_282000_69000 METAL5_282000_80000 0.044
R_VDD1_2290 METAL5_282000_80000 METAL5_282000_81000 0.004
R_VDD1_2291 METAL5_282000_81000 METAL5_282000_92000 0.044
R_VDD1_2292 METAL5_282000_92000 METAL5_288000_92000 0.024
R_VDD1_2293 METAL5_288000_92000 METAL5_290000_92000 0.008
R_VDD1_2294 METAL5_290000_92000 METAL5_292000_92000 0.008
R_VDD1_2295 METAL5_292000_92000 METAL4_292000_92000 0.1
R_VDD1_2296 METAL4_292000_92000 METAL4_293000_92000 0.008
R_VDD1_2297 METAL4_293000_92000 METAL4_294000_92000 0.008
R_VDD1_2298 METAL4_294000_92000 METAL4_300000_92000 0.048
R_VDD1_2299 METAL4_300000_92000 METAL4_302000_92000 0.016
R_VDD1_2300 METAL4_302000_92000 METAL4_304000_92000 0.016
R_VDD1_2301 METAL4_304000_92000 METAL4_305000_92000 0.008
R_VDD1_2302 METAL4_305000_92000 METAL4_306000_92000 0.008
R_VDD1_2303 METAL4_306000_92000 METAL4_312000_92000 0.048
R_VDD1_2304 METAL4_312000_92000 METAL4_314000_92000 0.016
R_VDD1_2305 METAL4_314000_92000 METAL4_316000_92000 0.016
R_VDD1_2306 METAL4_316000_92000 METAL4_317000_92000 0.008
R_VDD1_2307 METAL4_317000_92000 METAL4_318000_92000 0.008
R_VDD1_2308 METAL4_318000_92000 METAL4_324000_92000 0.048
R_VDD1_2309 METAL4_324000_92000 METAL4_326000_92000 0.016
R_VDD1_2310 METAL4_326000_92000 METAL4_328000_92000 0.016
R_VDD1_2311 METAL4_328000_92000 METAL4_329000_92000 0.008
R_VDD1_2312 METAL4_329000_92000 METAL4_330000_92000 0.008
R_VDD1_2313 METAL4_330000_92000 METAL5_330000_92000 0.1
R_VDD1_2314 METAL5_330000_92000 METAL5_330000_93000 0.004
R_VDD1_2315 METAL5_330000_93000 METAL5_330000_105000 0.048
R_VDD1_2316 METAL5_330000_105000 METAL5_330000_109000 0.016
R_VDD1_2317 METAL5_330000_109000 METAL5_330000_117000 0.032
R_VDD1_2318 METAL5_330000_117000 METAL5_330000_121000 0.016
R_VDD1_2319 METAL5_330000_121000 METAL5_330000_129000 0.032
R_VDD1_2320 METAL5_330000_129000 METAL5_330000_133000 0.016
R_VDD1_2321 METAL5_330000_133000 METAL5_330000_141000 0.032
R_VDD1_2322 METAL5_330000_141000 METAL5_330000_145000 0.016
R_VDD1_2323 METAL5_330000_145000 METAL5_330000_153000 0.032
R_VDD1_2324 METAL5_330000_153000 METAL5_330000_157000 0.016
R_VDD1_2325 METAL5_330000_157000 METAL5_330000_165000 0.032
R_VDD1_2326 METAL5_330000_165000 METAL5_330000_169000 0.016
R_VDD1_2327 METAL5_330000_169000 METAL5_330000_177000 0.032
R_VDD1_2328 METAL5_330000_177000 METAL5_330000_181000 0.016
R_VDD1_2329 METAL5_330000_181000 METAL5_330000_193000 0.048
R_VDD1_2330 METAL5_330000_193000 METAL5_330000_205000 0.048
R_VDD1_2331 METAL5_330000_205000 METAL5_330000_217000 0.048
R_VDD1_2332 METAL5_330000_217000 METAL5_330000_229000 0.048
R_VDD1_2333 METAL5_330000_229000 METAL5_330000_233000 0.016
R_VDD1_2334 METAL5_330000_233000 METAL4_330000_233000 0.1
R_VDD1_2335 METAL4_330000_233000 METAL3_330000_233000 0.1
R_VDD1_2336 METAL3_330000_233000 METAL3_330000_241000 0.064
R_VDD1_2337 METAL3_330000_241000 METAL3_336000_241000 0.048
R_VDD1_2338 METAL3_336000_241000 METAL3_336000_245000 0.032
R_VDD1_2339 METAL3_336000_245000 METAL3_336000_253000 0.064
R_VDD1_2340 METAL3_336000_253000 METAL3_336000_257000 0.032
R_VDD1_2341 METAL3_336000_257000 METAL3_336000_265000 0.064
R_VDD1_2342 METAL3_336000_265000 METAL3_336000_269000 0.032
R_VDD1_2343 METAL3_336000_269000 METAL3_336000_277000 0.064
R_VDD1_2344 METAL3_336000_277000 METAL3_336000_281000 0.032
R_VDD1_2345 METAL3_336000_281000 METAL3_336000_289000 0.064
R_VDD1_2346 METAL3_336000_289000 METAL3_336000_293000 0.032
R_VDD1_2347 METAL3_336000_293000 METAL3_336000_301000 0.064
R_VDD1_2348 METAL3_336000_301000 METAL3_336000_305000 0.032
R_VDD1_2349 METAL3_336000_305000 METAL3_336000_313000 0.064
R_VDD1_2350 METAL3_336000_313000 METAL3_336000_317000 0.032
R_VDD1_2351 METAL3_336000_317000 METAL3_336000_329000 0.096
R_VDD1_2352 METAL3_336000_329000 METAL3_336000_341000 0.096
R_VDD1_2353 METAL3_336000_341000 METAL3_336000_353000 0.096
R_VDD1_2354 METAL3_336000_353000 METAL3_336000_365000 0.096
R_VDD1_2355 METAL3_336000_365000 METAL3_336000_377000 0.096
R_VDD1_2356 METAL3_336000_377000 METAL3_336000_381000 0.032
R_VDD1_2357 METAL3_336000_381000 METAL3_336000_389000 0.064
R_VDD1_2358 METAL3_336000_389000 METAL3_336000_393000 0.032
R_VDD1_2359 METAL3_336000_393000 METAL3_336000_401000 0.064
R_VDD1_2360 METAL3_336000_401000 METAL3_336000_405000 0.032
R_VDD1_2361 METAL3_336000_405000 METAL3_336000_417000 0.096
R_VDD1_2362 METAL3_336000_417000 METAL3_336000_429000 0.096
R_VDD1_2363 METAL3_336000_429000 METAL3_336000_441000 0.096
R_VDD1_2364 METAL3_336000_441000 METAL3_336000_453000 0.096
R_VDD1_2365 METAL3_336000_453000 METAL3_336000_465000 0.096
R_VDD1_2366 METAL3_336000_465000 METAL3_336000_469000 0.032
R_VDD1_2367 METAL3_336000_469000 METAL3_336000_477000 0.064
R_VDD1_2368 METAL3_336000_477000 METAL3_336000_481000 0.032
R_VDD1_2369 METAL3_336000_481000 METAL3_336000_489000 0.064
R_VDD1_2370 METAL3_336000_489000 METAL3_336000_493000 0.032
R_VDD1_2371 METAL3_336000_493000 METAL3_336000_501000 0.064
R_VDD1_2372 METAL3_336000_501000 METAL3_336000_505000 0.032
R_VDD1_2373 METAL3_336000_505000 METAL3_336000_517000 0.096
R_VDD1_2374 METAL3_336000_517000 METAL3_336000_529000 0.096
R_VDD1_2375 METAL3_336000_529000 METAL3_336000_541000 0.096
R_VDD1_2376 METAL3_336000_541000 METAL3_336000_553000 0.096
R_VDD1_2377 METAL3_336000_553000 METAL3_336000_565000 0.096
R_VDD1_2378 METAL3_336000_565000 METAL3_336000_577000 0.096
R_VDD1_2379 METAL3_336000_577000 METAL3_336000_589000 0.096
R_VDD1_2380 METAL3_336000_589000 METAL3_336000_601000 0.096
R_VDD1_2381 METAL3_336000_601000 METAL3_336000_613000 0.096
R_VDD1_2382 METAL3_336000_613000 METAL3_338000_613000 0.016
R_VDD1_2383 METAL3_338000_613000 METAL3_340000_613000 0.016
R_VDD1_2384 METAL3_340000_613000 METAL3_342000_613000 0.016
R_VDD1_2385 METAL3_342000_613000 METAL3_348000_613000 0.048
R_VDD1_2386 METAL3_348000_613000 METAL3_350000_613000 0.016
R_VDD1_2387 METAL3_350000_613000 METAL3_352000_613000 0.016
R_VDD1_2388 METAL3_352000_613000 METAL3_354000_613000 0.016
R_VDD1_2389 METAL3_354000_613000 METAL3_360000_613000 0.048
R_VDD1_2390 METAL3_360000_613000 METAL3_362000_613000 0.016
R_VDD1_2391 METAL3_362000_613000 METAL3_364000_613000 0.016
R_VDD1_2392 METAL3_364000_613000 METAL3_366000_613000 0.016
R_VDD1_2393 METAL3_366000_613000 METAL3_372000_613000 0.048
R_VDD1_2394 METAL3_372000_613000 METAL3_374000_613000 0.016
R_VDD1_2395 METAL3_374000_613000 METAL3_376000_613000 0.016
R_VDD1_2396 METAL3_376000_613000 METAL3_378000_613000 0.016
R_VDD1_2397 METAL3_378000_613000 METAL3_384000_613000 0.048
R_VDD1_2398 METAL3_384000_613000 METAL3_386000_613000 0.016
R_VDD1_2399 METAL3_386000_613000 METAL3_388000_613000 0.016
R_VDD1_2400 METAL3_388000_613000 METAL3_390000_613000 0.016
R_VDD1_2401 METAL3_390000_613000 METAL3_396000_613000 0.048
R_VDD1_2402 METAL3_396000_613000 METAL3_398000_613000 0.016
R_VDD1_2403 METAL3_398000_613000 METAL3_400000_613000 0.016
R_VDD1_2404 METAL3_400000_613000 METAL3_402000_613000 0.016
R_VDD1_2405 METAL3_402000_613000 METAL3_404000_613000 0.016
R_VDD1_2406 METAL3_404000_613000 METAL3_408000_613000 0.032
R_VDD1_2407 METAL3_408000_613000 METAL3_410000_613000 0.016
R_VDD1_2408 METAL3_410000_613000 METAL3_412000_613000 0.016
R_VDD1_2409 METAL3_412000_613000 METAL3_414000_613000 0.016
R_VDD1_2410 METAL3_414000_613000 METAL3_416000_613000 0.016
R_VDD1_2411 METAL3_416000_613000 METAL3_420000_613000 0.032
R_VDD1_2412 METAL3_420000_613000 METAL3_422000_613000 0.016
R_VDD1_2413 METAL3_422000_613000 METAL3_424000_613000 0.016
R_VDD1_2414 METAL3_424000_613000 METAL3_426000_613000 0.016
R_VDD1_2415 METAL3_426000_613000 METAL3_428000_613000 0.016
R_VDD1_2416 METAL3_428000_613000 METAL3_432000_613000 0.032
R_VDD1_2417 METAL3_432000_613000 METAL3_434000_613000 0.016
R_VDD1_2418 METAL3_434000_613000 METAL3_436000_613000 0.016
R_VDD1_2419 METAL3_436000_613000 METAL3_438000_613000 0.016
R_VDD1_2420 METAL3_438000_613000 METAL3_440000_613000 0.016
R_VDD1_2421 METAL3_440000_613000 METAL3_444000_613000 0.032
R_VDD1_2422 METAL3_444000_613000 METAL3_446000_613000 0.016
R_VDD1_2423 METAL3_446000_613000 METAL3_448000_613000 0.016
R_VDD1_2424 METAL3_448000_613000 METAL3_450000_613000 0.016
R_VDD1_2425 METAL3_450000_613000 METAL3_452000_613000 0.016
R_VDD1_2426 METAL3_452000_613000 METAL3_458000_613000 0.048
R_VDD1_2427 METAL3_458000_613000 METAL3_460000_613000 0.016
R_VDD1_2428 METAL3_460000_613000 METAL3_462000_613000 0.016
R_VDD1_2429 METAL3_462000_613000 METAL3_464000_613000 0.016
R_VDD1_2430 METAL3_464000_613000 METAL3_470000_613000 0.048
R_VDD1_2431 METAL3_470000_613000 METAL3_471000_613000 0.008
R_VDD1_2432 METAL3_471000_613000 METAL3_472000_613000 0.008
R_VDD1_2433 METAL3_472000_613000 METAL3_474000_613000 0.016
R_VDD1_2434 METAL3_474000_613000 METAL3_476000_613000 0.016
R_VDD1_2435 METAL3_476000_613000 METAL3_482000_613000 0.048
R_VDD1_2436 METAL3_482000_613000 METAL3_483000_613000 0.008
R_VDD1_2437 METAL3_483000_613000 METAL3_484000_613000 0.008
R_VDD1_2438 METAL3_484000_613000 METAL3_486000_613000 0.016
R_VDD1_2439 METAL3_486000_613000 METAL3_488000_613000 0.016
R_VDD1_2440 METAL3_488000_613000 METAL3_494000_613000 0.048
R_VDD1_2441 METAL3_494000_613000 METAL3_495000_613000 0.008
R_VDD1_2442 METAL3_495000_613000 METAL3_496000_613000 0.008
R_VDD1_2443 METAL3_496000_613000 METAL3_498000_613000 0.016
R_VDD1_2444 METAL3_498000_613000 METAL4_498000_613000 0.1
R_VDD1_2445 METAL4_498000_613000 METAL5_498000_613000 0.1
R_VDD1_2446 METAL5_498000_613000 METAL5_498000_625000 0.048
R_VDD1_2447 METAL5_498000_625000 METAL5_498000_669000 0.176
R_VDD1_2448 METAL5_498000_669000 METAL5_498000_681000 0.048
R_VDD1_2449 METAL5_498000_681000 METAL5_498000_693000 0.048
R_VDD1_2450 METAL5_498000_693000 METAL5_498000_705000 0.048
R_VDD1_2451 METAL5_498000_705000 METAL5_498000_707000 0.008
R_VDD1_2452 METAL5_498000_707000 METAL5_498000_717000 0.04
R_VDD1_2453 METAL5_498000_717000 METAL5_498000_729000 0.048
R_VDD1_2454 METAL5_498000_729000 METAL5_498000_757000 0.112
R_VDD1_2455 METAL5_498000_757000 METAL5_498000_769000 0.048
R_VDD1_2456 METAL5_498000_769000 METAL5_500000_769000 0.008
R_VDD1_2457 METAL5_500000_769000 METAL5_506000_769000 0.024
R_VDD1_2458 METAL5_506000_769000 METAL5_507000_769000 0.004
R_VDD1_2459 METAL5_507000_769000 METAL4_507000_769000 0.1
R_VDD1_2460 METAL4_507000_769000 METAL3_507000_769000 0.1
R_VDD1_2461 METAL3_507000_769000 METAL3_507000_781000 0.096
R_VDD1_2462 METAL3_507000_781000 METAL3_507000_793000 0.096
R_VDD1_2463 METAL3_507000_793000 METAL3_507000_805000 0.096
R_VDD1_2464 METAL3_507000_805000 METAL3_507000_817000 0.096
R_VDD1_2465 METAL3_507000_817000 METAL3_507000_829000 0.096
R_VDD1_2466 METAL3_507000_829000 METAL3_507000_841000 0.096
R_VDD1_2467 METAL3_507000_841000 METAL3_507000_845000 0.032
R_VDD1_2468 METAL3_507000_845000 METAL3_507000_853000 0.064
R_VDD1_2469 METAL3_507000_853000 METAL3_507000_857000 0.032
R_VDD1_2470 METAL3_507000_857000 METAL3_507000_865000 0.064
R_VDD1_2471 METAL3_507000_865000 METAL3_507000_869000 0.032
R_VDD1_2472 METAL3_507000_869000 METAL3_507000_877000 0.064
R_VDD1_2473 METAL3_507000_877000 METAL3_507000_881000 0.032
R_VDD1_2474 METAL3_507000_881000 METAL3_507000_889000 0.064
R_VDD1_2475 METAL3_507000_889000 METAL3_507000_893000 0.032
R_VDD1_2476 METAL3_507000_893000 METAL3_507000_901000 0.064
R_VDD1_2477 METAL3_507000_901000 METAL3_507000_905000 0.032
R_VDD1_2478 METAL3_507000_905000 METAL3_507000_913000 0.064
R_VDD1_2479 METAL3_507000_913000 METAL3_507000_917000 0.032
R_VDD1_2480 METAL3_507000_917000 METAL3_507000_929000 0.096
R_VDD1_2481 METAL3_507000_929000 METAL3_507000_941000 0.096
R_VDD1_2482 METAL3_507000_941000 METAL3_507000_953000 0.096
R_VDD1_2483 METAL3_507000_953000 METAL3_507000_965000 0.096
R_VDD1_2484 METAL3_507000_965000 METAL3_507000_977000 0.096
R_VDD1_2485 METAL3_507000_977000 METAL3_507000_989000 0.096
R_VDD1_2486 METAL3_507000_989000 METAL3_507000_1001000 0.096
R_VDD1_2487 METAL3_507000_1001000 METAL3_507000_1013000 0.096
R_VDD1_2488 METAL3_507000_1013000 METAL3_507000_1025000 0.096
R_VDD1_2489 METAL3_507000_1025000 METAL3_507000_1041000 0.128
R_VDD1_2490 METAL3_507000_1041000 METAL3_507000_1053000 0.096
R_VDD1_2491 METAL3_507000_1053000 METAL3_507000_1065000 0.096
R_VDD1_2492 METAL3_507000_1065000 METAL3_507000_1077000 0.096
R_VDD1_2493 METAL3_507000_1077000 METAL3_507000_1089000 0.096
R_VDD1_2494 METAL3_507000_1089000 METAL3_507000_1101000 0.096
R_VDD1_2495 METAL3_507000_1101000 METAL3_507000_1113000 0.096
R_VDD1_2496 METAL3_507000_1113000 METAL3_507000_1141000 0.224
R_VDD1_2497 METAL3_507000_1141000 METAL3_507000_1153000 0.096
R_VDD1_2498 METAL3_507000_1153000 METAL3_507000_1165000 0.096
R_VDD1_2499 METAL3_507000_1165000 METAL3_507000_1177000 0.096
R_VDD1_2500 METAL3_507000_1177000 METAL3_507000_1189000 0.096
R_VDD1_2501 METAL3_507000_1189000 METAL3_507000_1201000 0.096
R_VDD1_2502 METAL3_507000_1201000 METAL3_507000_1205000 0.032
R_VDD1_2503 METAL3_507000_1205000 METAL3_507000_1217000 0.096
R_VDD1_2504 METAL3_507000_1217000 METAL3_507000_1229000 0.096
R_VDD1_2505 METAL3_507000_1229000 METAL3_507000_1241000 0.096
R_VDD1_2506 METAL3_507000_1241000 METAL3_507000_1253000 0.096
R_VDD1_2507 METAL3_507000_1253000 METAL3_507000_1265000 0.096
R_VDD1_2508 METAL3_507000_1265000 METAL3_507000_1277000 0.096
R_VDD1_2509 METAL3_507000_1277000 METAL3_507000_1289000 0.096
R_VDD1_2510 METAL3_507000_1289000 METAL3_507000_1301000 0.096
R_VDD1_2511 METAL3_507000_1301000 METAL3_507000_1333000 0.256
R_VDD1_2512 METAL3_507000_1333000 METAL3_507000_1345000 0.096
R_VDD1_2513 METAL3_507000_1345000 METAL3_507000_1357000 0.096
R_VDD1_2514 METAL3_507000_1357000 METAL3_507000_1369000 0.096
R_VDD1_2515 METAL3_507000_1369000 METAL3_507000_1381000 0.096
R_VDD1_2516 METAL3_507000_1381000 METAL3_507000_1393000 0.096
R_VDD1_2517 METAL3_507000_1393000 METAL3_507000_1405000 0.096
R_VDD1_2518 METAL3_507000_1405000 METAL3_507000_1407000 0.016
R_VDD1_2519 METAL3_507000_1407000 METAL3_507000_1417000 0.08
R_VDD1_2520 METAL3_507000_1417000 METAL3_507000_1429000 0.096
R_VDD1_2521 METAL3_507000_1429000 METAL3_507000_1505000 0.608
R_VDD1_2522 METAL3_507000_1505000 METAL3_507000_1517000 0.096
R_VDD1_2523 METAL3_507000_1517000 METAL3_507000_1529000 0.096
R_VDD1_2524 METAL3_507000_1529000 METAL3_507000_1541000 0.096
R_VDD1_2525 METAL3_507000_1541000 METAL3_507000_1553000 0.096
R_VDD1_2526 METAL3_507000_1553000 METAL3_507000_1565000 0.096
R_VDD1_2527 METAL3_507000_1565000 METAL3_507000_1577000 0.096
R_VDD1_2528 METAL3_507000_1577000 METAL3_507000_1589000 0.096
R_VDD1_2529 METAL3_507000_1589000 METAL3_507000_1605000 0.128
R_VDD1_2530 METAL3_507000_1605000 METAL3_507000_1617000 0.096
R_VDD1_2531 METAL3_507000_1617000 METAL3_507000_1629000 0.096
R_VDD1_2532 METAL3_507000_1629000 METAL3_507000_1641000 0.096
R_VDD1_2533 METAL3_507000_1641000 METAL3_507000_1653000 0.096
R_VDD1_2534 METAL3_507000_1653000 METAL3_507000_1665000 0.096
R_VDD1_2535 METAL3_507000_1665000 METAL3_507000_1677000 0.096
R_VDD1_2536 METAL3_507000_1677000 METAL3_507000_1689000 0.096
R_VDD1_2537 METAL3_507000_1689000 METAL3_507000_1701000 0.096
R_VDD1_2538 METAL3_507000_1701000 METAL3_507000_1753000 0.416
R_VDD1_2539 METAL3_507000_1753000 METAL3_507000_1765000 0.096
R_VDD1_2540 METAL3_507000_1765000 METAL3_507000_1777000 0.096
R_VDD1_2541 METAL3_507000_1777000 METAL3_507000_1789000 0.096
R_VDD1_2542 METAL3_507000_1789000 METAL3_507000_1793000 0.032
R_VDD1_2543 METAL3_507000_1793000 METAL3_507000_1801000 0.064
R_VDD1_2544 METAL3_507000_1801000 METAL3_507000_1805000 0.032
R_VDD1_2545 METAL3_507000_1805000 METAL3_507000_1817000 0.096
R_VDD1_2546 METAL3_507000_1817000 METAL3_507000_1829000 0.096
R_VDD1_2547 METAL3_507000_1829000 METAL3_507000_1841000 0.096
R_VDD1_2548 METAL3_507000_1841000 METAL3_507000_1853000 0.096
R_VDD1_2549 METAL3_507000_1853000 METAL3_507000_1865000 0.096
R_VDD1_2550 METAL3_507000_1865000 METAL3_507000_1877000 0.096
R_VDD1_2551 METAL3_507000_1877000 METAL3_507000_1905000 0.224
R_VDD1_2552 METAL3_507000_1905000 METAL3_507000_1917000 0.096
R_VDD1_2553 METAL3_507000_1917000 METAL3_507000_1929000 0.096
R_VDD1_2554 METAL3_507000_1929000 METAL3_507000_1941000 0.096
R_VDD1_2555 METAL3_507000_1941000 METAL3_507000_1953000 0.096
R_VDD1_2556 METAL3_507000_1953000 METAL3_507000_1965000 0.096
R_VDD1_2557 METAL3_507000_1965000 METAL3_507000_1977000 0.096
R_VDD1_2558 METAL3_507000_1977000 METAL3_507000_1989000 0.096
R_VDD1_2559 METAL3_507000_1989000 METAL3_507000_2001000 0.096
R_VDD1_2560 METAL3_507000_2001000 METAL3_507000_2013000 0.096
R_VDD1_2561 METAL3_507000_2013000 METAL3_507000_2025000 0.096
R_VDD1_2562 METAL3_507000_2025000 METAL3_507000_2093000 0.544
R_VDD1_2563 METAL3_507000_2093000 METAL3_507000_2107000 0.112
R_VDD1_2564 METAL3_507000_2107000 METAL3_507000_2217000 0.88
R_VDD1_2565 METAL3_507000_2217000 METAL3_507000_2229000 0.096
R_VDD1_2566 METAL3_507000_2229000 METAL3_507000_2241000 0.096
R_VDD1_2567 METAL3_507000_2241000 METAL3_507000_2253000 0.096
R_VDD1_2568 METAL3_507000_2253000 METAL3_507000_2265000 0.096
R_VDD1_2569 METAL3_507000_2265000 METAL3_508000_2265000 0.008
R_VDD1_2570 METAL3_508000_2265000 METAL3_510000_2265000 0.016
R_VDD1_2571 METAL3_510000_2265000 METAL3_512000_2265000 0.016
R_VDD1_2572 METAL3_512000_2265000 METAL3_519000_2265000 0.056
R_VDD1_2573 METAL3_519000_2265000 METAL3_522000_2265000 0.024
R_VDD1_2574 METAL3_522000_2265000 METAL3_524000_2265000 0.016
R_VDD1_2575 METAL3_524000_2265000 METAL3_531000_2265000 0.056
R_VDD1_2576 METAL3_531000_2265000 METAL3_536000_2265000 0.04
R_VDD1_2577 METAL3_536000_2265000 METAL3_543000_2265000 0.056
R_VDD1_2578 METAL3_543000_2265000 METAL4_543000_2265000 0.1
R_VDD1_2579 METAL4_543000_2265000 METAL5_543000_2265000 0.1
R_VDD1_2580 METAL5_543000_2265000 METAL6_543000_2265000 0.1
R_VDD1_2581 METAL6_245000_2265000 METAL6_257000_2265000 0.024
R_VDD1_2582 METAL3_507000_2025000 METAL4_507000_2025000 0.1
R_VDD1_2583 METAL4_507000_2025000 METAL4_506000_2025000 0.008
R_VDD1_2584 METAL4_506000_2025000 METAL4_500000_2025000 0.048
R_VDD1_2585 METAL4_500000_2025000 METAL4_498000_2025000 0.016
R_VDD1_2586 METAL4_498000_2025000 METAL4_496000_2025000 0.016
R_VDD1_2587 METAL4_496000_2025000 METAL4_495000_2025000 0.008
R_VDD1_2588 METAL4_495000_2025000 METAL4_494000_2025000 0.008
R_VDD1_2589 METAL4_494000_2025000 METAL4_488000_2025000 0.048
R_VDD1_2590 METAL4_488000_2025000 METAL4_486000_2025000 0.016
R_VDD1_2591 METAL4_486000_2025000 METAL4_484000_2025000 0.016
R_VDD1_2592 METAL4_484000_2025000 METAL4_483000_2025000 0.008
R_VDD1_2593 METAL4_483000_2025000 METAL4_482000_2025000 0.008
R_VDD1_2594 METAL4_482000_2025000 METAL4_476000_2025000 0.048
R_VDD1_2595 METAL4_476000_2025000 METAL4_474000_2025000 0.016
R_VDD1_2596 METAL4_474000_2025000 METAL4_472000_2025000 0.016
R_VDD1_2597 METAL4_472000_2025000 METAL4_471000_2025000 0.008
R_VDD1_2598 METAL4_471000_2025000 METAL4_470000_2025000 0.008
R_VDD1_2599 METAL4_470000_2025000 METAL4_464000_2025000 0.048
R_VDD1_2600 METAL4_464000_2025000 METAL4_462000_2025000 0.016
R_VDD1_2601 METAL4_462000_2025000 METAL4_460000_2025000 0.016
R_VDD1_2602 METAL4_460000_2025000 METAL4_458000_2025000 0.016
R_VDD1_2603 METAL4_458000_2025000 METAL4_452000_2025000 0.048
R_VDD1_2604 METAL4_452000_2025000 METAL4_450000_2025000 0.016
R_VDD1_2605 METAL4_450000_2025000 METAL4_448000_2025000 0.016
R_VDD1_2606 METAL4_448000_2025000 METAL4_446000_2025000 0.016
R_VDD1_2607 METAL4_446000_2025000 METAL4_444000_2025000 0.016
R_VDD1_2608 METAL4_444000_2025000 METAL4_440000_2025000 0.032
R_VDD1_2609 METAL4_440000_2025000 METAL4_438000_2025000 0.016
R_VDD1_2610 METAL4_438000_2025000 METAL4_436000_2025000 0.016
R_VDD1_2611 METAL4_436000_2025000 METAL4_434000_2025000 0.016
R_VDD1_2612 METAL4_434000_2025000 METAL4_432000_2025000 0.016
R_VDD1_2613 METAL4_432000_2025000 METAL4_428000_2025000 0.032
R_VDD1_2614 METAL4_428000_2025000 METAL4_426000_2025000 0.016
R_VDD1_2615 METAL4_426000_2025000 METAL4_424000_2025000 0.016
R_VDD1_2616 METAL4_424000_2025000 METAL4_422000_2025000 0.016
R_VDD1_2617 METAL4_422000_2025000 METAL4_420000_2025000 0.016
R_VDD1_2618 METAL4_420000_2025000 METAL4_416000_2025000 0.032
R_VDD1_2619 METAL4_416000_2025000 METAL4_414000_2025000 0.016
R_VDD1_2620 METAL4_414000_2025000 METAL4_412000_2025000 0.016
R_VDD1_2621 METAL4_412000_2025000 METAL4_410000_2025000 0.016
R_VDD1_2622 METAL4_410000_2025000 METAL4_408000_2025000 0.016
R_VDD1_2623 METAL4_408000_2025000 METAL4_404000_2025000 0.032
R_VDD1_2624 METAL4_404000_2025000 METAL4_402000_2025000 0.016
R_VDD1_2625 METAL4_402000_2025000 METAL4_400000_2025000 0.016
R_VDD1_2626 METAL4_400000_2025000 METAL4_398000_2025000 0.016
R_VDD1_2627 METAL4_398000_2025000 METAL4_396000_2025000 0.016
R_VDD1_2628 METAL4_396000_2025000 METAL4_390000_2025000 0.048
R_VDD1_2629 METAL4_390000_2025000 METAL4_388000_2025000 0.016
R_VDD1_2630 METAL4_388000_2025000 METAL4_386000_2025000 0.016
R_VDD1_2631 METAL4_386000_2025000 METAL4_384000_2025000 0.016
R_VDD1_2632 METAL4_384000_2025000 METAL4_378000_2025000 0.048
R_VDD1_2633 METAL4_378000_2025000 METAL4_376000_2025000 0.016
R_VDD1_2634 METAL4_376000_2025000 METAL4_374000_2025000 0.016
R_VDD1_2635 METAL4_374000_2025000 METAL4_372000_2025000 0.016
R_VDD1_2636 METAL4_372000_2025000 METAL4_366000_2025000 0.048
R_VDD1_2637 METAL4_366000_2025000 METAL4_364000_2025000 0.016
R_VDD1_2638 METAL4_364000_2025000 METAL4_362000_2025000 0.016
R_VDD1_2639 METAL4_362000_2025000 METAL4_360000_2025000 0.016
R_VDD1_2640 METAL4_360000_2025000 METAL4_354000_2025000 0.048
R_VDD1_2641 METAL4_354000_2025000 METAL4_352000_2025000 0.016
R_VDD1_2642 METAL4_352000_2025000 METAL4_350000_2025000 0.016
R_VDD1_2643 METAL4_350000_2025000 METAL4_348000_2025000 0.016
R_VDD1_2644 METAL4_348000_2025000 METAL4_342000_2025000 0.048
R_VDD1_2645 METAL4_342000_2025000 METAL4_340000_2025000 0.016
R_VDD1_2646 METAL4_340000_2025000 METAL4_338000_2025000 0.016
R_VDD1_2647 METAL4_338000_2025000 METAL4_336000_2025000 0.016
R_VDD1_2648 METAL4_336000_2025000 METAL4_330000_2025000 0.048
R_VDD1_2649 METAL4_330000_2025000 METAL4_329000_2025000 0.008
R_VDD1_2650 METAL4_329000_2025000 METAL4_328000_2025000 0.008
R_VDD1_2651 METAL4_328000_2025000 METAL4_326000_2025000 0.016
R_VDD1_2652 METAL4_326000_2025000 METAL4_324000_2025000 0.016
R_VDD1_2653 METAL4_324000_2025000 METAL4_318000_2025000 0.048
R_VDD1_2654 METAL4_318000_2025000 METAL4_317000_2025000 0.008
R_VDD1_2655 METAL4_317000_2025000 METAL4_316000_2025000 0.008
R_VDD1_2656 METAL4_316000_2025000 METAL4_314000_2025000 0.016
R_VDD1_2657 METAL4_314000_2025000 METAL4_312000_2025000 0.016
R_VDD1_2658 METAL4_312000_2025000 METAL4_306000_2025000 0.048
R_VDD1_2659 METAL4_306000_2025000 METAL4_305000_2025000 0.008
R_VDD1_2660 METAL4_305000_2025000 METAL4_304000_2025000 0.008
R_VDD1_2661 METAL4_304000_2025000 METAL4_302000_2025000 0.016
R_VDD1_2662 METAL4_302000_2025000 METAL4_300000_2025000 0.016
R_VDD1_2663 METAL4_300000_2025000 METAL4_294000_2025000 0.048
R_VDD1_2664 METAL4_294000_2025000 METAL4_293000_2025000 0.008
R_VDD1_2665 METAL4_293000_2025000 METAL4_292000_2025000 0.008
R_VDD1_2666 METAL4_292000_2025000 METAL4_290000_2025000 0.016
R_VDD1_2667 METAL4_290000_2025000 METAL4_288000_2025000 0.016
R_VDD1_2668 METAL4_288000_2025000 METAL4_282000_2025000 0.048
R_VDD1_2669 METAL4_282000_2025000 METAL4_281000_2025000 0.008
R_VDD1_2670 METAL4_281000_2025000 METAL4_280000_2025000 0.008
R_VDD1_2671 METAL4_280000_2025000 METAL4_278000_2025000 0.016
R_VDD1_2672 METAL4_278000_2025000 METAL4_276000_2025000 0.016
R_VDD1_2673 METAL4_276000_2025000 METAL4_270000_2025000 0.048
R_VDD1_2674 METAL4_270000_2025000 METAL4_269000_2025000 0.008
R_VDD1_2675 METAL4_269000_2025000 METAL4_268000_2025000 0.008
R_VDD1_2676 METAL4_268000_2025000 METAL4_266000_2025000 0.016
R_VDD1_2677 METAL4_266000_2025000 METAL4_264000_2025000 0.016
R_VDD1_2678 METAL4_264000_2025000 METAL5_264000_2025000 0.1
R_VDD1_2679 METAL5_264000_2025000 METAL5_264000_2093000 0.272
R_VDD1_2680 METAL5_264000_2093000 METAL5_264000_2107000 0.056
R_VDD1_2681 METAL5_264000_2107000 METAL5_264000_2217000 0.44
R_VDD1_2682 METAL5_264000_2217000 METAL5_264000_2229000 0.048
R_VDD1_2683 METAL5_264000_2229000 METAL5_258000_2229000 0.024
R_VDD1_2684 METAL5_258000_2229000 METAL5_257000_2229000 0.004
R_VDD1_2685 METAL5_257000_2229000 METAL5_257000_2241000 0.048
R_VDD1_2686 METAL5_257000_2241000 METAL4_257000_2241000 0.1
R_VDD1_2687 METAL4_257000_2241000 METAL4_257000_2253000 0.096
R_VDD1_2688 METAL4_257000_2253000 METAL4_257000_2265000 0.096
R_VDD1_2689 METAL4_257000_2265000 METAL5_257000_2265000 0.1
R_VDD1_2690 METAL5_257000_2265000 METAL6_257000_2265000 0.1
R_VDD1_2691 METAL6_555000_1565000 METAL6_543000_1565000 0.024
R_VDD1_2692 METAL6_300000_8000 METAL6_302000_8000 0.004
R_VDD1_2693 METAL6_302000_8000 METAL6_304000_8000 0.004
R_VDD1_2694 METAL6_304000_8000 METAL6_305000_8000 0.002
R_VDD1_2695 METAL6_305000_8000 METAL6_306000_8000 0.002
R_VDD1_2696 METAL6_306000_8000 METAL6_312000_8000 0.012
R_VDD1_2697 METAL6_312000_8000 METAL6_314000_8000 0.004
R_VDD1_2698 METAL6_314000_8000 METAL5_314000_8000 0.1
R_VDD1_2699 METAL5_314000_8000 METAL4_314000_8000 0.1
R_VDD1_2700 METAL4_314000_8000 METAL3_314000_8000 0.1
R_VDD1_2701 METAL3_314000_8000 METAL3_314000_20000 0.096
R_VDD1_2702 METAL3_314000_20000 METAL3_314000_32000 0.096
R_VDD1_2703 METAL3_314000_32000 METAL3_314000_44000 0.096
R_VDD1_2704 METAL3_314000_44000 METAL3_316000_44000 0.016
R_VDD1_2705 METAL3_316000_44000 METAL3_317000_44000 0.008
R_VDD1_2706 METAL3_317000_44000 METAL3_318000_44000 0.008
R_VDD1_2707 METAL3_318000_44000 METAL3_324000_44000 0.048
R_VDD1_2708 METAL3_324000_44000 METAL3_326000_44000 0.016
R_VDD1_2709 METAL3_326000_44000 METAL3_328000_44000 0.016
R_VDD1_2710 METAL3_328000_44000 METAL3_329000_44000 0.008
R_VDD1_2711 METAL3_329000_44000 METAL3_330000_44000 0.008
R_VDD1_2712 METAL3_330000_44000 METAL3_336000_44000 0.048
R_VDD1_2713 METAL3_336000_44000 METAL3_338000_44000 0.016
R_VDD1_2714 METAL3_338000_44000 METAL3_340000_44000 0.016
R_VDD1_2715 METAL3_340000_44000 METAL3_342000_44000 0.016
R_VDD1_2716 METAL3_342000_44000 METAL3_348000_44000 0.048
R_VDD1_2717 METAL3_348000_44000 METAL3_350000_44000 0.016
R_VDD1_2718 METAL3_350000_44000 METAL3_352000_44000 0.016
R_VDD1_2719 METAL3_352000_44000 METAL3_354000_44000 0.016
R_VDD1_2720 METAL3_354000_44000 METAL3_360000_44000 0.048
R_VDD1_2721 METAL3_360000_44000 METAL3_362000_44000 0.016
R_VDD1_2722 METAL3_362000_44000 METAL3_364000_44000 0.016
R_VDD1_2723 METAL3_364000_44000 METAL3_366000_44000 0.016
R_VDD1_2724 METAL3_366000_44000 METAL3_372000_44000 0.048
R_VDD1_2725 METAL3_372000_44000 METAL3_374000_44000 0.016
R_VDD1_2726 METAL3_374000_44000 METAL3_376000_44000 0.016
R_VDD1_2727 METAL3_376000_44000 METAL3_378000_44000 0.016
R_VDD1_2728 METAL3_378000_44000 METAL3_384000_44000 0.048
R_VDD1_2729 METAL3_384000_44000 METAL3_386000_44000 0.016
R_VDD1_2730 METAL3_386000_44000 METAL3_388000_44000 0.016
R_VDD1_2731 METAL3_388000_44000 METAL3_390000_44000 0.016
R_VDD1_2732 METAL3_390000_44000 METAL3_396000_44000 0.048
R_VDD1_2733 METAL3_396000_44000 METAL3_398000_44000 0.016
R_VDD1_2734 METAL3_398000_44000 METAL3_400000_44000 0.016
R_VDD1_2735 METAL3_400000_44000 METAL3_402000_44000 0.016
R_VDD1_2736 METAL3_402000_44000 METAL3_404000_44000 0.016
R_VDD1_2737 METAL3_404000_44000 METAL3_408000_44000 0.032
R_VDD1_2738 METAL3_408000_44000 METAL3_410000_44000 0.016
R_VDD1_2739 METAL3_410000_44000 METAL3_412000_44000 0.016
R_VDD1_2740 METAL3_412000_44000 METAL3_414000_44000 0.016
R_VDD1_2741 METAL3_414000_44000 METAL3_416000_44000 0.016
R_VDD1_2742 METAL3_416000_44000 METAL3_420000_44000 0.032
R_VDD1_2743 METAL3_420000_44000 METAL3_422000_44000 0.016
R_VDD1_2744 METAL3_422000_44000 METAL3_424000_44000 0.016
R_VDD1_2745 METAL3_424000_44000 METAL4_424000_44000 0.1
R_VDD1_2746 METAL4_424000_44000 METAL4_426000_44000 0.016
R_VDD1_2747 METAL4_426000_44000 METAL4_428000_44000 0.016
R_VDD1_2748 METAL4_428000_44000 METAL4_432000_44000 0.032
R_VDD1_2749 METAL4_432000_44000 METAL4_434000_44000 0.016
R_VDD1_2750 METAL4_434000_44000 METAL4_436000_44000 0.016
R_VDD1_2751 METAL4_436000_44000 METAL4_438000_44000 0.016
R_VDD1_2752 METAL4_438000_44000 METAL4_440000_44000 0.016
R_VDD1_2753 METAL4_440000_44000 METAL4_444000_44000 0.032
R_VDD1_2754 METAL4_444000_44000 METAL4_446000_44000 0.016
R_VDD1_2755 METAL4_446000_44000 METAL4_448000_44000 0.016
R_VDD1_2756 METAL4_448000_44000 METAL4_450000_44000 0.016
R_VDD1_2757 METAL4_450000_44000 METAL4_452000_44000 0.016
R_VDD1_2758 METAL4_452000_44000 METAL4_458000_44000 0.048
R_VDD1_2759 METAL4_458000_44000 METAL4_460000_44000 0.016
R_VDD1_2760 METAL4_460000_44000 METAL4_462000_44000 0.016
R_VDD1_2761 METAL4_462000_44000 METAL4_464000_44000 0.016
R_VDD1_2762 METAL4_464000_44000 METAL4_470000_44000 0.048
R_VDD1_2763 METAL4_470000_44000 METAL4_471000_44000 0.008
R_VDD1_2764 METAL4_471000_44000 METAL4_472000_44000 0.008
R_VDD1_2765 METAL4_472000_44000 METAL4_474000_44000 0.016
R_VDD1_2766 METAL4_474000_44000 METAL4_476000_44000 0.016
R_VDD1_2767 METAL4_476000_44000 METAL4_482000_44000 0.048
R_VDD1_2768 METAL4_482000_44000 METAL4_483000_44000 0.008
R_VDD1_2769 METAL4_483000_44000 METAL4_484000_44000 0.008
R_VDD1_2770 METAL4_484000_44000 METAL4_486000_44000 0.016
R_VDD1_2771 METAL4_486000_44000 METAL4_488000_44000 0.016
R_VDD1_2772 METAL4_488000_44000 METAL4_494000_44000 0.048
R_VDD1_2773 METAL4_494000_44000 METAL4_495000_44000 0.008
R_VDD1_2774 METAL4_495000_44000 METAL4_496000_44000 0.008
R_VDD1_2775 METAL4_496000_44000 METAL4_498000_44000 0.016
R_VDD1_2776 METAL4_498000_44000 METAL4_500000_44000 0.016
R_VDD1_2777 METAL4_500000_44000 METAL4_506000_44000 0.048
R_VDD1_2778 METAL4_506000_44000 METAL4_507000_44000 0.008
R_VDD1_2779 METAL4_507000_44000 METAL4_508000_44000 0.008
R_VDD1_2780 METAL4_508000_44000 METAL4_510000_44000 0.016
R_VDD1_2781 METAL4_510000_44000 METAL4_512000_44000 0.016
R_VDD1_2782 METAL4_512000_44000 METAL5_512000_44000 0.1
R_VDD1_2783 METAL5_512000_44000 METAL5_519000_44000 0.028
R_VDD1_2784 METAL5_519000_44000 METAL5_522000_44000 0.012
R_VDD1_2785 METAL5_522000_44000 METAL5_524000_44000 0.008
R_VDD1_2786 METAL5_524000_44000 METAL5_531000_44000 0.028
R_VDD1_2787 METAL5_531000_44000 METAL5_531000_45000 0.004
R_VDD1_2788 METAL5_531000_45000 METAL5_531000_56000 0.044
R_VDD1_2789 METAL5_531000_56000 METAL5_531000_57000 0.004
R_VDD1_2790 METAL5_531000_57000 METAL5_531000_68000 0.044
R_VDD1_2791 METAL5_531000_68000 METAL5_531000_69000 0.004
R_VDD1_2792 METAL5_531000_69000 METAL5_531000_80000 0.044
R_VDD1_2793 METAL5_531000_80000 METAL5_531000_81000 0.004
R_VDD1_2794 METAL5_531000_81000 METAL5_531000_92000 0.044
R_VDD1_2795 METAL5_531000_92000 METAL5_531000_93000 0.004
R_VDD1_2796 METAL5_531000_93000 METAL5_531000_104000 0.044
R_VDD1_2797 METAL5_531000_104000 METAL5_531000_105000 0.004
R_VDD1_2798 METAL5_531000_105000 METAL5_531000_109000 0.016
R_VDD1_2799 METAL5_531000_109000 METAL5_531000_117000 0.032
R_VDD1_2800 METAL5_531000_117000 METAL5_531000_121000 0.016
R_VDD1_2801 METAL5_531000_121000 METAL5_531000_129000 0.032
R_VDD1_2802 METAL5_531000_129000 METAL5_531000_133000 0.016
R_VDD1_2803 METAL5_531000_133000 METAL5_531000_141000 0.032
R_VDD1_2804 METAL5_531000_141000 METAL5_531000_145000 0.016
R_VDD1_2805 METAL5_531000_145000 METAL5_531000_153000 0.032
R_VDD1_2806 METAL5_531000_153000 METAL5_531000_157000 0.016
R_VDD1_2807 METAL5_531000_157000 METAL5_531000_165000 0.032
R_VDD1_2808 METAL5_531000_165000 METAL5_531000_169000 0.016
R_VDD1_2809 METAL5_531000_169000 METAL5_531000_177000 0.032
R_VDD1_2810 METAL5_531000_177000 METAL5_531000_181000 0.016
R_VDD1_2811 METAL5_531000_181000 METAL5_531000_193000 0.048
R_VDD1_2812 METAL5_531000_193000 METAL5_531000_205000 0.048
R_VDD1_2813 METAL5_531000_205000 METAL4_531000_205000 0.1
R_VDD1_2814 METAL4_531000_205000 METAL3_531000_205000 0.1
R_VDD1_2815 METAL3_531000_205000 METAL3_531000_217000 0.096
R_VDD1_2816 METAL3_531000_217000 METAL3_531000_221000 0.032
R_VDD1_2817 METAL3_531000_221000 METAL3_531000_229000 0.064
R_VDD1_2818 METAL3_531000_229000 METAL3_531000_233000 0.032
R_VDD1_2819 METAL3_531000_233000 METAL3_531000_241000 0.064
R_VDD1_2820 METAL3_531000_241000 METAL3_531000_245000 0.032
R_VDD1_2821 METAL3_531000_245000 METAL3_531000_253000 0.064
R_VDD1_2822 METAL3_531000_253000 METAL3_531000_257000 0.032
R_VDD1_2823 METAL3_531000_257000 METAL3_531000_265000 0.064
R_VDD1_2824 METAL3_531000_265000 METAL3_531000_269000 0.032
R_VDD1_2825 METAL3_531000_269000 METAL3_531000_277000 0.064
R_VDD1_2826 METAL3_531000_277000 METAL3_531000_281000 0.032
R_VDD1_2827 METAL3_531000_281000 METAL3_531000_289000 0.064
R_VDD1_2828 METAL3_531000_289000 METAL3_531000_293000 0.032
R_VDD1_2829 METAL3_531000_293000 METAL3_531000_301000 0.064
R_VDD1_2830 METAL3_531000_301000 METAL3_531000_305000 0.032
R_VDD1_2831 METAL3_531000_305000 METAL3_531000_313000 0.064
R_VDD1_2832 METAL3_531000_313000 METAL3_531000_317000 0.032
R_VDD1_2833 METAL3_531000_317000 METAL3_531000_329000 0.096
R_VDD1_2834 METAL3_531000_329000 METAL3_531000_341000 0.096
R_VDD1_2835 METAL3_531000_341000 METAL3_531000_353000 0.096
R_VDD1_2836 METAL3_531000_353000 METAL3_531000_365000 0.096
R_VDD1_2837 METAL3_531000_365000 METAL3_531000_377000 0.096
R_VDD1_2838 METAL3_531000_377000 METAL3_531000_381000 0.032
R_VDD1_2839 METAL3_531000_381000 METAL3_531000_389000 0.064
R_VDD1_2840 METAL3_531000_389000 METAL3_531000_393000 0.032
R_VDD1_2841 METAL3_531000_393000 METAL3_531000_401000 0.064
R_VDD1_2842 METAL3_531000_401000 METAL3_531000_405000 0.032
R_VDD1_2843 METAL3_531000_405000 METAL3_531000_417000 0.096
R_VDD1_2844 METAL3_531000_417000 METAL3_531000_429000 0.096
R_VDD1_2845 METAL3_531000_429000 METAL3_531000_441000 0.096
R_VDD1_2846 METAL3_531000_441000 METAL3_531000_453000 0.096
R_VDD1_2847 METAL3_531000_453000 METAL3_531000_465000 0.096
R_VDD1_2848 METAL3_531000_465000 METAL3_531000_469000 0.032
R_VDD1_2849 METAL3_531000_469000 METAL3_531000_477000 0.064
R_VDD1_2850 METAL3_531000_477000 METAL3_531000_481000 0.032
R_VDD1_2851 METAL3_531000_481000 METAL3_531000_489000 0.064
R_VDD1_2852 METAL3_531000_489000 METAL3_531000_493000 0.032
R_VDD1_2853 METAL3_531000_493000 METAL3_531000_501000 0.064
R_VDD1_2854 METAL3_531000_501000 METAL3_531000_505000 0.032
R_VDD1_2855 METAL3_531000_505000 METAL3_531000_517000 0.096
R_VDD1_2856 METAL3_531000_517000 METAL3_531000_529000 0.096
R_VDD1_2857 METAL3_531000_529000 METAL3_531000_541000 0.096
R_VDD1_2858 METAL3_531000_541000 METAL3_531000_553000 0.096
R_VDD1_2859 METAL3_531000_553000 METAL3_531000_565000 0.096
R_VDD1_2860 METAL3_531000_565000 METAL3_531000_577000 0.096
R_VDD1_2861 METAL3_531000_577000 METAL3_531000_589000 0.096
R_VDD1_2862 METAL3_531000_589000 METAL3_531000_601000 0.096
R_VDD1_2863 METAL3_531000_601000 METAL3_531000_613000 0.096
R_VDD1_2864 METAL3_531000_613000 METAL3_536000_613000 0.04
R_VDD1_2865 METAL3_536000_613000 METAL4_536000_613000 0.1
R_VDD1_2866 METAL4_536000_613000 METAL5_536000_613000 0.1
R_VDD1_2867 METAL5_536000_613000 METAL5_536000_625000 0.048
R_VDD1_2868 METAL5_536000_625000 METAL5_536000_669000 0.176
R_VDD1_2869 METAL5_536000_669000 METAL5_536000_681000 0.048
R_VDD1_2870 METAL5_536000_681000 METAL5_543000_681000 0.028
R_VDD1_2871 METAL5_543000_681000 METAL5_543000_693000 0.048
R_VDD1_2872 METAL5_543000_693000 METAL5_543000_705000 0.048
R_VDD1_2873 METAL5_543000_705000 METAL5_543000_707000 0.008
R_VDD1_2874 METAL5_543000_707000 METAL5_543000_717000 0.04
R_VDD1_2875 METAL5_543000_717000 METAL5_543000_729000 0.048
R_VDD1_2876 METAL5_543000_729000 METAL5_543000_757000 0.112
R_VDD1_2877 METAL5_543000_757000 METAL5_543000_769000 0.048
R_VDD1_2878 METAL5_543000_769000 METAL5_543000_781000 0.048
R_VDD1_2879 METAL5_543000_781000 METAL5_543000_793000 0.048
R_VDD1_2880 METAL5_543000_793000 METAL5_543000_805000 0.048
R_VDD1_2881 METAL5_543000_805000 METAL5_543000_817000 0.048
R_VDD1_2882 METAL5_543000_817000 METAL5_543000_829000 0.048
R_VDD1_2883 METAL5_543000_829000 METAL5_543000_841000 0.048
R_VDD1_2884 METAL5_543000_841000 METAL4_543000_841000 0.1
R_VDD1_2885 METAL4_543000_841000 METAL3_543000_841000 0.1
R_VDD1_2886 METAL3_543000_841000 METAL2_543000_841000 0.1
R_VDD1_2887 METAL2_543000_841000 METAL2_536000_841000 0.056
R_VDD1_2888 METAL2_536000_841000 METAL2_531000_841000 0.04
R_VDD1_2889 METAL2_531000_841000 METAL2_531000_845000 0.032
R_VDD1_2890 METAL2_531000_845000 METAL2_531000_853000 0.064
R_VDD1_2891 METAL2_531000_853000 METAL2_531000_857000 0.032
R_VDD1_2892 METAL2_531000_857000 METAL2_531000_865000 0.064
R_VDD1_2893 METAL2_531000_865000 METAL2_531000_869000 0.032
R_VDD1_2894 METAL2_531000_869000 METAL2_531000_877000 0.064
R_VDD1_2895 METAL2_531000_877000 METAL2_531000_881000 0.032
R_VDD1_2896 METAL2_531000_881000 METAL2_531000_889000 0.064
R_VDD1_2897 METAL2_531000_889000 METAL2_531000_893000 0.032
R_VDD1_2898 METAL2_531000_893000 METAL2_531000_901000 0.064
R_VDD1_2899 METAL2_531000_901000 METAL2_531000_905000 0.032
R_VDD1_2900 METAL2_531000_905000 METAL2_531000_913000 0.064
R_VDD1_2901 METAL2_531000_913000 METAL2_531000_917000 0.032
R_VDD1_2902 METAL2_531000_917000 METAL2_531000_929000 0.096
R_VDD1_2903 METAL2_531000_929000 METAL2_531000_941000 0.096
R_VDD1_2904 METAL2_531000_941000 METAL2_531000_953000 0.096
R_VDD1_2905 METAL2_531000_953000 METAL2_531000_965000 0.096
R_VDD1_2906 METAL2_531000_965000 METAL2_531000_977000 0.096
R_VDD1_2907 METAL2_531000_977000 METAL2_531000_989000 0.096
R_VDD1_2908 METAL2_531000_989000 METAL2_531000_1001000 0.096
R_VDD1_2909 METAL2_531000_1001000 METAL2_531000_1013000 0.096
R_VDD1_2910 METAL2_531000_1013000 METAL2_531000_1025000 0.096
R_VDD1_2911 METAL2_531000_1025000 METAL2_531000_1041000 0.128
R_VDD1_2912 METAL2_531000_1041000 METAL2_531000_1053000 0.096
R_VDD1_2913 METAL2_531000_1053000 METAL2_531000_1065000 0.096
R_VDD1_2914 METAL2_531000_1065000 METAL2_531000_1077000 0.096
R_VDD1_2915 METAL2_531000_1077000 METAL2_531000_1089000 0.096
R_VDD1_2916 METAL2_531000_1089000 METAL2_531000_1101000 0.096
R_VDD1_2917 METAL2_531000_1101000 METAL2_531000_1113000 0.096
R_VDD1_2918 METAL2_531000_1113000 METAL2_531000_1141000 0.224
R_VDD1_2919 METAL2_531000_1141000 METAL2_531000_1153000 0.096
R_VDD1_2920 METAL2_531000_1153000 METAL2_531000_1165000 0.096
R_VDD1_2921 METAL2_531000_1165000 METAL2_531000_1177000 0.096
R_VDD1_2922 METAL2_531000_1177000 METAL2_531000_1189000 0.096
R_VDD1_2923 METAL2_531000_1189000 METAL2_531000_1201000 0.096
R_VDD1_2924 METAL2_531000_1201000 METAL2_531000_1205000 0.032
R_VDD1_2925 METAL2_531000_1205000 METAL2_531000_1217000 0.096
R_VDD1_2926 METAL2_531000_1217000 METAL2_531000_1229000 0.096
R_VDD1_2927 METAL2_531000_1229000 METAL2_531000_1241000 0.096
R_VDD1_2928 METAL2_531000_1241000 METAL2_531000_1253000 0.096
R_VDD1_2929 METAL2_531000_1253000 METAL2_531000_1265000 0.096
R_VDD1_2930 METAL2_531000_1265000 METAL2_531000_1277000 0.096
R_VDD1_2931 METAL2_531000_1277000 METAL2_531000_1289000 0.096
R_VDD1_2932 METAL2_531000_1289000 METAL2_531000_1301000 0.096
R_VDD1_2933 METAL2_531000_1301000 METAL2_531000_1333000 0.256
R_VDD1_2934 METAL2_531000_1333000 METAL2_531000_1345000 0.096
R_VDD1_2935 METAL2_531000_1345000 METAL2_531000_1357000 0.096
R_VDD1_2936 METAL2_531000_1357000 METAL2_531000_1369000 0.096
R_VDD1_2937 METAL2_531000_1369000 METAL2_531000_1381000 0.096
R_VDD1_2938 METAL2_531000_1381000 METAL2_531000_1393000 0.096
R_VDD1_2939 METAL2_531000_1393000 METAL2_531000_1405000 0.096
R_VDD1_2940 METAL2_531000_1405000 METAL2_536000_1405000 0.04
R_VDD1_2941 METAL2_536000_1405000 METAL2_543000_1405000 0.056
R_VDD1_2942 METAL2_543000_1405000 METAL2_543000_1407000 0.016
R_VDD1_2943 METAL2_543000_1407000 METAL2_543000_1417000 0.08
R_VDD1_2944 METAL2_543000_1417000 METAL2_543000_1429000 0.096
R_VDD1_2945 METAL2_543000_1429000 METAL2_543000_1505000 0.608
R_VDD1_2946 METAL2_543000_1505000 METAL2_543000_1517000 0.096
R_VDD1_2947 METAL2_543000_1517000 METAL2_543000_1529000 0.096
R_VDD1_2948 METAL2_543000_1529000 METAL2_543000_1541000 0.096
R_VDD1_2949 METAL2_543000_1541000 METAL2_543000_1553000 0.096
R_VDD1_2950 METAL2_543000_1553000 METAL2_543000_1565000 0.096
R_VDD1_2951 METAL2_543000_1565000 METAL3_543000_1565000 0.1
R_VDD1_2952 METAL3_543000_1565000 METAL4_543000_1565000 0.1
R_VDD1_2953 METAL4_543000_1565000 METAL5_543000_1565000 0.1
R_VDD1_2954 METAL5_543000_1565000 METAL6_543000_1565000 0.1
R_VDD1_2955 METAL6_245000_1565000 METAL6_257000_1565000 0.024
R_VDD1_2956 METAL5_536000_669000 METAL4_536000_669000 0.1
R_VDD1_2957 METAL4_536000_669000 METAL4_536000_681000 0.096
R_VDD1_2958 METAL4_536000_681000 METAL4_531000_681000 0.04
R_VDD1_2959 METAL4_531000_681000 METAL4_524000_681000 0.056
R_VDD1_2960 METAL4_524000_681000 METAL4_522000_681000 0.016
R_VDD1_2961 METAL4_522000_681000 METAL4_519000_681000 0.024
R_VDD1_2962 METAL4_519000_681000 METAL4_512000_681000 0.056
R_VDD1_2963 METAL4_512000_681000 METAL4_510000_681000 0.016
R_VDD1_2964 METAL4_510000_681000 METAL4_508000_681000 0.016
R_VDD1_2965 METAL4_508000_681000 METAL4_507000_681000 0.008
R_VDD1_2966 METAL4_507000_681000 METAL4_506000_681000 0.008
R_VDD1_2967 METAL4_506000_681000 METAL4_500000_681000 0.048
R_VDD1_2968 METAL4_500000_681000 METAL4_498000_681000 0.016
R_VDD1_2969 METAL4_498000_681000 METAL4_496000_681000 0.016
R_VDD1_2970 METAL4_496000_681000 METAL4_495000_681000 0.008
R_VDD1_2971 METAL4_495000_681000 METAL4_494000_681000 0.008
R_VDD1_2972 METAL4_494000_681000 METAL4_488000_681000 0.048
R_VDD1_2973 METAL4_488000_681000 METAL4_486000_681000 0.016
R_VDD1_2974 METAL4_486000_681000 METAL4_484000_681000 0.016
R_VDD1_2975 METAL4_484000_681000 METAL4_483000_681000 0.008
R_VDD1_2976 METAL4_483000_681000 METAL4_482000_681000 0.008
R_VDD1_2977 METAL4_482000_681000 METAL4_476000_681000 0.048
R_VDD1_2978 METAL4_476000_681000 METAL4_474000_681000 0.016
R_VDD1_2979 METAL4_474000_681000 METAL4_472000_681000 0.016
R_VDD1_2980 METAL4_472000_681000 METAL4_471000_681000 0.008
R_VDD1_2981 METAL4_471000_681000 METAL4_470000_681000 0.008
R_VDD1_2982 METAL4_470000_681000 METAL4_464000_681000 0.048
R_VDD1_2983 METAL4_464000_681000 METAL4_462000_681000 0.016
R_VDD1_2984 METAL4_462000_681000 METAL4_460000_681000 0.016
R_VDD1_2985 METAL4_460000_681000 METAL4_458000_681000 0.016
R_VDD1_2986 METAL4_458000_681000 METAL4_452000_681000 0.048
R_VDD1_2987 METAL4_452000_681000 METAL4_450000_681000 0.016
R_VDD1_2988 METAL4_450000_681000 METAL4_448000_681000 0.016
R_VDD1_2989 METAL4_448000_681000 METAL4_446000_681000 0.016
R_VDD1_2990 METAL4_446000_681000 METAL4_444000_681000 0.016
R_VDD1_2991 METAL4_444000_681000 METAL4_440000_681000 0.032
R_VDD1_2992 METAL4_440000_681000 METAL4_438000_681000 0.016
R_VDD1_2993 METAL4_438000_681000 METAL4_436000_681000 0.016
R_VDD1_2994 METAL4_436000_681000 METAL4_434000_681000 0.016
R_VDD1_2995 METAL4_434000_681000 METAL4_432000_681000 0.016
R_VDD1_2996 METAL4_432000_681000 METAL4_428000_681000 0.032
R_VDD1_2997 METAL4_428000_681000 METAL4_426000_681000 0.016
R_VDD1_2998 METAL4_426000_681000 METAL4_426000_693000 0.096
R_VDD1_2999 METAL4_426000_693000 METAL4_426000_705000 0.096
R_VDD1_3000 METAL4_426000_705000 METAL4_426000_707000 0.016
R_VDD1_3001 METAL4_426000_707000 METAL4_426000_717000 0.08
R_VDD1_3002 METAL4_426000_717000 METAL5_426000_717000 0.1
R_VDD1_3003 METAL5_426000_717000 METAL5_426000_729000 0.048
R_VDD1_3004 METAL5_426000_729000 METAL5_426000_757000 0.112
R_VDD1_3005 METAL5_426000_757000 METAL5_426000_769000 0.048
R_VDD1_3006 METAL5_426000_769000 METAL5_426000_781000 0.048
R_VDD1_3007 METAL5_426000_781000 METAL5_424000_781000 0.008
R_VDD1_3008 METAL5_424000_781000 METAL5_422000_781000 0.008
R_VDD1_3009 METAL5_422000_781000 METAL4_422000_781000 0.1
R_VDD1_3010 METAL4_422000_781000 METAL4_422000_793000 0.096
R_VDD1_3011 METAL4_422000_793000 METAL4_420000_793000 0.016
R_VDD1_3012 METAL4_420000_793000 METAL4_416000_793000 0.032
R_VDD1_3013 METAL4_416000_793000 METAL4_414000_793000 0.016
R_VDD1_3014 METAL4_414000_793000 METAL4_412000_793000 0.016
R_VDD1_3015 METAL4_412000_793000 METAL4_410000_793000 0.016
R_VDD1_3016 METAL4_410000_793000 METAL4_408000_793000 0.016
R_VDD1_3017 METAL4_408000_793000 METAL4_404000_793000 0.032
R_VDD1_3018 METAL4_404000_793000 METAL4_402000_793000 0.016
R_VDD1_3019 METAL4_402000_793000 METAL4_400000_793000 0.016
R_VDD1_3020 METAL4_400000_793000 METAL4_398000_793000 0.016
R_VDD1_3021 METAL4_398000_793000 METAL4_396000_793000 0.016
R_VDD1_3022 METAL4_396000_793000 METAL4_390000_793000 0.048
R_VDD1_3023 METAL4_390000_793000 METAL4_388000_793000 0.016
R_VDD1_3024 METAL4_388000_793000 METAL4_386000_793000 0.016
R_VDD1_3025 METAL4_386000_793000 METAL4_384000_793000 0.016
R_VDD1_3026 METAL4_384000_793000 METAL4_378000_793000 0.048
R_VDD1_3027 METAL4_378000_793000 METAL4_376000_793000 0.016
R_VDD1_3028 METAL4_376000_793000 METAL4_374000_793000 0.016
R_VDD1_3029 METAL4_374000_793000 METAL4_372000_793000 0.016
R_VDD1_3030 METAL4_372000_793000 METAL4_366000_793000 0.048
R_VDD1_3031 METAL4_366000_793000 METAL4_364000_793000 0.016
R_VDD1_3032 METAL4_364000_793000 METAL4_362000_793000 0.016
R_VDD1_3033 METAL4_362000_793000 METAL4_362000_805000 0.096
R_VDD1_3034 METAL4_362000_805000 METAL4_362000_817000 0.096
R_VDD1_3035 METAL4_362000_817000 METAL4_362000_829000 0.096
R_VDD1_3036 METAL4_362000_829000 METAL4_362000_841000 0.096
R_VDD1_3037 METAL4_362000_841000 METAL4_362000_845000 0.032
R_VDD1_3038 METAL4_362000_845000 METAL4_362000_853000 0.064
R_VDD1_3039 METAL4_362000_853000 METAL4_362000_857000 0.032
R_VDD1_3040 METAL4_362000_857000 METAL4_362000_865000 0.064
R_VDD1_3041 METAL4_362000_865000 METAL4_362000_869000 0.032
R_VDD1_3042 METAL4_362000_869000 METAL4_364000_869000 0.016
R_VDD1_3043 METAL4_364000_869000 METAL4_366000_869000 0.016
R_VDD1_3044 METAL4_366000_869000 METAL4_372000_869000 0.048
R_VDD1_3045 METAL4_372000_869000 METAL4_374000_869000 0.016
R_VDD1_3046 METAL4_374000_869000 METAL4_376000_869000 0.016
R_VDD1_3047 METAL4_376000_869000 METAL4_378000_869000 0.016
R_VDD1_3048 METAL4_378000_869000 METAL4_384000_869000 0.048
R_VDD1_3049 METAL4_384000_869000 METAL4_386000_869000 0.016
R_VDD1_3050 METAL4_386000_869000 METAL4_386000_877000 0.064
R_VDD1_3051 METAL4_386000_877000 METAL4_386000_881000 0.032
R_VDD1_3052 METAL4_386000_881000 METAL4_386000_889000 0.064
R_VDD1_3053 METAL4_386000_889000 METAL4_386000_893000 0.032
R_VDD1_3054 METAL4_386000_893000 METAL4_386000_901000 0.064
R_VDD1_3055 METAL4_386000_901000 METAL4_386000_905000 0.032
R_VDD1_3056 METAL4_386000_905000 METAL4_386000_913000 0.064
R_VDD1_3057 METAL4_386000_913000 METAL4_386000_917000 0.032
R_VDD1_3058 METAL4_386000_917000 METAL4_386000_929000 0.096
R_VDD1_3059 METAL4_386000_929000 METAL4_386000_941000 0.096
R_VDD1_3060 METAL4_386000_941000 METAL4_386000_953000 0.096
R_VDD1_3061 METAL4_386000_953000 METAL4_386000_965000 0.096
R_VDD1_3062 METAL4_386000_965000 METAL4_386000_977000 0.096
R_VDD1_3063 METAL4_386000_977000 METAL4_386000_989000 0.096
R_VDD1_3064 METAL4_386000_989000 METAL4_386000_1001000 0.096
R_VDD1_3065 METAL4_386000_1001000 METAL4_386000_1013000 0.096
R_VDD1_3066 METAL4_386000_1013000 METAL4_386000_1025000 0.096
R_VDD1_3067 METAL4_386000_1025000 METAL4_384000_1025000 0.016
R_VDD1_3068 METAL4_384000_1025000 METAL4_378000_1025000 0.048
R_VDD1_3069 METAL4_378000_1025000 METAL4_376000_1025000 0.016
R_VDD1_3070 METAL4_376000_1025000 METAL4_374000_1025000 0.016
R_VDD1_3071 METAL4_374000_1025000 METAL4_372000_1025000 0.016
R_VDD1_3072 METAL4_372000_1025000 METAL4_366000_1025000 0.048
R_VDD1_3073 METAL4_366000_1025000 METAL4_364000_1025000 0.016
R_VDD1_3074 METAL4_364000_1025000 METAL4_362000_1025000 0.016
R_VDD1_3075 METAL4_362000_1025000 METAL4_360000_1025000 0.016
R_VDD1_3076 METAL4_360000_1025000 METAL4_354000_1025000 0.048
R_VDD1_3077 METAL4_354000_1025000 METAL4_352000_1025000 0.016
R_VDD1_3078 METAL4_352000_1025000 METAL4_350000_1025000 0.016
R_VDD1_3079 METAL4_350000_1025000 METAL4_348000_1025000 0.016
R_VDD1_3080 METAL4_348000_1025000 METAL4_342000_1025000 0.048
R_VDD1_3081 METAL4_342000_1025000 METAL4_340000_1025000 0.016
R_VDD1_3082 METAL4_340000_1025000 METAL4_338000_1025000 0.016
R_VDD1_3083 METAL4_338000_1025000 METAL5_338000_1025000 0.1
R_VDD1_3084 METAL5_338000_1025000 METAL5_338000_1041000 0.064
R_VDD1_3085 METAL5_338000_1041000 METAL5_338000_1053000 0.048
R_VDD1_3086 METAL5_338000_1053000 METAL5_338000_1065000 0.048
R_VDD1_3087 METAL5_338000_1065000 METAL4_338000_1065000 0.1
R_VDD1_3088 METAL4_338000_1065000 METAL4_338000_1077000 0.096
R_VDD1_3089 METAL4_338000_1077000 METAL4_338000_1089000 0.096
R_VDD1_3090 METAL4_338000_1089000 METAL5_338000_1089000 0.1
R_VDD1_3091 METAL5_338000_1089000 METAL5_338000_1101000 0.048
R_VDD1_3092 METAL5_338000_1101000 METAL5_338000_1113000 0.048
R_VDD1_3093 METAL5_338000_1113000 METAL5_338000_1141000 0.112
R_VDD1_3094 METAL5_338000_1141000 METAL5_338000_1153000 0.048
R_VDD1_3095 METAL5_338000_1153000 METAL5_338000_1165000 0.048
R_VDD1_3096 METAL5_338000_1165000 METAL5_338000_1177000 0.048
R_VDD1_3097 METAL5_338000_1177000 METAL5_338000_1189000 0.048
R_VDD1_3098 METAL5_338000_1189000 METAL5_338000_1201000 0.048
R_VDD1_3099 METAL5_338000_1201000 METAL5_338000_1205000 0.016
R_VDD1_3100 METAL5_338000_1205000 METAL5_338000_1217000 0.048
R_VDD1_3101 METAL5_338000_1217000 METAL4_338000_1217000 0.1
R_VDD1_3102 METAL4_338000_1217000 METAL4_336000_1217000 0.016
R_VDD1_3103 METAL4_336000_1217000 METAL4_330000_1217000 0.048
R_VDD1_3104 METAL4_330000_1217000 METAL4_329000_1217000 0.008
R_VDD1_3105 METAL4_329000_1217000 METAL4_328000_1217000 0.008
R_VDD1_3106 METAL4_328000_1217000 METAL4_326000_1217000 0.016
R_VDD1_3107 METAL4_326000_1217000 METAL4_324000_1217000 0.016
R_VDD1_3108 METAL4_324000_1217000 METAL4_318000_1217000 0.048
R_VDD1_3109 METAL4_318000_1217000 METAL4_317000_1217000 0.008
R_VDD1_3110 METAL4_317000_1217000 METAL4_316000_1217000 0.008
R_VDD1_3111 METAL4_316000_1217000 METAL4_314000_1217000 0.016
R_VDD1_3112 METAL4_314000_1217000 METAL4_312000_1217000 0.016
R_VDD1_3113 METAL4_312000_1217000 METAL4_306000_1217000 0.048
R_VDD1_3114 METAL4_306000_1217000 METAL4_305000_1217000 0.008
R_VDD1_3115 METAL4_305000_1217000 METAL4_304000_1217000 0.008
R_VDD1_3116 METAL4_304000_1217000 METAL4_302000_1217000 0.016
R_VDD1_3117 METAL4_302000_1217000 METAL4_300000_1217000 0.016
R_VDD1_3118 METAL4_300000_1217000 METAL4_300000_1229000 0.096
R_VDD1_3119 METAL4_300000_1229000 METAL4_300000_1241000 0.096
R_VDD1_3120 METAL4_300000_1241000 METAL4_300000_1253000 0.096
R_VDD1_3121 METAL4_300000_1253000 METAL4_294000_1253000 0.048
R_VDD1_3122 METAL4_294000_1253000 METAL4_293000_1253000 0.008
R_VDD1_3123 METAL4_293000_1253000 METAL4_292000_1253000 0.008
R_VDD1_3124 METAL4_292000_1253000 METAL4_290000_1253000 0.016
R_VDD1_3125 METAL4_290000_1253000 METAL4_288000_1253000 0.016
R_VDD1_3126 METAL4_288000_1253000 METAL4_288000_1265000 0.096
R_VDD1_3127 METAL4_288000_1265000 METAL4_288000_1277000 0.096
R_VDD1_3128 METAL4_288000_1277000 METAL4_288000_1289000 0.096
R_VDD1_3129 METAL4_288000_1289000 METAL5_288000_1289000 0.1
R_VDD1_3130 METAL5_288000_1289000 METAL5_288000_1301000 0.048
R_VDD1_3131 METAL5_288000_1301000 METAL5_288000_1333000 0.128
R_VDD1_3132 METAL5_288000_1333000 METAL5_282000_1333000 0.024
R_VDD1_3133 METAL5_282000_1333000 METAL5_281000_1333000 0.004
R_VDD1_3134 METAL5_281000_1333000 METAL5_280000_1333000 0.004
R_VDD1_3135 METAL5_280000_1333000 METAL5_278000_1333000 0.008
R_VDD1_3136 METAL5_278000_1333000 METAL5_278000_1345000 0.048
R_VDD1_3137 METAL5_278000_1345000 METAL5_278000_1357000 0.048
R_VDD1_3138 METAL5_278000_1357000 METAL4_278000_1357000 0.1
R_VDD1_3139 METAL4_278000_1357000 METAL4_278000_1369000 0.096
R_VDD1_3140 METAL4_278000_1369000 METAL4_278000_1381000 0.096
R_VDD1_3141 METAL4_278000_1381000 METAL4_278000_1393000 0.096
R_VDD1_3142 METAL4_278000_1393000 METAL4_278000_1405000 0.096
R_VDD1_3143 METAL4_278000_1405000 METAL4_278000_1407000 0.016
R_VDD1_3144 METAL4_278000_1407000 METAL4_278000_1417000 0.08
R_VDD1_3145 METAL4_278000_1417000 METAL5_278000_1417000 0.1
R_VDD1_3146 METAL5_278000_1417000 METAL5_278000_1429000 0.048
R_VDD1_3147 METAL5_278000_1429000 METAL5_278000_1505000 0.304
R_VDD1_3148 METAL5_278000_1505000 METAL5_276000_1505000 0.008
R_VDD1_3149 METAL5_276000_1505000 METAL4_276000_1505000 0.1
R_VDD1_3150 METAL4_276000_1505000 METAL4_270000_1505000 0.048
R_VDD1_3151 METAL4_270000_1505000 METAL4_269000_1505000 0.008
R_VDD1_3152 METAL4_269000_1505000 METAL4_268000_1505000 0.008
R_VDD1_3153 METAL4_268000_1505000 METAL4_266000_1505000 0.016
R_VDD1_3154 METAL4_266000_1505000 METAL4_264000_1505000 0.016
R_VDD1_3155 METAL4_264000_1505000 METAL4_264000_1517000 0.096
R_VDD1_3156 METAL4_264000_1517000 METAL4_258000_1517000 0.048
R_VDD1_3157 METAL4_258000_1517000 METAL4_257000_1517000 0.008
R_VDD1_3158 METAL4_257000_1517000 METAL4_257000_1529000 0.096
R_VDD1_3159 METAL4_257000_1529000 METAL4_257000_1541000 0.096
R_VDD1_3160 METAL4_257000_1541000 METAL4_257000_1553000 0.096
R_VDD1_3161 METAL4_257000_1553000 METAL4_257000_1565000 0.096
R_VDD1_3162 METAL4_257000_1565000 METAL5_257000_1565000 0.1
R_VDD1_3163 METAL5_257000_1565000 METAL6_257000_1565000 0.1
R_VDD1_3164 METAL6_555000_865000 METAL6_543000_865000 0.024
R_VDD1_3165 METAL5_300000_8000 METAL4_300000_8000 0.1
R_VDD1_3166 METAL4_300000_8000 METAL3_300000_8000 0.1
R_VDD1_3167 METAL3_300000_8000 METAL3_300000_20000 0.096
R_VDD1_3168 METAL3_300000_20000 METAL3_300000_32000 0.096
R_VDD1_3169 METAL3_300000_32000 METAL3_300000_44000 0.096
R_VDD1_3170 METAL3_300000_44000 METAL3_302000_44000 0.016
R_VDD1_3171 METAL3_302000_44000 METAL3_302000_45000 0.008
R_VDD1_3172 METAL3_302000_45000 METAL3_302000_56000 0.088
R_VDD1_3173 METAL3_302000_56000 METAL3_304000_56000 0.016
R_VDD1_3174 METAL3_304000_56000 METAL3_305000_56000 0.008
R_VDD1_3175 METAL3_305000_56000 METAL3_306000_56000 0.008
R_VDD1_3176 METAL3_306000_56000 METAL3_312000_56000 0.048
R_VDD1_3177 METAL3_312000_56000 METAL3_314000_56000 0.016
R_VDD1_3178 METAL3_314000_56000 METAL3_316000_56000 0.016
R_VDD1_3179 METAL3_316000_56000 METAL3_317000_56000 0.008
R_VDD1_3180 METAL3_317000_56000 METAL3_318000_56000 0.008
R_VDD1_3181 METAL3_318000_56000 METAL3_324000_56000 0.048
R_VDD1_3182 METAL3_324000_56000 METAL3_326000_56000 0.016
R_VDD1_3183 METAL3_326000_56000 METAL3_328000_56000 0.016
R_VDD1_3184 METAL3_328000_56000 METAL3_329000_56000 0.008
R_VDD1_3185 METAL3_329000_56000 METAL3_330000_56000 0.008
R_VDD1_3186 METAL3_330000_56000 METAL3_336000_56000 0.048
R_VDD1_3187 METAL3_336000_56000 METAL3_338000_56000 0.016
R_VDD1_3188 METAL3_338000_56000 METAL3_340000_56000 0.016
R_VDD1_3189 METAL3_340000_56000 METAL3_342000_56000 0.016
R_VDD1_3190 METAL3_342000_56000 METAL3_348000_56000 0.048
R_VDD1_3191 METAL3_348000_56000 METAL3_350000_56000 0.016
R_VDD1_3192 METAL3_350000_56000 METAL3_352000_56000 0.016
R_VDD1_3193 METAL3_352000_56000 METAL3_354000_56000 0.016
R_VDD1_3194 METAL3_354000_56000 METAL3_360000_56000 0.048
R_VDD1_3195 METAL3_360000_56000 METAL3_362000_56000 0.016
R_VDD1_3196 METAL3_362000_56000 METAL3_364000_56000 0.016
R_VDD1_3197 METAL3_364000_56000 METAL3_366000_56000 0.016
R_VDD1_3198 METAL3_366000_56000 METAL3_372000_56000 0.048
R_VDD1_3199 METAL3_372000_56000 METAL3_374000_56000 0.016
R_VDD1_3200 METAL3_374000_56000 METAL3_376000_56000 0.016
R_VDD1_3201 METAL3_376000_56000 METAL3_378000_56000 0.016
R_VDD1_3202 METAL3_378000_56000 METAL4_378000_56000 0.1
R_VDD1_3203 METAL4_378000_56000 METAL4_384000_56000 0.048
R_VDD1_3204 METAL4_384000_56000 METAL4_386000_56000 0.016
R_VDD1_3205 METAL4_386000_56000 METAL4_388000_56000 0.016
R_VDD1_3206 METAL4_388000_56000 METAL4_390000_56000 0.016
R_VDD1_3207 METAL4_390000_56000 METAL4_396000_56000 0.048
R_VDD1_3208 METAL4_396000_56000 METAL4_398000_56000 0.016
R_VDD1_3209 METAL4_398000_56000 METAL4_400000_56000 0.016
R_VDD1_3210 METAL4_400000_56000 METAL4_402000_56000 0.016
R_VDD1_3211 METAL4_402000_56000 METAL4_404000_56000 0.016
R_VDD1_3212 METAL4_404000_56000 METAL4_408000_56000 0.032
R_VDD1_3213 METAL4_408000_56000 METAL4_410000_56000 0.016
R_VDD1_3214 METAL4_410000_56000 METAL4_412000_56000 0.016
R_VDD1_3215 METAL4_412000_56000 METAL5_412000_56000 0.1
R_VDD1_3216 METAL5_412000_56000 METAL5_414000_56000 0.008
R_VDD1_3217 METAL5_414000_56000 METAL5_416000_56000 0.008
R_VDD1_3218 METAL5_416000_56000 METAL5_420000_56000 0.016
R_VDD1_3219 METAL5_420000_56000 METAL5_422000_56000 0.008
R_VDD1_3220 METAL5_422000_56000 METAL5_424000_56000 0.008
R_VDD1_3221 METAL5_424000_56000 METAL5_426000_56000 0.008
R_VDD1_3222 METAL5_426000_56000 METAL5_428000_56000 0.008
R_VDD1_3223 METAL5_428000_56000 METAL5_432000_56000 0.016
R_VDD1_3224 METAL5_432000_56000 METAL5_434000_56000 0.008
R_VDD1_3225 METAL5_434000_56000 METAL5_436000_56000 0.008
R_VDD1_3226 METAL5_436000_56000 METAL5_438000_56000 0.008
R_VDD1_3227 METAL5_438000_56000 METAL5_440000_56000 0.008
R_VDD1_3228 METAL5_440000_56000 METAL5_444000_56000 0.016
R_VDD1_3229 METAL5_444000_56000 METAL5_446000_56000 0.008
R_VDD1_3230 METAL5_446000_56000 METAL5_448000_56000 0.008
R_VDD1_3231 METAL5_448000_56000 METAL5_450000_56000 0.008
R_VDD1_3232 METAL5_450000_56000 METAL5_452000_56000 0.008
R_VDD1_3233 METAL5_452000_56000 METAL5_458000_56000 0.024
R_VDD1_3234 METAL5_458000_56000 METAL5_460000_56000 0.008
R_VDD1_3235 METAL5_460000_56000 METAL5_462000_56000 0.008
R_VDD1_3236 METAL5_462000_56000 METAL5_464000_56000 0.008
R_VDD1_3237 METAL5_464000_56000 METAL5_470000_56000 0.024
R_VDD1_3238 METAL5_470000_56000 METAL5_470000_57000 0.004
R_VDD1_3239 METAL5_470000_57000 METAL5_470000_68000 0.044
R_VDD1_3240 METAL5_470000_68000 METAL5_470000_69000 0.004
R_VDD1_3241 METAL5_470000_69000 METAL5_470000_80000 0.044
R_VDD1_3242 METAL5_470000_80000 METAL5_470000_81000 0.004
R_VDD1_3243 METAL5_470000_81000 METAL5_470000_92000 0.044
R_VDD1_3244 METAL5_470000_92000 METAL5_470000_93000 0.004
R_VDD1_3245 METAL5_470000_93000 METAL5_470000_104000 0.044
R_VDD1_3246 METAL5_470000_104000 METAL5_470000_105000 0.004
R_VDD1_3247 METAL5_470000_105000 METAL5_470000_109000 0.016
R_VDD1_3248 METAL5_470000_109000 METAL5_470000_117000 0.032
R_VDD1_3249 METAL5_470000_117000 METAL4_470000_117000 0.1
R_VDD1_3250 METAL4_470000_117000 METAL4_470000_121000 0.032
R_VDD1_3251 METAL4_470000_121000 METAL4_470000_129000 0.064
R_VDD1_3252 METAL4_470000_129000 METAL4_470000_133000 0.032
R_VDD1_3253 METAL4_470000_133000 METAL4_470000_141000 0.064
R_VDD1_3254 METAL4_470000_141000 METAL4_470000_145000 0.032
R_VDD1_3255 METAL4_470000_145000 METAL4_470000_153000 0.064
R_VDD1_3256 METAL4_470000_153000 METAL4_470000_157000 0.032
R_VDD1_3257 METAL4_470000_157000 METAL4_470000_165000 0.064
R_VDD1_3258 METAL4_470000_165000 METAL4_470000_169000 0.032
R_VDD1_3259 METAL4_470000_169000 METAL4_470000_177000 0.064
R_VDD1_3260 METAL4_470000_177000 METAL4_471000_177000 0.008
R_VDD1_3261 METAL4_471000_177000 METAL4_472000_177000 0.008
R_VDD1_3262 METAL4_472000_177000 METAL5_472000_177000 0.1
R_VDD1_3263 METAL5_472000_177000 METAL5_472000_181000 0.016
R_VDD1_3264 METAL5_472000_181000 METAL5_472000_193000 0.048
R_VDD1_3265 METAL5_472000_193000 METAL5_472000_205000 0.048
R_VDD1_3266 METAL5_472000_205000 METAL5_472000_217000 0.048
R_VDD1_3267 METAL5_472000_217000 METAL5_472000_221000 0.016
R_VDD1_3268 METAL5_472000_221000 METAL5_472000_229000 0.032
R_VDD1_3269 METAL5_472000_229000 METAL5_474000_229000 0.008
R_VDD1_3270 METAL5_474000_229000 METAL5_476000_229000 0.008
R_VDD1_3271 METAL5_476000_229000 METAL5_482000_229000 0.024
R_VDD1_3272 METAL5_482000_229000 METAL5_483000_229000 0.004
R_VDD1_3273 METAL5_483000_229000 METAL5_484000_229000 0.004
R_VDD1_3274 METAL5_484000_229000 METAL5_486000_229000 0.008
R_VDD1_3275 METAL5_486000_229000 METAL4_486000_229000 0.1
R_VDD1_3276 METAL4_486000_229000 METAL4_486000_233000 0.032
R_VDD1_3277 METAL4_486000_233000 METAL4_486000_241000 0.064
R_VDD1_3278 METAL4_486000_241000 METAL4_486000_245000 0.032
R_VDD1_3279 METAL4_486000_245000 METAL4_486000_253000 0.064
R_VDD1_3280 METAL4_486000_253000 METAL4_486000_257000 0.032
R_VDD1_3281 METAL4_486000_257000 METAL4_486000_265000 0.064
R_VDD1_3282 METAL4_486000_265000 METAL4_486000_269000 0.032
R_VDD1_3283 METAL4_486000_269000 METAL4_486000_277000 0.064
R_VDD1_3284 METAL4_486000_277000 METAL4_486000_281000 0.032
R_VDD1_3285 METAL4_486000_281000 METAL4_486000_289000 0.064
R_VDD1_3286 METAL4_486000_289000 METAL4_486000_293000 0.032
R_VDD1_3287 METAL4_486000_293000 METAL4_486000_301000 0.064
R_VDD1_3288 METAL4_486000_301000 METAL4_486000_305000 0.032
R_VDD1_3289 METAL4_486000_305000 METAL4_486000_313000 0.064
R_VDD1_3290 METAL4_486000_313000 METAL4_486000_317000 0.032
R_VDD1_3291 METAL4_486000_317000 METAL4_486000_329000 0.096
R_VDD1_3292 METAL4_486000_329000 METAL4_486000_341000 0.096
R_VDD1_3293 METAL4_486000_341000 METAL5_486000_341000 0.1
R_VDD1_3294 METAL5_486000_341000 METAL5_486000_353000 0.048
R_VDD1_3295 METAL5_486000_353000 METAL5_486000_365000 0.048
R_VDD1_3296 METAL5_486000_365000 METAL5_486000_377000 0.048
R_VDD1_3297 METAL5_486000_377000 METAL5_486000_381000 0.016
R_VDD1_3298 METAL5_486000_381000 METAL5_486000_389000 0.032
R_VDD1_3299 METAL5_486000_389000 METAL5_486000_393000 0.016
R_VDD1_3300 METAL5_486000_393000 METAL5_488000_393000 0.008
R_VDD1_3301 METAL5_488000_393000 METAL5_494000_393000 0.024
R_VDD1_3302 METAL5_494000_393000 METAL5_495000_393000 0.004
R_VDD1_3303 METAL5_495000_393000 METAL4_495000_393000 0.1
R_VDD1_3304 METAL4_495000_393000 METAL3_495000_393000 0.1
R_VDD1_3305 METAL3_495000_393000 METAL3_495000_401000 0.064
R_VDD1_3306 METAL3_495000_401000 METAL3_495000_405000 0.032
R_VDD1_3307 METAL3_495000_405000 METAL3_495000_417000 0.096
R_VDD1_3308 METAL3_495000_417000 METAL3_495000_429000 0.096
R_VDD1_3309 METAL3_495000_429000 METAL3_495000_441000 0.096
R_VDD1_3310 METAL3_495000_441000 METAL3_495000_453000 0.096
R_VDD1_3311 METAL3_495000_453000 METAL3_495000_465000 0.096
R_VDD1_3312 METAL3_495000_465000 METAL3_495000_469000 0.032
R_VDD1_3313 METAL3_495000_469000 METAL3_495000_477000 0.064
R_VDD1_3314 METAL3_495000_477000 METAL3_495000_481000 0.032
R_VDD1_3315 METAL3_495000_481000 METAL3_495000_489000 0.064
R_VDD1_3316 METAL3_495000_489000 METAL3_495000_493000 0.032
R_VDD1_3317 METAL3_495000_493000 METAL3_495000_501000 0.064
R_VDD1_3318 METAL3_495000_501000 METAL3_495000_505000 0.032
R_VDD1_3319 METAL3_495000_505000 METAL3_495000_517000 0.096
R_VDD1_3320 METAL3_495000_517000 METAL3_495000_529000 0.096
R_VDD1_3321 METAL3_495000_529000 METAL3_495000_541000 0.096
R_VDD1_3322 METAL3_495000_541000 METAL3_495000_553000 0.096
R_VDD1_3323 METAL3_495000_553000 METAL3_495000_565000 0.096
R_VDD1_3324 METAL3_495000_565000 METAL3_495000_577000 0.096
R_VDD1_3325 METAL3_495000_577000 METAL3_495000_589000 0.096
R_VDD1_3326 METAL3_495000_589000 METAL3_495000_601000 0.096
R_VDD1_3327 METAL3_495000_601000 METAL3_496000_601000 0.008
R_VDD1_3328 METAL3_496000_601000 METAL3_498000_601000 0.016
R_VDD1_3329 METAL3_498000_601000 METAL3_500000_601000 0.016
R_VDD1_3330 METAL3_500000_601000 METAL3_506000_601000 0.048
R_VDD1_3331 METAL3_506000_601000 METAL3_507000_601000 0.008
R_VDD1_3332 METAL3_507000_601000 METAL3_508000_601000 0.008
R_VDD1_3333 METAL3_508000_601000 METAL3_510000_601000 0.016
R_VDD1_3334 METAL3_510000_601000 METAL3_510000_613000 0.096
R_VDD1_3335 METAL3_510000_613000 METAL3_510000_625000 0.096
R_VDD1_3336 METAL3_510000_625000 METAL3_510000_657000 0.256
R_VDD1_3337 METAL3_510000_657000 METAL3_510000_669000 0.096
R_VDD1_3338 METAL3_510000_669000 METAL3_510000_681000 0.096
R_VDD1_3339 METAL3_510000_681000 METAL3_510000_693000 0.096
R_VDD1_3340 METAL3_510000_693000 METAL3_510000_705000 0.096
R_VDD1_3341 METAL3_510000_705000 METAL3_512000_705000 0.016
R_VDD1_3342 METAL3_512000_705000 METAL3_519000_705000 0.056
R_VDD1_3343 METAL3_519000_705000 METAL3_522000_705000 0.024
R_VDD1_3344 METAL3_522000_705000 METAL3_524000_705000 0.016
R_VDD1_3345 METAL3_524000_705000 METAL3_531000_705000 0.056
R_VDD1_3346 METAL3_531000_705000 METAL3_531000_707000 0.016
R_VDD1_3347 METAL3_531000_707000 METAL3_531000_717000 0.08
R_VDD1_3348 METAL3_531000_717000 METAL3_531000_729000 0.096
R_VDD1_3349 METAL3_531000_729000 METAL3_531000_757000 0.224
R_VDD1_3350 METAL3_531000_757000 METAL3_531000_769000 0.096
R_VDD1_3351 METAL3_531000_769000 METAL3_531000_781000 0.096
R_VDD1_3352 METAL3_531000_781000 METAL3_531000_793000 0.096
R_VDD1_3353 METAL3_531000_793000 METAL3_531000_805000 0.096
R_VDD1_3354 METAL3_531000_805000 METAL3_531000_817000 0.096
R_VDD1_3355 METAL3_531000_817000 METAL3_531000_829000 0.096
R_VDD1_3356 METAL3_531000_829000 METAL3_531000_841000 0.096
R_VDD1_3357 METAL3_531000_841000 METAL3_531000_845000 0.032
R_VDD1_3358 METAL3_531000_845000 METAL3_531000_853000 0.064
R_VDD1_3359 METAL3_531000_853000 METAL3_536000_853000 0.04
R_VDD1_3360 METAL3_536000_853000 METAL3_543000_853000 0.056
R_VDD1_3361 METAL3_543000_853000 METAL4_543000_853000 0.1
R_VDD1_3362 METAL4_543000_853000 METAL4_543000_857000 0.032
R_VDD1_3363 METAL4_543000_857000 METAL4_543000_865000 0.064
R_VDD1_3364 METAL4_543000_865000 METAL5_543000_865000 0.1
R_VDD1_3365 METAL5_543000_865000 METAL6_543000_865000 0.1
R_VDD1_3366 METAL6_245000_865000 METAL6_257000_865000 0.024
R_VDD1_3367 METAL4_300000_8000 METAL4_294000_8000 0.048
R_VDD1_3368 METAL4_294000_8000 METAL4_293000_8000 0.008
R_VDD1_3369 METAL4_293000_8000 METAL4_292000_8000 0.008
R_VDD1_3370 METAL4_292000_8000 METAL4_290000_8000 0.016
R_VDD1_3371 METAL4_290000_8000 METAL4_288000_8000 0.016
R_VDD1_3372 METAL4_288000_8000 METAL4_282000_8000 0.048
R_VDD1_3373 METAL4_282000_8000 METAL4_281000_8000 0.008
R_VDD1_3374 METAL4_281000_8000 METAL4_280000_8000 0.008
R_VDD1_3375 METAL4_280000_8000 METAL4_278000_8000 0.016
R_VDD1_3376 METAL4_278000_8000 METAL4_276000_8000 0.016
R_VDD1_3377 METAL4_276000_8000 METAL4_270000_8000 0.048
R_VDD1_3378 METAL4_270000_8000 METAL4_269000_8000 0.008
R_VDD1_3379 METAL4_269000_8000 METAL4_268000_8000 0.008
R_VDD1_3380 METAL4_268000_8000 METAL4_266000_8000 0.016
R_VDD1_3381 METAL4_266000_8000 METAL4_264000_8000 0.016
R_VDD1_3382 METAL4_264000_8000 METAL4_258000_8000 0.048
R_VDD1_3383 METAL4_258000_8000 METAL5_258000_8000 0.1
R_VDD1_3384 METAL5_258000_8000 METAL5_258000_20000 0.048
R_VDD1_3385 METAL5_258000_20000 METAL5_258000_32000 0.048
R_VDD1_3386 METAL5_258000_32000 METAL5_258000_44000 0.048
R_VDD1_3387 METAL5_258000_44000 METAL5_258000_45000 0.004
R_VDD1_3388 METAL5_258000_45000 METAL5_258000_56000 0.044
R_VDD1_3389 METAL5_258000_56000 METAL5_258000_57000 0.004
R_VDD1_3390 METAL5_258000_57000 METAL5_258000_68000 0.044
R_VDD1_3391 METAL5_258000_68000 METAL5_258000_69000 0.004
R_VDD1_3392 METAL5_258000_69000 METAL5_258000_80000 0.044
R_VDD1_3393 METAL5_258000_80000 METAL5_258000_81000 0.004
R_VDD1_3394 METAL5_258000_81000 METAL5_258000_92000 0.044
R_VDD1_3395 METAL5_258000_92000 METAL5_258000_93000 0.004
R_VDD1_3396 METAL5_258000_93000 METAL5_258000_104000 0.044
R_VDD1_3397 METAL5_258000_104000 METAL5_258000_105000 0.004
R_VDD1_3398 METAL5_258000_105000 METAL5_258000_109000 0.016
R_VDD1_3399 METAL5_258000_109000 METAL5_257000_109000 0.004
R_VDD1_3400 METAL5_257000_109000 METAL5_257000_117000 0.032
R_VDD1_3401 METAL5_257000_117000 METAL5_257000_121000 0.016
R_VDD1_3402 METAL5_257000_121000 METAL5_257000_129000 0.032
R_VDD1_3403 METAL5_257000_129000 METAL5_257000_133000 0.016
R_VDD1_3404 METAL5_257000_133000 METAL5_257000_141000 0.032
R_VDD1_3405 METAL5_257000_141000 METAL4_257000_141000 0.1
R_VDD1_3406 METAL4_257000_141000 METAL3_257000_141000 0.1
R_VDD1_3407 METAL3_257000_141000 METAL2_257000_141000 0.1
R_VDD1_3408 METAL2_257000_141000 METAL2_257000_145000 0.032
R_VDD1_3409 METAL2_257000_145000 METAL2_257000_153000 0.064
R_VDD1_3410 METAL2_257000_153000 METAL2_258000_153000 0.008
R_VDD1_3411 METAL2_258000_153000 METAL2_264000_153000 0.048
R_VDD1_3412 METAL2_264000_153000 METAL2_266000_153000 0.016
R_VDD1_3413 METAL2_266000_153000 METAL2_268000_153000 0.016
R_VDD1_3414 METAL2_268000_153000 METAL2_269000_153000 0.008
R_VDD1_3415 METAL2_269000_153000 METAL2_269000_157000 0.032
R_VDD1_3416 METAL2_269000_157000 METAL2_269000_165000 0.064
R_VDD1_3417 METAL2_269000_165000 METAL2_269000_169000 0.032
R_VDD1_3418 METAL2_269000_169000 METAL2_269000_177000 0.064
R_VDD1_3419 METAL2_269000_177000 METAL2_269000_181000 0.032
R_VDD1_3420 METAL2_269000_181000 METAL2_269000_189000 0.064
R_VDD1_3421 METAL2_269000_189000 METAL2_269000_193000 0.032
R_VDD1_3422 METAL2_269000_193000 METAL2_269000_205000 0.096
R_VDD1_3423 METAL2_269000_205000 METAL2_269000_217000 0.096
R_VDD1_3424 METAL2_269000_217000 METAL2_269000_221000 0.032
R_VDD1_3425 METAL2_269000_221000 METAL2_269000_229000 0.064
R_VDD1_3426 METAL2_269000_229000 METAL2_269000_233000 0.032
R_VDD1_3427 METAL2_269000_233000 METAL2_269000_241000 0.064
R_VDD1_3428 METAL2_269000_241000 METAL2_269000_245000 0.032
R_VDD1_3429 METAL2_269000_245000 METAL2_269000_253000 0.064
R_VDD1_3430 METAL2_269000_253000 METAL2_269000_257000 0.032
R_VDD1_3431 METAL2_269000_257000 METAL2_269000_265000 0.064
R_VDD1_3432 METAL2_269000_265000 METAL2_269000_269000 0.032
R_VDD1_3433 METAL2_269000_269000 METAL2_269000_277000 0.064
R_VDD1_3434 METAL2_269000_277000 METAL2_269000_281000 0.032
R_VDD1_3435 METAL2_269000_281000 METAL2_269000_289000 0.064
R_VDD1_3436 METAL2_269000_289000 METAL2_269000_293000 0.032
R_VDD1_3437 METAL2_269000_293000 METAL2_269000_301000 0.064
R_VDD1_3438 METAL2_269000_301000 METAL2_269000_305000 0.032
R_VDD1_3439 METAL2_269000_305000 METAL2_269000_313000 0.064
R_VDD1_3440 METAL2_269000_313000 METAL2_269000_317000 0.032
R_VDD1_3441 METAL2_269000_317000 METAL2_269000_329000 0.096
R_VDD1_3442 METAL2_269000_329000 METAL2_269000_341000 0.096
R_VDD1_3443 METAL2_269000_341000 METAL2_269000_353000 0.096
R_VDD1_3444 METAL2_269000_353000 METAL2_269000_365000 0.096
R_VDD1_3445 METAL2_269000_365000 METAL2_269000_377000 0.096
R_VDD1_3446 METAL2_269000_377000 METAL2_269000_381000 0.032
R_VDD1_3447 METAL2_269000_381000 METAL2_269000_389000 0.064
R_VDD1_3448 METAL2_269000_389000 METAL2_269000_393000 0.032
R_VDD1_3449 METAL2_269000_393000 METAL2_269000_401000 0.064
R_VDD1_3450 METAL2_269000_401000 METAL2_269000_405000 0.032
R_VDD1_3451 METAL2_269000_405000 METAL2_269000_417000 0.096
R_VDD1_3452 METAL2_269000_417000 METAL2_269000_429000 0.096
R_VDD1_3453 METAL2_269000_429000 METAL2_269000_441000 0.096
R_VDD1_3454 METAL2_269000_441000 METAL2_269000_453000 0.096
R_VDD1_3455 METAL2_269000_453000 METAL2_269000_465000 0.096
R_VDD1_3456 METAL2_269000_465000 METAL2_269000_469000 0.032
R_VDD1_3457 METAL2_269000_469000 METAL2_269000_477000 0.064
R_VDD1_3458 METAL2_269000_477000 METAL2_269000_481000 0.032
R_VDD1_3459 METAL2_269000_481000 METAL2_269000_489000 0.064
R_VDD1_3460 METAL2_269000_489000 METAL2_269000_493000 0.032
R_VDD1_3461 METAL2_269000_493000 METAL2_269000_501000 0.064
R_VDD1_3462 METAL2_269000_501000 METAL2_269000_505000 0.032
R_VDD1_3463 METAL2_269000_505000 METAL2_269000_517000 0.096
R_VDD1_3464 METAL2_269000_517000 METAL2_269000_529000 0.096
R_VDD1_3465 METAL2_269000_529000 METAL2_269000_541000 0.096
R_VDD1_3466 METAL2_269000_541000 METAL2_269000_553000 0.096
R_VDD1_3467 METAL2_269000_553000 METAL2_269000_565000 0.096
R_VDD1_3468 METAL2_269000_565000 METAL2_269000_577000 0.096
R_VDD1_3469 METAL2_269000_577000 METAL2_269000_589000 0.096
R_VDD1_3470 METAL2_269000_589000 METAL2_269000_601000 0.096
R_VDD1_3471 METAL2_269000_601000 METAL2_269000_613000 0.096
R_VDD1_3472 METAL2_269000_613000 METAL2_269000_625000 0.096
R_VDD1_3473 METAL2_269000_625000 METAL2_269000_657000 0.256
R_VDD1_3474 METAL2_269000_657000 METAL2_269000_669000 0.096
R_VDD1_3475 METAL2_269000_669000 METAL2_269000_681000 0.096
R_VDD1_3476 METAL2_269000_681000 METAL2_269000_693000 0.096
R_VDD1_3477 METAL2_269000_693000 METAL2_269000_705000 0.096
R_VDD1_3478 METAL2_269000_705000 METAL2_269000_707000 0.016
R_VDD1_3479 METAL2_269000_707000 METAL2_269000_717000 0.08
R_VDD1_3480 METAL2_269000_717000 METAL2_269000_729000 0.096
R_VDD1_3481 METAL2_269000_729000 METAL2_269000_757000 0.224
R_VDD1_3482 METAL2_269000_757000 METAL2_269000_769000 0.096
R_VDD1_3483 METAL2_269000_769000 METAL2_269000_781000 0.096
R_VDD1_3484 METAL2_269000_781000 METAL2_269000_793000 0.096
R_VDD1_3485 METAL2_269000_793000 METAL2_269000_805000 0.096
R_VDD1_3486 METAL2_269000_805000 METAL2_269000_817000 0.096
R_VDD1_3487 METAL2_269000_817000 METAL2_269000_829000 0.096
R_VDD1_3488 METAL2_269000_829000 METAL2_269000_841000 0.096
R_VDD1_3489 METAL2_269000_841000 METAL2_269000_845000 0.032
R_VDD1_3490 METAL2_269000_845000 METAL2_269000_853000 0.064
R_VDD1_3491 METAL2_269000_853000 METAL2_269000_857000 0.032
R_VDD1_3492 METAL2_269000_857000 METAL2_269000_865000 0.064
R_VDD1_3493 METAL2_269000_865000 METAL2_268000_865000 0.008
R_VDD1_3494 METAL2_268000_865000 METAL2_266000_865000 0.016
R_VDD1_3495 METAL2_266000_865000 METAL2_264000_865000 0.016
R_VDD1_3496 METAL2_264000_865000 METAL2_258000_865000 0.048
R_VDD1_3497 METAL2_258000_865000 METAL2_257000_865000 0.008
R_VDD1_3498 METAL2_257000_865000 METAL3_257000_865000 0.1
R_VDD1_3499 METAL3_257000_865000 METAL4_257000_865000 0.1
R_VDD1_3500 METAL4_257000_865000 METAL5_257000_865000 0.1
R_VDD1_3501 METAL5_257000_865000 METAL6_257000_865000 0.1
R_VDD1_3502 METAL6_555000_165000 METAL6_543000_165000 0.024
R_VDD1_3503 METAL5_531000_45000 METAL5_536000_45000 0.02
R_VDD1_3504 METAL5_536000_45000 METAL5_543000_45000 0.028
R_VDD1_3505 METAL5_543000_45000 METAL6_543000_45000 0.1
R_VDD1_3506 METAL6_543000_45000 METAL6_543000_56000 0.022
R_VDD1_3507 METAL6_543000_56000 METAL6_543000_57000 0.002
R_VDD1_3508 METAL6_543000_57000 METAL6_543000_68000 0.022
R_VDD1_3509 METAL6_543000_68000 METAL6_543000_69000 0.002
R_VDD1_3510 METAL6_543000_69000 METAL6_543000_80000 0.022
R_VDD1_3511 METAL6_543000_80000 METAL6_543000_81000 0.002
R_VDD1_3512 METAL6_543000_81000 METAL6_543000_92000 0.022
R_VDD1_3513 METAL6_543000_92000 METAL6_543000_93000 0.002
R_VDD1_3514 METAL6_543000_93000 METAL6_543000_97000 0.008
R_VDD1_3515 METAL6_543000_97000 METAL6_543000_104000 0.014
R_VDD1_3516 METAL6_543000_104000 METAL6_543000_105000 0.002
R_VDD1_3517 METAL6_543000_105000 METAL6_543000_109000 0.008
R_VDD1_3518 METAL6_543000_109000 METAL6_543000_117000 0.016
R_VDD1_3519 METAL6_543000_117000 METAL6_543000_121000 0.008
R_VDD1_3520 METAL6_543000_121000 METAL6_543000_129000 0.016
R_VDD1_3521 METAL6_543000_129000 METAL6_543000_133000 0.008
R_VDD1_3522 METAL6_543000_133000 METAL6_543000_141000 0.016
R_VDD1_3523 METAL6_543000_141000 METAL6_543000_145000 0.008
R_VDD1_3524 METAL6_543000_145000 METAL6_543000_153000 0.016
R_VDD1_3525 METAL6_543000_153000 METAL6_543000_157000 0.008
R_VDD1_3526 METAL6_543000_157000 METAL6_543000_165000 0.016
R_VDD1_3527 METAL6_245000_165000 METAL6_257000_165000 0.024
R_VDD1_3528 METAL3_306000_56000 METAL4_306000_56000 0.1
R_VDD1_3529 METAL4_306000_56000 METAL4_306000_57000 0.008
R_VDD1_3530 METAL4_306000_57000 METAL4_306000_68000 0.088
R_VDD1_3531 METAL4_306000_68000 METAL4_305000_68000 0.008
R_VDD1_3532 METAL4_305000_68000 METAL4_304000_68000 0.008
R_VDD1_3533 METAL4_304000_68000 METAL4_302000_68000 0.016
R_VDD1_3534 METAL4_302000_68000 METAL4_300000_68000 0.016
R_VDD1_3535 METAL4_300000_68000 METAL4_294000_68000 0.048
R_VDD1_3536 METAL4_294000_68000 METAL4_293000_68000 0.008
R_VDD1_3537 METAL4_293000_68000 METAL4_292000_68000 0.008
R_VDD1_3538 METAL4_292000_68000 METAL4_290000_68000 0.016
R_VDD1_3539 METAL4_290000_68000 METAL4_288000_68000 0.016
R_VDD1_3540 METAL4_288000_68000 METAL4_282000_68000 0.048
R_VDD1_3541 METAL4_282000_68000 METAL4_282000_69000 0.008
R_VDD1_3542 METAL4_282000_69000 METAL4_282000_80000 0.088
R_VDD1_3543 METAL4_282000_80000 METAL4_281000_80000 0.008
R_VDD1_3544 METAL4_281000_80000 METAL4_280000_80000 0.008
R_VDD1_3545 METAL4_280000_80000 METAL4_278000_80000 0.016
R_VDD1_3546 METAL4_278000_80000 METAL4_276000_80000 0.016
R_VDD1_3547 METAL4_276000_80000 METAL4_270000_80000 0.048
R_VDD1_3548 METAL4_270000_80000 METAL4_270000_81000 0.008
R_VDD1_3549 METAL4_270000_81000 METAL4_270000_92000 0.088
R_VDD1_3550 METAL4_270000_92000 METAL4_270000_93000 0.008
R_VDD1_3551 METAL4_270000_93000 METAL4_270000_97000 0.032
R_VDD1_3552 METAL4_270000_97000 METAL4_270000_104000 0.056
R_VDD1_3553 METAL4_270000_104000 METAL4_269000_104000 0.008
R_VDD1_3554 METAL4_269000_104000 METAL4_269000_105000 0.008
R_VDD1_3555 METAL4_269000_105000 METAL4_269000_109000 0.032
R_VDD1_3556 METAL4_269000_109000 METAL4_269000_117000 0.064
R_VDD1_3557 METAL4_269000_117000 METAL4_269000_121000 0.032
R_VDD1_3558 METAL4_269000_121000 METAL4_269000_129000 0.064
R_VDD1_3559 METAL4_269000_129000 METAL4_269000_133000 0.032
R_VDD1_3560 METAL4_269000_133000 METAL4_269000_141000 0.064
R_VDD1_3561 METAL4_269000_141000 METAL4_269000_145000 0.032
R_VDD1_3562 METAL4_269000_145000 METAL4_269000_153000 0.064
R_VDD1_3563 METAL4_269000_153000 METAL4_269000_157000 0.032
R_VDD1_3564 METAL4_269000_157000 METAL4_269000_165000 0.064
R_VDD1_3565 METAL4_269000_165000 METAL4_268000_165000 0.008
R_VDD1_3566 METAL4_268000_165000 METAL4_266000_165000 0.016
R_VDD1_3567 METAL4_266000_165000 METAL4_264000_165000 0.016
R_VDD1_3568 METAL4_264000_165000 METAL4_258000_165000 0.048
R_VDD1_3569 METAL4_258000_165000 METAL4_257000_165000 0.008
R_VDD1_3570 METAL4_257000_165000 METAL5_257000_165000 0.1
R_VDD1_3571 METAL5_257000_165000 METAL6_257000_165000 0.1
R_VDD1_3572 METAL6_543000_165000 METAL5_543000_165000 0.1
R_VDD1_3573 METAL5_543000_165000 METAL5_543000_157000 0.032
R_VDD1_3574 METAL5_543000_157000 METAL5_543000_153000 0.016
R_VDD1_3575 METAL5_543000_153000 METAL5_543000_145000 0.032
R_VDD1_3576 METAL5_543000_145000 METAL5_543000_141000 0.016
R_VDD1_3577 METAL5_543000_141000 METAL5_543000_133000 0.032
R_VDD1_3578 METAL5_543000_133000 METAL5_543000_129000 0.016
R_VDD1_3579 METAL5_543000_129000 METAL5_543000_128000 0.004
R_VDD1_3580 METAL5_543000_128000 METAL5_543000_121000 0.028
R_VDD1_3581 METAL5_543000_121000 METAL5_543000_117000 0.016
R_VDD1_3582 METAL5_543000_117000 METAL5_543000_116000 0.004
R_VDD1_3583 METAL5_543000_116000 METAL5_543000_109000 0.028
R_VDD1_3584 METAL5_543000_109000 METAL5_543000_105000 0.016
R_VDD1_3585 METAL5_543000_105000 METAL5_543000_104000 0.004
R_VDD1_3586 METAL5_543000_104000 METAL5_543000_97000 0.028
R_VDD1_3587 METAL5_543000_97000 METAL5_543000_93000 0.016
R_VDD1_3588 METAL5_543000_93000 METAL5_543000_92000 0.004
R_VDD1_3589 METAL5_543000_92000 METAL5_543000_81000 0.044
R_VDD1_3590 METAL5_543000_81000 METAL5_543000_80000 0.004
R_VDD1_3591 METAL5_543000_80000 METAL4_543000_80000 0.1
R_VDD1_3592 METAL4_543000_80000 METAL4_536000_80000 0.056
R_VDD1_3593 METAL4_536000_80000 METAL4_531000_80000 0.04
R_VDD1_3594 METAL4_531000_80000 METAL4_524000_80000 0.056
R_VDD1_3595 METAL4_524000_80000 METAL4_522000_80000 0.016
R_VDD1_3596 METAL4_522000_80000 METAL4_520000_80000 0.016
R_VDD1_3597 METAL4_520000_80000 METAL4_519000_80000 0.008
R_VDD1_3598 METAL4_519000_80000 METAL4_512000_80000 0.056
R_VDD1_3599 METAL4_512000_80000 METAL4_510000_80000 0.016
R_VDD1_3600 METAL4_510000_80000 METAL4_508000_80000 0.016
R_VDD1_3601 METAL4_508000_80000 METAL4_507000_80000 0.008
R_VDD1_3602 METAL4_507000_80000 METAL4_506000_80000 0.008
R_VDD1_3603 METAL4_506000_80000 METAL4_500000_80000 0.048
R_VDD1_3604 METAL4_500000_80000 METAL4_498000_80000 0.016
R_VDD1_3605 METAL4_498000_80000 METAL4_496000_80000 0.016
R_VDD1_3606 METAL4_496000_80000 METAL4_495000_80000 0.008
R_VDD1_3607 METAL4_495000_80000 METAL4_494000_80000 0.008
R_VDD1_3608 METAL4_494000_80000 METAL4_488000_80000 0.048
R_VDD1_3609 METAL4_488000_80000 METAL4_486000_80000 0.016
R_VDD1_3610 METAL4_486000_80000 METAL4_484000_80000 0.016
R_VDD1_3611 METAL4_484000_80000 METAL4_483000_80000 0.008
R_VDD1_3612 METAL4_483000_80000 METAL4_482000_80000 0.008
R_VDD1_3613 METAL4_482000_80000 METAL4_476000_80000 0.048
R_VDD1_3614 METAL4_476000_80000 METAL4_474000_80000 0.016
R_VDD1_3615 METAL4_474000_80000 METAL4_472000_80000 0.016
R_VDD1_3616 METAL4_472000_80000 METAL4_471000_80000 0.008
R_VDD1_3617 METAL4_471000_80000 METAL4_470000_80000 0.008
R_VDD1_3618 METAL4_470000_80000 METAL4_464000_80000 0.048
R_VDD1_3619 METAL4_464000_80000 METAL4_462000_80000 0.016
R_VDD1_3620 METAL4_462000_80000 METAL4_460000_80000 0.016
R_VDD1_3621 METAL4_460000_80000 METAL4_458000_80000 0.016
R_VDD1_3622 METAL4_458000_80000 METAL4_452000_80000 0.048
R_VDD1_3623 METAL4_452000_80000 METAL4_450000_80000 0.016
R_VDD1_3624 METAL4_450000_80000 METAL4_448000_80000 0.016
R_VDD1_3625 METAL4_448000_80000 METAL4_446000_80000 0.016
R_VDD1_3626 METAL4_446000_80000 METAL4_444000_80000 0.016
R_VDD1_3627 METAL4_444000_80000 METAL4_440000_80000 0.032
R_VDD1_3628 METAL4_440000_80000 METAL4_438000_80000 0.016
R_VDD1_3629 METAL4_438000_80000 METAL4_436000_80000 0.016
R_VDD1_3630 METAL4_436000_80000 METAL4_434000_80000 0.016
R_VDD1_3631 METAL4_434000_80000 METAL4_432000_80000 0.016
R_VDD1_3632 METAL4_432000_80000 METAL4_428000_80000 0.032
R_VDD1_3633 METAL4_428000_80000 METAL4_426000_80000 0.016
R_VDD1_3634 METAL4_426000_80000 METAL4_424000_80000 0.016
R_VDD1_3635 METAL4_424000_80000 METAL4_424000_69000 0.088
R_VDD1_3636 METAL4_424000_69000 METAL3_424000_69000 0.1
R_VDD1_3637 METAL3_424000_69000 METAL3_422000_69000 0.016
R_VDD1_3638 METAL3_422000_69000 METAL3_420000_69000 0.016
R_VDD1_3639 METAL3_420000_69000 METAL3_416000_69000 0.032
R_VDD1_3640 METAL3_416000_69000 METAL3_414000_69000 0.016
R_VDD1_3641 METAL3_414000_69000 METAL3_412000_69000 0.016
R_VDD1_3642 METAL3_412000_69000 METAL3_410000_69000 0.016
R_VDD1_3643 METAL3_410000_69000 METAL3_408000_69000 0.016
R_VDD1_3644 METAL3_408000_69000 METAL3_404000_69000 0.032
R_VDD1_3645 METAL3_404000_69000 METAL3_402000_69000 0.016
R_VDD1_3646 METAL3_402000_69000 METAL3_400000_69000 0.016
R_VDD1_3647 METAL3_400000_69000 METAL3_398000_69000 0.016
R_VDD1_3648 METAL3_398000_69000 METAL3_396000_69000 0.016
R_VDD1_3649 METAL3_396000_69000 METAL3_390000_69000 0.048
R_VDD1_3650 METAL3_390000_69000 METAL3_388000_69000 0.016
R_VDD1_3651 METAL3_388000_69000 METAL3_386000_69000 0.016
R_VDD1_3652 METAL3_386000_69000 METAL3_384000_69000 0.016
R_VDD1_3653 METAL3_384000_69000 METAL3_378000_69000 0.048
R_VDD1_3654 METAL3_378000_69000 METAL3_376000_69000 0.016
R_VDD1_3655 METAL3_376000_69000 METAL3_374000_69000 0.016
R_VDD1_3656 METAL3_374000_69000 METAL3_372000_69000 0.016
R_VDD1_3657 METAL3_372000_69000 METAL3_366000_69000 0.048
R_VDD1_3658 METAL3_366000_69000 METAL3_364000_69000 0.016
R_VDD1_3659 METAL3_364000_69000 METAL3_362000_69000 0.016
R_VDD1_3660 METAL3_362000_69000 METAL3_360000_69000 0.016
R_VDD1_3661 METAL3_360000_69000 METAL3_354000_69000 0.048
R_VDD1_3662 METAL3_354000_69000 METAL3_352000_69000 0.016
R_VDD1_3663 METAL3_352000_69000 METAL3_350000_69000 0.016
R_VDD1_3664 METAL3_350000_69000 METAL3_348000_69000 0.016
R_VDD1_3665 METAL3_348000_69000 METAL3_342000_69000 0.048
R_VDD1_3666 METAL3_342000_69000 METAL3_341000_69000 0.008
R_VDD1_3667 METAL3_341000_69000 METAL3_340000_69000 0.008
R_VDD1_3668 METAL3_340000_69000 METAL3_338000_69000 0.016
R_VDD1_3669 METAL3_338000_69000 METAL3_336000_69000 0.016
R_VDD1_3670 METAL3_336000_69000 METAL3_330000_69000 0.048
R_VDD1_3671 METAL3_330000_69000 METAL3_329000_69000 0.008
R_VDD1_3672 METAL3_329000_69000 METAL3_328000_69000 0.008
R_VDD1_3673 METAL3_328000_69000 METAL3_326000_69000 0.016
R_VDD1_3674 METAL3_326000_69000 METAL3_324000_69000 0.016
R_VDD1_3675 METAL3_324000_69000 METAL3_318000_69000 0.048
R_VDD1_3676 METAL3_318000_69000 METAL3_317000_69000 0.008
R_VDD1_3677 METAL3_317000_69000 METAL3_316000_69000 0.008
R_VDD1_3678 METAL3_316000_69000 METAL3_314000_69000 0.016
R_VDD1_3679 METAL3_314000_69000 METAL3_312000_69000 0.016
R_VDD1_3680 METAL3_312000_69000 METAL3_306000_69000 0.048
R_VDD1_3681 METAL3_306000_69000 METAL3_305000_69000 0.008
R_VDD1_3682 METAL3_305000_69000 METAL3_304000_69000 0.008
R_VDD1_3683 METAL3_304000_69000 METAL3_302000_69000 0.016
R_VDD1_3684 METAL3_302000_69000 METAL3_300000_69000 0.016
R_VDD1_3685 METAL3_300000_69000 METAL3_294000_69000 0.048
R_VDD1_3686 METAL3_294000_69000 METAL3_293000_69000 0.008
R_VDD1_3687 METAL3_293000_69000 METAL3_292000_69000 0.008
R_VDD1_3688 METAL3_292000_69000 METAL3_290000_69000 0.016
R_VDD1_3689 METAL3_290000_69000 METAL3_288000_69000 0.016
R_VDD1_3690 METAL3_288000_69000 METAL3_288000_68000 0.008
R_VDD1_3691 METAL3_288000_68000 METAL3_288000_57000 0.088
R_VDD1_3692 METAL3_288000_57000 METAL3_288000_56000 0.008
R_VDD1_3693 METAL3_288000_56000 METAL3_288000_45000 0.088
R_VDD1_3694 METAL3_288000_45000 METAL3_288000_44000 0.008
R_VDD1_3695 METAL3_288000_44000 METAL3_288000_33000 0.088
R_VDD1_3696 METAL3_288000_33000 METAL3_288000_32000 0.008
R_VDD1_3697 METAL3_288000_32000 METAL3_288000_21000 0.088
R_VDD1_3698 METAL3_288000_21000 METAL3_288000_20000 0.008
R_VDD1_3699 METAL3_288000_20000 METAL3_288000_9000 0.088
R_VDD1_3700 METAL3_288000_9000 METAL3_288000_8000 0.008
R_VDD1_3701 METAL3_288000_8000 METAL3_290000_8000 0.016
R_VDD1_3702 METAL3_290000_8000 METAL3_292000_8000 0.016
R_VDD1_3703 METAL3_292000_8000 METAL3_293000_8000 0.008
R_VDD1_3704 METAL3_293000_8000 METAL3_294000_8000 0.008
R_VDD1_3705 METAL3_294000_8000 METAL3_300000_8000 0.048
R_VDD1_3706 METAL3_300000_8000 METAL4_300000_8000 0.1
R_VDD1_3707 METAL4_300000_8000 METAL5_300000_8000 0.1
R_VDD1_3708 METAL5_300000_8000 METAL6_300000_8000 0.1
R_VDD1_3709 METAL5_543000_165000 METAL4_543000_165000 0.1
R_VDD1_3710 METAL4_543000_165000 METAL4_543000_157000 0.064
R_VDD1_3711 METAL4_543000_157000 METAL4_543000_153000 0.032
R_VDD1_3712 METAL4_543000_153000 METAL4_543000_145000 0.064
R_VDD1_3713 METAL4_543000_145000 METAL4_536000_145000 0.056
R_VDD1_3714 METAL4_536000_145000 METAL4_536000_141000 0.032
R_VDD1_3715 METAL4_536000_141000 METAL4_536000_133000 0.064
R_VDD1_3716 METAL4_536000_133000 METAL4_536000_129000 0.032
R_VDD1_3717 METAL4_536000_129000 METAL4_536000_128000 0.008
R_VDD1_3718 METAL4_536000_128000 METAL4_536000_121000 0.056
R_VDD1_3719 METAL4_536000_121000 METAL4_536000_117000 0.032
R_VDD1_3720 METAL4_536000_117000 METAL4_536000_116000 0.008
R_VDD1_3721 METAL4_536000_116000 METAL4_536000_109000 0.056
R_VDD1_3722 METAL4_536000_109000 METAL4_536000_105000 0.032
R_VDD1_3723 METAL4_536000_105000 METAL4_531000_105000 0.04
R_VDD1_3724 METAL4_531000_105000 METAL4_524000_105000 0.056
R_VDD1_3725 METAL4_524000_105000 METAL4_522000_105000 0.016
R_VDD1_3726 METAL4_522000_105000 METAL4_520000_105000 0.016
R_VDD1_3727 METAL4_520000_105000 METAL4_520000_104000 0.008
R_VDD1_3728 METAL4_520000_104000 METAL4_520000_97000 0.056
R_VDD1_3729 METAL4_520000_97000 METAL4_520000_93000 0.032
R_VDD1_3730 METAL4_520000_93000 METAL4_519000_93000 0.008
R_VDD1_3731 METAL4_519000_93000 METAL4_512000_93000 0.056
R_VDD1_3732 METAL4_512000_93000 METAL4_510000_93000 0.016
R_VDD1_3733 METAL4_510000_93000 METAL4_508000_93000 0.016
R_VDD1_3734 METAL4_508000_93000 METAL4_507000_93000 0.008
R_VDD1_3735 METAL4_507000_93000 METAL4_506000_93000 0.008
R_VDD1_3736 METAL4_506000_93000 METAL4_500000_93000 0.048
R_VDD1_3737 METAL4_500000_93000 METAL4_498000_93000 0.016
R_VDD1_3738 METAL4_498000_93000 METAL4_496000_93000 0.016
R_VDD1_3739 METAL4_496000_93000 METAL4_495000_93000 0.008
R_VDD1_3740 METAL4_495000_93000 METAL3_495000_93000 0.1
R_VDD1_3741 METAL3_495000_93000 METAL3_495000_92000 0.008
R_VDD1_3742 METAL3_495000_92000 METAL3_495000_81000 0.088
R_VDD1_3743 METAL3_495000_81000 METAL3_495000_80000 0.008
R_VDD1_3744 METAL3_495000_80000 METAL3_495000_69000 0.088
R_VDD1_3745 METAL3_495000_69000 METAL3_495000_68000 0.008
R_VDD1_3746 METAL3_495000_68000 METAL3_494000_68000 0.008
R_VDD1_3747 METAL3_494000_68000 METAL3_488000_68000 0.048
R_VDD1_3748 METAL3_488000_68000 METAL3_486000_68000 0.016
R_VDD1_3749 METAL3_486000_68000 METAL3_484000_68000 0.016
R_VDD1_3750 METAL3_484000_68000 METAL3_483000_68000 0.008
R_VDD1_3751 METAL3_483000_68000 METAL3_483000_57000 0.088
R_VDD1_3752 METAL3_483000_57000 METAL3_483000_56000 0.008
R_VDD1_3753 METAL3_483000_56000 METAL2_483000_56000 0.1
R_VDD1_3754 METAL2_483000_56000 METAL2_482000_56000 0.008
R_VDD1_3755 METAL2_482000_56000 METAL2_476000_56000 0.048
R_VDD1_3756 METAL2_476000_56000 METAL2_474000_56000 0.016
R_VDD1_3757 METAL2_474000_56000 METAL2_472000_56000 0.016
R_VDD1_3758 METAL2_472000_56000 METAL2_471000_56000 0.008
R_VDD1_3759 METAL2_471000_56000 METAL2_470000_56000 0.008
R_VDD1_3760 METAL2_470000_56000 METAL2_464000_56000 0.048
R_VDD1_3761 METAL2_464000_56000 METAL2_462000_56000 0.016
R_VDD1_3762 METAL2_462000_56000 METAL2_460000_56000 0.016
R_VDD1_3763 METAL2_460000_56000 METAL2_458000_56000 0.016
R_VDD1_3764 METAL2_458000_56000 METAL2_452000_56000 0.048
R_VDD1_3765 METAL2_452000_56000 METAL2_450000_56000 0.016
R_VDD1_3766 METAL2_450000_56000 METAL2_448000_56000 0.016
R_VDD1_3767 METAL2_448000_56000 METAL2_446000_56000 0.016
R_VDD1_3768 METAL2_446000_56000 METAL2_444000_56000 0.016
R_VDD1_3769 METAL2_444000_56000 METAL2_440000_56000 0.032
R_VDD1_3770 METAL2_440000_56000 METAL2_438000_56000 0.016
R_VDD1_3771 METAL2_438000_56000 METAL2_436000_56000 0.016
R_VDD1_3772 METAL2_436000_56000 METAL2_434000_56000 0.016
R_VDD1_3773 METAL2_434000_56000 METAL2_432000_56000 0.016
R_VDD1_3774 METAL2_432000_56000 METAL2_428000_56000 0.032
R_VDD1_3775 METAL2_428000_56000 METAL2_426000_56000 0.016
R_VDD1_3776 METAL2_426000_56000 METAL2_424000_56000 0.016
R_VDD1_3777 METAL2_424000_56000 METAL2_422000_56000 0.016
R_VDD1_3778 METAL2_422000_56000 METAL2_420000_56000 0.016
R_VDD1_3779 METAL2_420000_56000 METAL2_416000_56000 0.032
R_VDD1_3780 METAL2_416000_56000 METAL2_414000_56000 0.016
R_VDD1_3781 METAL2_414000_56000 METAL2_412000_56000 0.016
R_VDD1_3782 METAL2_412000_56000 METAL2_410000_56000 0.016
R_VDD1_3783 METAL2_410000_56000 METAL2_408000_56000 0.016
R_VDD1_3784 METAL2_408000_56000 METAL2_404000_56000 0.032
R_VDD1_3785 METAL2_404000_56000 METAL2_402000_56000 0.016
R_VDD1_3786 METAL2_402000_56000 METAL2_400000_56000 0.016
R_VDD1_3787 METAL2_400000_56000 METAL2_398000_56000 0.016
R_VDD1_3788 METAL2_398000_56000 METAL2_396000_56000 0.016
R_VDD1_3789 METAL2_396000_56000 METAL2_390000_56000 0.048
R_VDD1_3790 METAL2_390000_56000 METAL2_388000_56000 0.016
R_VDD1_3791 METAL2_388000_56000 METAL2_386000_56000 0.016
R_VDD1_3792 METAL2_386000_56000 METAL2_384000_56000 0.016
R_VDD1_3793 METAL2_384000_56000 METAL2_378000_56000 0.048
R_VDD1_3794 METAL2_378000_56000 METAL2_376000_56000 0.016
R_VDD1_3795 METAL2_376000_56000 METAL2_374000_56000 0.016
R_VDD1_3796 METAL2_374000_56000 METAL2_372000_56000 0.016
R_VDD1_3797 METAL2_372000_56000 METAL2_366000_56000 0.048
R_VDD1_3798 METAL2_366000_56000 METAL2_364000_56000 0.016
R_VDD1_3799 METAL2_364000_56000 METAL2_362000_56000 0.016
R_VDD1_3800 METAL2_362000_56000 METAL2_360000_56000 0.016
R_VDD1_3801 METAL2_360000_56000 METAL2_354000_56000 0.048
R_VDD1_3802 METAL2_354000_56000 METAL2_352000_56000 0.016
R_VDD1_3803 METAL2_352000_56000 METAL2_350000_56000 0.016
R_VDD1_3804 METAL2_350000_56000 METAL2_348000_56000 0.016
R_VDD1_3805 METAL2_348000_56000 METAL2_342000_56000 0.048
R_VDD1_3806 METAL2_342000_56000 METAL2_341000_56000 0.008
R_VDD1_3807 METAL2_341000_56000 METAL2_340000_56000 0.008
R_VDD1_3808 METAL2_340000_56000 METAL2_338000_56000 0.016
R_VDD1_3809 METAL2_338000_56000 METAL1_338000_56000 0.1
R_VDD1_3810 METAL1_338000_56000 METAL1_338000_45000 0.088
R_VDD1_3811 METAL1_338000_45000 METAL1_336000_45000 0.016
R_VDD1_3812 METAL1_336000_45000 METAL1_330000_45000 0.048
R_VDD1_3813 METAL1_330000_45000 METAL1_330000_44000 0.008
R_VDD1_3814 METAL1_330000_44000 METAL1_330000_33000 0.088
R_VDD1_3815 METAL1_330000_33000 METAL1_330000_32000 0.008
R_VDD1_3816 METAL1_330000_32000 METAL1_330000_21000 0.088
R_VDD1_3817 METAL1_330000_21000 METAL1_329000_21000 0.008
R_VDD1_3818 METAL1_329000_21000 METAL1_328000_21000 0.008
R_VDD1_3819 METAL1_328000_21000 METAL1_326000_21000 0.016
R_VDD1_3820 METAL1_326000_21000 METAL1_324000_21000 0.016
R_VDD1_3821 METAL1_324000_21000 METAL1_318000_21000 0.048
R_VDD1_3822 METAL1_318000_21000 METAL1_318000_20000 0.008
R_VDD1_3823 METAL1_318000_20000 METAL1_318000_9000 0.088
R_VDD1_3824 METAL1_318000_9000 METAL1_317000_9000 0.008
R_VDD1_3825 METAL1_317000_9000 METAL1_316000_9000 0.008
R_VDD1_3826 METAL1_316000_9000 METAL1_314000_9000 0.016
R_VDD1_3827 METAL1_314000_9000 METAL1_312000_9000 0.016
R_VDD1_3828 METAL1_312000_9000 METAL1_312000_8000 0.008
R_VDD1_3829 METAL1_312000_8000 METAL2_312000_8000 0.1
R_VDD1_3830 METAL2_312000_8000 METAL2_306000_8000 0.048
R_VDD1_3831 METAL2_306000_8000 METAL2_305000_8000 0.008
R_VDD1_3832 METAL2_305000_8000 METAL2_304000_8000 0.008
R_VDD1_3833 METAL2_304000_8000 METAL2_302000_8000 0.016
R_VDD1_3834 METAL2_302000_8000 METAL2_300000_8000 0.016
R_VDD1_3835 METAL2_300000_8000 METAL3_300000_8000 0.1
R_VDD1_3836 METAL2_257000_145000 METAL1_257000_145000 0.1
R_VDD1_3837 METAL1_257000_145000 METAL1_257000_141000 0.032
R_VDD1_3838 METAL1_257000_141000 METAL1_257000_133000 0.064
R_VDD1_3839 METAL1_257000_133000 METAL1_257000_129000 0.032
R_VDD1_3840 METAL1_257000_129000 METAL2_257000_129000 0.1
R_VDD1_3841 METAL2_257000_129000 METAL2_257000_128000 0.008
R_VDD1_3842 METAL2_257000_128000 METAL2_257000_121000 0.056
R_VDD1_3843 METAL2_257000_121000 METAL2_257000_117000 0.032
R_VDD1_3844 METAL2_257000_117000 METAL2_257000_116000 0.008
R_VDD1_3845 METAL2_257000_116000 METAL2_257000_109000 0.056
R_VDD1_3846 METAL2_257000_109000 METAL2_257000_105000 0.032
R_VDD1_3847 METAL2_257000_105000 METAL2_257000_104000 0.008
R_VDD1_3848 METAL2_257000_104000 METAL2_257000_97000 0.056
R_VDD1_3849 METAL2_257000_97000 METAL2_257000_93000 0.032
R_VDD1_3850 METAL2_257000_93000 METAL2_257000_92000 0.008
R_VDD1_3851 METAL2_257000_92000 METAL2_257000_81000 0.088
R_VDD1_3852 METAL2_257000_81000 METAL2_257000_80000 0.008
R_VDD1_3853 METAL2_257000_80000 METAL2_257000_69000 0.088
R_VDD1_3854 METAL2_257000_69000 METAL2_257000_68000 0.008
R_VDD1_3855 METAL2_257000_68000 METAL2_257000_57000 0.088
R_VDD1_3856 METAL2_257000_57000 METAL2_257000_56000 0.008
R_VDD1_3857 METAL2_257000_56000 METAL2_257000_45000 0.088
R_VDD1_3858 METAL2_257000_45000 METAL2_257000_44000 0.008
R_VDD1_3859 METAL2_257000_44000 METAL2_257000_33000 0.088
R_VDD1_3860 METAL2_257000_33000 METAL2_257000_32000 0.008
R_VDD1_3861 METAL2_257000_32000 METAL2_257000_21000 0.088
R_VDD1_3862 METAL2_257000_21000 METAL2_257000_20000 0.008
R_VDD1_3863 METAL2_257000_20000 METAL2_257000_9000 0.088
R_VDD1_3864 METAL2_257000_9000 METAL2_257000_8000 0.008
R_VDD1_3865 METAL2_257000_8000 METAL2_258000_8000 0.008
R_VDD1_3866 METAL2_258000_8000 METAL2_264000_8000 0.048
R_VDD1_3867 METAL2_264000_8000 METAL2_266000_8000 0.016
R_VDD1_3868 METAL2_266000_8000 METAL2_268000_8000 0.016
R_VDD1_3869 METAL2_268000_8000 METAL2_269000_8000 0.008
R_VDD1_3870 METAL2_269000_8000 METAL2_270000_8000 0.008
R_VDD1_3871 METAL2_270000_8000 METAL2_276000_8000 0.048
R_VDD1_3872 METAL2_276000_8000 METAL2_278000_8000 0.016
R_VDD1_3873 METAL2_278000_8000 METAL2_280000_8000 0.016
R_VDD1_3874 METAL2_280000_8000 METAL2_281000_8000 0.008
R_VDD1_3875 METAL2_281000_8000 METAL2_282000_8000 0.008
R_VDD1_3876 METAL2_282000_8000 METAL2_288000_8000 0.048
R_VDD1_3877 METAL2_288000_8000 METAL2_290000_8000 0.016
R_VDD1_3878 METAL2_290000_8000 METAL2_292000_8000 0.016
R_VDD1_3879 METAL2_292000_8000 METAL2_293000_8000 0.008
R_VDD1_3880 METAL2_293000_8000 METAL2_294000_8000 0.008
R_VDD1_3881 METAL2_294000_8000 METAL2_300000_8000 0.048
R_VDD1_3882 METAL2_269000_601000 METAL2_268000_601000 0.008
R_VDD1_3883 METAL2_268000_601000 METAL2_266000_601000 0.016
R_VDD1_3884 METAL2_266000_601000 METAL2_264000_601000 0.016
R_VDD1_3885 METAL2_264000_601000 METAL2_258000_601000 0.048
R_VDD1_3886 METAL2_258000_601000 METAL2_257000_601000 0.008
R_VDD1_3887 METAL2_257000_601000 METAL2_257000_613000 0.096
R_VDD1_3888 METAL2_257000_613000 METAL2_257000_625000 0.096
R_VDD1_3889 METAL2_257000_625000 METAL2_257000_645000 0.16
R_VDD1_3890 METAL2_257000_645000 METAL2_257000_657000 0.096
R_VDD1_3891 METAL2_257000_657000 METAL2_257000_669000 0.096
R_VDD1_3892 METAL2_257000_669000 METAL2_257000_681000 0.096
R_VDD1_3893 METAL2_257000_681000 METAL2_257000_693000 0.096
R_VDD1_3894 METAL2_257000_693000 METAL2_257000_705000 0.096
R_VDD1_3895 METAL2_257000_705000 METAL2_257000_707000 0.016
R_VDD1_3896 METAL2_257000_707000 METAL2_257000_717000 0.08
R_VDD1_3897 METAL2_257000_717000 METAL2_257000_729000 0.096
R_VDD1_3898 METAL2_257000_729000 METAL2_257000_757000 0.224
R_VDD1_3899 METAL2_257000_757000 METAL2_257000_769000 0.096
R_VDD1_3900 METAL2_257000_769000 METAL2_257000_781000 0.096
R_VDD1_3901 METAL2_257000_781000 METAL2_257000_793000 0.096
R_VDD1_3902 METAL2_257000_793000 METAL2_257000_805000 0.096
R_VDD1_3903 METAL2_257000_805000 METAL2_257000_817000 0.096
R_VDD1_3904 METAL2_257000_817000 METAL2_257000_829000 0.096
R_VDD1_3905 METAL2_257000_829000 METAL2_257000_841000 0.096
R_VDD1_3906 METAL2_257000_841000 METAL2_257000_845000 0.032
R_VDD1_3907 METAL2_257000_845000 METAL2_257000_853000 0.064
R_VDD1_3908 METAL2_257000_853000 METAL2_257000_857000 0.032
R_VDD1_3909 METAL2_257000_857000 METAL2_257000_865000 0.064
R_VDD1_3910 METAL2_269000_601000 METAL3_269000_601000 0.1
R_VDD1_3911 METAL3_269000_601000 METAL3_269000_589000 0.096
R_VDD1_3912 METAL3_269000_589000 METAL3_268000_589000 0.008
R_VDD1_3913 METAL3_268000_589000 METAL3_266000_589000 0.016
R_VDD1_3914 METAL3_266000_589000 METAL3_264000_589000 0.016
R_VDD1_3915 METAL3_264000_589000 METAL3_258000_589000 0.048
R_VDD1_3916 METAL3_258000_589000 METAL3_257000_589000 0.008
R_VDD1_3917 METAL3_257000_589000 METAL2_257000_589000 0.1
R_VDD1_3918 METAL2_257000_589000 METAL1_257000_589000 0.1
R_VDD1_3919 METAL1_257000_589000 METAL1_257000_601000 0.096
R_VDD1_3920 METAL1_257000_601000 METAL1_257000_613000 0.096
R_VDD1_3921 METAL1_257000_613000 METAL1_257000_625000 0.096
R_VDD1_3922 METAL1_257000_625000 METAL1_257000_645000 0.16
R_VDD1_3923 METAL1_257000_645000 METAL1_257000_657000 0.096
R_VDD1_3924 METAL1_257000_657000 METAL1_257000_669000 0.096
R_VDD1_3925 METAL1_257000_669000 METAL1_257000_681000 0.096
R_VDD1_3926 METAL1_257000_681000 METAL1_257000_693000 0.096
R_VDD1_3927 METAL1_257000_693000 METAL1_257000_705000 0.096
R_VDD1_3928 METAL1_257000_705000 METAL1_257000_707000 0.016
R_VDD1_3929 METAL1_257000_707000 METAL1_257000_717000 0.08
R_VDD1_3930 METAL1_257000_717000 METAL1_257000_729000 0.096
R_VDD1_3931 METAL1_257000_729000 METAL1_257000_757000 0.224
R_VDD1_3932 METAL1_257000_757000 METAL1_257000_769000 0.096
R_VDD1_3933 METAL1_257000_769000 METAL1_257000_781000 0.096
R_VDD1_3934 METAL1_257000_781000 METAL1_257000_793000 0.096
R_VDD1_3935 METAL1_257000_793000 METAL1_257000_805000 0.096
R_VDD1_3936 METAL1_257000_805000 METAL1_257000_817000 0.096
R_VDD1_3937 METAL1_257000_817000 METAL1_257000_829000 0.096
R_VDD1_3938 METAL1_257000_829000 METAL1_257000_841000 0.096
R_VDD1_3939 METAL1_257000_841000 METAL1_257000_845000 0.032
R_VDD1_3940 METAL1_257000_845000 METAL1_257000_853000 0.064
R_VDD1_3941 METAL1_257000_853000 METAL1_257000_857000 0.032
R_VDD1_3942 METAL1_257000_857000 METAL1_257000_865000 0.064
R_VDD1_3943 METAL1_257000_865000 METAL2_257000_865000 0.1
R_VDD1_3944 METAL3_510000_681000 METAL3_512000_681000 0.016
R_VDD1_3945 METAL3_512000_681000 METAL3_519000_681000 0.056
R_VDD1_3946 METAL3_519000_681000 METAL3_520000_681000 0.008
R_VDD1_3947 METAL3_520000_681000 METAL3_522000_681000 0.016
R_VDD1_3948 METAL3_522000_681000 METAL3_522000_669000 0.096
R_VDD1_3949 METAL3_522000_669000 METAL4_522000_669000 0.1
R_VDD1_3950 METAL4_522000_669000 METAL4_522000_657000 0.096
R_VDD1_3951 METAL4_522000_657000 METAL4_522000_645000 0.096
R_VDD1_3952 METAL4_522000_645000 METAL4_522000_633000 0.096
R_VDD1_3953 METAL4_522000_633000 METAL4_522000_625000 0.064
R_VDD1_3954 METAL4_522000_625000 METAL4_520000_625000 0.016
R_VDD1_3955 METAL4_520000_625000 METAL4_519000_625000 0.008
R_VDD1_3956 METAL4_519000_625000 METAL4_512000_625000 0.056
R_VDD1_3957 METAL4_512000_625000 METAL4_510000_625000 0.016
R_VDD1_3958 METAL4_510000_625000 METAL4_508000_625000 0.016
R_VDD1_3959 METAL4_508000_625000 METAL4_507000_625000 0.008
R_VDD1_3960 METAL4_507000_625000 METAL4_506000_625000 0.008
R_VDD1_3961 METAL4_506000_625000 METAL4_500000_625000 0.048
R_VDD1_3962 METAL4_500000_625000 METAL4_498000_625000 0.016
R_VDD1_3963 METAL4_498000_625000 METAL3_498000_625000 0.1
R_VDD1_3964 METAL3_498000_625000 METAL3_496000_625000 0.016
R_VDD1_3965 METAL3_496000_625000 METAL3_495000_625000 0.008
R_VDD1_3966 METAL3_495000_625000 METAL3_494000_625000 0.008
R_VDD1_3967 METAL3_494000_625000 METAL3_488000_625000 0.048
R_VDD1_3968 METAL3_488000_625000 METAL3_486000_625000 0.016
R_VDD1_3969 METAL3_486000_625000 METAL3_484000_625000 0.016
R_VDD1_3970 METAL3_484000_625000 METAL3_483000_625000 0.008
R_VDD1_3971 METAL3_483000_625000 METAL3_482000_625000 0.008
R_VDD1_3972 METAL3_482000_625000 METAL3_476000_625000 0.048
R_VDD1_3973 METAL3_476000_625000 METAL3_474000_625000 0.016
R_VDD1_3974 METAL3_474000_625000 METAL3_472000_625000 0.016
R_VDD1_3975 METAL3_472000_625000 METAL3_471000_625000 0.008
R_VDD1_3976 METAL3_471000_625000 METAL3_470000_625000 0.008
R_VDD1_3977 METAL3_470000_625000 METAL3_464000_625000 0.048
R_VDD1_3978 METAL3_464000_625000 METAL3_462000_625000 0.016
R_VDD1_3979 METAL3_462000_625000 METAL3_460000_625000 0.016
R_VDD1_3980 METAL3_460000_625000 METAL3_459000_625000 0.008
R_VDD1_3981 METAL3_459000_625000 METAL2_459000_625000 0.1
R_VDD1_3982 METAL2_459000_625000 METAL2_459000_613000 0.096
R_VDD1_3983 METAL2_459000_613000 METAL2_459000_601000 0.096
R_VDD1_3984 METAL2_459000_601000 METAL3_459000_601000 0.1
R_VDD1_3985 METAL3_459000_601000 METAL3_459000_589000 0.096
R_VDD1_3986 METAL3_459000_589000 METAL3_459000_577000 0.096
R_VDD1_3987 METAL3_459000_577000 METAL3_459000_565000 0.096
R_VDD1_3988 METAL3_459000_565000 METAL3_459000_553000 0.096
R_VDD1_3989 METAL3_459000_553000 METAL3_459000_541000 0.096
R_VDD1_3990 METAL3_459000_541000 METAL3_459000_529000 0.096
R_VDD1_3991 METAL3_459000_529000 METAL3_459000_517000 0.096
R_VDD1_3992 METAL3_459000_517000 METAL3_459000_513000 0.032
R_VDD1_3993 METAL3_459000_513000 METAL3_459000_505000 0.064
R_VDD1_3994 METAL3_459000_505000 METAL3_459000_501000 0.032
R_VDD1_3995 METAL3_459000_501000 METAL3_459000_493000 0.064
R_VDD1_3996 METAL3_459000_493000 METAL3_459000_489000 0.032
R_VDD1_3997 METAL3_459000_489000 METAL3_459000_481000 0.064
R_VDD1_3998 METAL3_459000_481000 METAL3_459000_477000 0.032
R_VDD1_3999 METAL3_459000_477000 METAL3_459000_469000 0.064
R_VDD1_4000 METAL3_459000_469000 METAL3_459000_465000 0.032
R_VDD1_4001 METAL3_459000_465000 METAL3_459000_453000 0.096
R_VDD1_4002 METAL3_459000_453000 METAL3_459000_441000 0.096
R_VDD1_4003 METAL3_459000_441000 METAL3_459000_429000 0.096
R_VDD1_4004 METAL3_459000_429000 METAL3_459000_417000 0.096
R_VDD1_4005 METAL3_459000_417000 METAL3_459000_405000 0.096
R_VDD1_4006 METAL3_459000_405000 METAL3_459000_401000 0.032
R_VDD1_4007 METAL3_459000_401000 METAL3_459000_393000 0.064
R_VDD1_4008 METAL3_459000_393000 METAL3_459000_389000 0.032
R_VDD1_4009 METAL3_459000_389000 METAL3_458000_389000 0.008
R_VDD1_4010 METAL3_458000_389000 METAL3_452000_389000 0.048
R_VDD1_4011 METAL3_452000_389000 METAL3_450000_389000 0.016
R_VDD1_4012 METAL3_450000_389000 METAL3_448000_389000 0.016
R_VDD1_4013 METAL3_448000_389000 METAL3_446000_389000 0.016
R_VDD1_4014 METAL3_446000_389000 METAL3_444000_389000 0.016
R_VDD1_4015 METAL3_444000_389000 METAL3_440000_389000 0.032
R_VDD1_4016 METAL3_440000_389000 METAL3_438000_389000 0.016
R_VDD1_4017 METAL3_438000_389000 METAL3_436000_389000 0.016
R_VDD1_4018 METAL3_436000_389000 METAL3_434000_389000 0.016
R_VDD1_4019 METAL3_434000_389000 METAL3_432000_389000 0.016
R_VDD1_4020 METAL3_432000_389000 METAL3_428000_389000 0.032
R_VDD1_4021 METAL3_428000_389000 METAL3_426000_389000 0.016
R_VDD1_4022 METAL3_426000_389000 METAL3_426000_381000 0.064
R_VDD1_4023 METAL3_426000_381000 METAL3_426000_377000 0.032
R_VDD1_4024 METAL3_426000_377000 METAL3_426000_369000 0.064
R_VDD1_4025 METAL3_426000_369000 METAL3_426000_365000 0.032
R_VDD1_4026 METAL3_426000_365000 METAL3_426000_353000 0.096
R_VDD1_4027 METAL3_426000_353000 METAL3_426000_341000 0.096
R_VDD1_4028 METAL3_426000_341000 METAL3_426000_329000 0.096
R_VDD1_4029 METAL3_426000_329000 METAL3_426000_317000 0.096
R_VDD1_4030 METAL3_426000_317000 METAL3_426000_313000 0.032
R_VDD1_4031 METAL3_426000_313000 METAL3_426000_305000 0.064
R_VDD1_4032 METAL3_426000_305000 METAL3_426000_301000 0.032
R_VDD1_4033 METAL3_426000_301000 METAL3_426000_293000 0.064
R_VDD1_4034 METAL3_426000_293000 METAL3_426000_289000 0.032
R_VDD1_4035 METAL3_426000_289000 METAL3_426000_281000 0.064
R_VDD1_4036 METAL3_426000_281000 METAL3_426000_277000 0.032
R_VDD1_4037 METAL3_426000_277000 METAL3_426000_269000 0.064
R_VDD1_4038 METAL3_426000_269000 METAL3_426000_265000 0.032
R_VDD1_4039 METAL3_426000_265000 METAL3_426000_257000 0.064
R_VDD1_4040 METAL3_426000_257000 METAL3_426000_253000 0.032
R_VDD1_4041 METAL3_426000_253000 METAL3_426000_245000 0.064
R_VDD1_4042 METAL3_426000_245000 METAL3_426000_241000 0.032
R_VDD1_4043 METAL3_426000_241000 METAL3_426000_233000 0.064
R_VDD1_4044 METAL3_426000_233000 METAL3_426000_229000 0.032
R_VDD1_4045 METAL3_426000_229000 METAL3_426000_225000 0.032
R_VDD1_4046 METAL3_426000_225000 METAL3_426000_221000 0.032
R_VDD1_4047 METAL3_426000_221000 METAL3_426000_217000 0.032
R_VDD1_4048 METAL3_426000_217000 METAL3_426000_213000 0.032
R_VDD1_4049 METAL3_426000_213000 METAL3_426000_205000 0.064
R_VDD1_4050 METAL3_426000_205000 METAL3_426000_201000 0.032
R_VDD1_4051 METAL3_426000_201000 METAL3_426000_193000 0.064
R_VDD1_4052 METAL3_426000_193000 METAL3_426000_189000 0.032
R_VDD1_4053 METAL3_426000_189000 METAL3_426000_181000 0.064
R_VDD1_4054 METAL3_426000_181000 METAL3_426000_177000 0.032
R_VDD1_4055 METAL3_426000_177000 METAL3_426000_169000 0.064
R_VDD1_4056 METAL3_426000_169000 METAL3_426000_165000 0.032
R_VDD1_4057 METAL3_426000_165000 METAL3_426000_157000 0.064
R_VDD1_4058 METAL3_426000_157000 METAL3_426000_153000 0.032
R_VDD1_4059 METAL3_426000_153000 METAL3_424000_153000 0.016
R_VDD1_4060 METAL3_424000_153000 METAL3_422000_153000 0.016
R_VDD1_4061 METAL3_422000_153000 METAL3_420000_153000 0.016
R_VDD1_4062 METAL3_420000_153000 METAL3_416000_153000 0.032
R_VDD1_4063 METAL3_416000_153000 METAL3_414000_153000 0.016
R_VDD1_4064 METAL3_414000_153000 METAL3_412000_153000 0.016
R_VDD1_4065 METAL3_412000_153000 METAL3_410000_153000 0.016
R_VDD1_4066 METAL3_410000_153000 METAL3_408000_153000 0.016
R_VDD1_4067 METAL3_408000_153000 METAL3_404000_153000 0.032
R_VDD1_4068 METAL3_404000_153000 METAL3_402000_153000 0.016
R_VDD1_4069 METAL3_402000_153000 METAL3_400000_153000 0.016
R_VDD1_4070 METAL3_400000_153000 METAL3_398000_153000 0.016
R_VDD1_4071 METAL3_398000_153000 METAL3_396000_153000 0.016
R_VDD1_4072 METAL3_396000_153000 METAL3_390000_153000 0.048
R_VDD1_4073 METAL3_390000_153000 METAL3_388000_153000 0.016
R_VDD1_4074 METAL3_388000_153000 METAL3_386000_153000 0.016
R_VDD1_4075 METAL3_386000_153000 METAL3_384000_153000 0.016
R_VDD1_4076 METAL3_384000_153000 METAL3_378000_153000 0.048
R_VDD1_4077 METAL3_378000_153000 METAL3_376000_153000 0.016
R_VDD1_4078 METAL3_376000_153000 METAL3_374000_153000 0.016
R_VDD1_4079 METAL3_374000_153000 METAL3_372000_153000 0.016
R_VDD1_4080 METAL3_372000_153000 METAL3_366000_153000 0.048
R_VDD1_4081 METAL3_366000_153000 METAL3_364000_153000 0.016
R_VDD1_4082 METAL3_364000_153000 METAL3_362000_153000 0.016
R_VDD1_4083 METAL3_362000_153000 METAL3_360000_153000 0.016
R_VDD1_4084 METAL3_360000_153000 METAL3_354000_153000 0.048
R_VDD1_4085 METAL3_354000_153000 METAL3_352000_153000 0.016
R_VDD1_4086 METAL3_352000_153000 METAL3_350000_153000 0.016
R_VDD1_4087 METAL3_350000_153000 METAL3_348000_153000 0.016
R_VDD1_4088 METAL3_348000_153000 METAL3_342000_153000 0.048
R_VDD1_4089 METAL3_342000_153000 METAL3_342000_152000 0.008
R_VDD1_4090 METAL3_342000_152000 METAL3_342000_145000 0.056
R_VDD1_4091 METAL3_342000_145000 METAL3_342000_141000 0.032
R_VDD1_4092 METAL3_342000_141000 METAL3_342000_140000 0.008
R_VDD1_4093 METAL3_342000_140000 METAL3_342000_133000 0.056
R_VDD1_4094 METAL3_342000_133000 METAL3_342000_129000 0.032
R_VDD1_4095 METAL3_342000_129000 METAL3_342000_128000 0.008
R_VDD1_4096 METAL3_342000_128000 METAL3_342000_121000 0.056
R_VDD1_4097 METAL3_342000_121000 METAL3_342000_117000 0.032
R_VDD1_4098 METAL3_342000_117000 METAL3_342000_116000 0.008
R_VDD1_4099 METAL3_342000_116000 METAL3_342000_109000 0.056
R_VDD1_4100 METAL3_342000_109000 METAL3_342000_105000 0.032
R_VDD1_4101 METAL3_342000_105000 METAL3_342000_104000 0.008
R_VDD1_4102 METAL3_342000_104000 METAL3_342000_97000 0.056
R_VDD1_4103 METAL3_342000_97000 METAL3_342000_93000 0.032
R_VDD1_4104 METAL3_342000_93000 METAL3_341000_93000 0.008
R_VDD1_4105 METAL3_341000_93000 METAL3_340000_93000 0.008
R_VDD1_4106 METAL3_340000_93000 METAL3_338000_93000 0.016
R_VDD1_4107 METAL3_338000_93000 METAL3_336000_93000 0.016
R_VDD1_4108 METAL3_336000_93000 METAL3_330000_93000 0.048
R_VDD1_4109 METAL3_330000_93000 METAL3_329000_93000 0.008
R_VDD1_4110 METAL3_329000_93000 METAL3_328000_93000 0.008
R_VDD1_4111 METAL3_328000_93000 METAL3_326000_93000 0.016
R_VDD1_4112 METAL3_326000_93000 METAL3_324000_93000 0.016
R_VDD1_4113 METAL3_324000_93000 METAL3_318000_93000 0.048
R_VDD1_4114 METAL3_318000_93000 METAL3_317000_93000 0.008
R_VDD1_4115 METAL3_317000_93000 METAL3_316000_93000 0.008
R_VDD1_4116 METAL3_316000_93000 METAL3_314000_93000 0.016
R_VDD1_4117 METAL3_314000_93000 METAL3_312000_93000 0.016
R_VDD1_4118 METAL3_312000_93000 METAL3_306000_93000 0.048
R_VDD1_4119 METAL3_306000_93000 METAL3_305000_93000 0.008
R_VDD1_4120 METAL3_305000_93000 METAL3_304000_93000 0.008
R_VDD1_4121 METAL3_304000_93000 METAL3_302000_93000 0.016
R_VDD1_4122 METAL3_302000_93000 METAL3_300000_93000 0.016
R_VDD1_4123 METAL3_300000_93000 METAL3_294000_93000 0.048
R_VDD1_4124 METAL3_294000_93000 METAL3_293000_93000 0.008
R_VDD1_4125 METAL3_293000_93000 METAL2_293000_93000 0.1
R_VDD1_4126 METAL2_293000_93000 METAL2_293000_92000 0.008
R_VDD1_4127 METAL2_293000_92000 METAL2_293000_81000 0.088
R_VDD1_4128 METAL2_293000_81000 METAL2_293000_80000 0.008
R_VDD1_4129 METAL2_293000_80000 METAL2_293000_69000 0.088
R_VDD1_4130 METAL2_293000_69000 METAL2_293000_68000 0.008
R_VDD1_4131 METAL2_293000_68000 METAL1_293000_68000 0.1
R_VDD1_4132 METAL1_293000_68000 METAL1_293000_57000 0.088
R_VDD1_4133 METAL1_293000_57000 METAL1_293000_56000 0.008
R_VDD1_4134 METAL1_293000_56000 METAL1_293000_45000 0.088
R_VDD1_4135 METAL1_293000_45000 METAL1_293000_44000 0.008
R_VDD1_4136 METAL1_293000_44000 METAL1_293000_33000 0.088
R_VDD1_4137 METAL1_293000_33000 METAL1_293000_32000 0.008
R_VDD1_4138 METAL1_293000_32000 METAL1_293000_21000 0.088
R_VDD1_4139 METAL1_293000_21000 METAL1_294000_21000 0.008
R_VDD1_4140 METAL1_294000_21000 METAL1_300000_21000 0.048
R_VDD1_4141 METAL1_300000_21000 METAL1_300000_20000 0.008
R_VDD1_4142 METAL1_300000_20000 METAL1_300000_9000 0.088
R_VDD1_4143 METAL1_300000_9000 METAL1_300000_8000 0.008
R_VDD1_4144 METAL1_300000_8000 METAL2_300000_8000 0.1
R_VDD1_4145 METAL3_531000_707000 METAL3_532000_707000 0.008
R_VDD1_4146 METAL3_532000_707000 METAL3_534000_707000 0.016
R_VDD1_4147 METAL3_534000_707000 METAL3_536000_707000 0.016
R_VDD1_4148 METAL3_536000_707000 METAL3_543000_707000 0.056
R_VDD1_4149 METAL3_543000_707000 METAL2_543000_707000 0.1
R_VDD1_4150 METAL2_543000_707000 METAL1_543000_707000 0.1
R_VDD1_4151 METAL1_543000_707000 METAL1_543000_717000 0.08
R_VDD1_4152 METAL1_543000_717000 METAL1_543000_729000 0.096
R_VDD1_4153 METAL1_543000_729000 METAL1_543000_745000 0.128
R_VDD1_4154 METAL1_543000_745000 METAL1_543000_757000 0.096
R_VDD1_4155 METAL1_543000_757000 METAL1_543000_769000 0.096
R_VDD1_4156 METAL1_543000_769000 METAL1_543000_781000 0.096
R_VDD1_4157 METAL1_543000_781000 METAL1_543000_793000 0.096
R_VDD1_4158 METAL1_543000_793000 METAL1_543000_805000 0.096
R_VDD1_4159 METAL1_543000_805000 METAL1_543000_817000 0.096
R_VDD1_4160 METAL1_543000_817000 METAL1_543000_829000 0.096
R_VDD1_4161 METAL1_543000_829000 METAL1_543000_841000 0.096
R_VDD1_4162 METAL1_543000_841000 METAL1_543000_845000 0.032
R_VDD1_4163 METAL1_543000_845000 METAL1_543000_853000 0.064
R_VDD1_4164 METAL1_543000_853000 METAL2_543000_853000 0.1
R_VDD1_4165 METAL2_543000_853000 METAL2_543000_857000 0.032
R_VDD1_4166 METAL2_543000_857000 METAL2_543000_865000 0.064
R_VDD1_4167 METAL2_543000_865000 METAL3_543000_865000 0.1
R_VDD1_4168 METAL3_543000_865000 METAL4_543000_865000 0.1
I_VDD1_1 METAL6_555000_6465000 gnd 0.01
I_VDD1_2 METAL6_245000_6465000 gnd 0.01
I_VDD1_3 METAL6_555000_5765000 gnd 0.01
I_VDD1_4 METAL6_245000_5765000 gnd 0.01
I_VDD1_5 METAL6_555000_5065000 gnd 0.01
I_VDD1_6 METAL6_245000_5065000 gnd 0.01
I_VDD1_7 METAL6_555000_4365000 gnd 0.01
I_VDD1_8 METAL6_245000_4365000 gnd 0.01
I_VDD1_9 METAL6_555000_3665000 gnd 0.01
I_VDD1_10 METAL6_245000_3665000 gnd 0.01
I_VDD1_11 METAL6_555000_2965000 gnd 0.01
I_VDD1_12 METAL6_245000_2965000 gnd 0.01
I_VDD1_13 METAL6_555000_2265000 gnd 0.01
I_VDD1_14 METAL6_245000_2265000 gnd 0.01
I_VDD1_15 METAL6_555000_1565000 gnd 0.01
I_VDD1_16 METAL6_245000_1565000 gnd 0.01
I_VDD1_17 METAL6_555000_865000 gnd 0.01
I_VDD1_18 METAL6_245000_865000 gnd 0.01
I_VDD1_19 METAL6_555000_165000 gnd 0.01
I_VDD1_20 METAL6_245000_165000 gnd 0.01

V_VDD2_2 METAL6_350000_0 gnd 1
R_VDD2_4169 METAL6_350000_0 METAL6_350000_8000 0.016
R_VDD2_4170 METAL6_350000_8000 METAL6_350000_20000 0.024
R_VDD2_4171 METAL6_350000_20000 METAL6_348000_20000 0.004
R_VDD2_4172 METAL6_348000_20000 METAL6_342000_20000 0.012
R_VDD2_4173 METAL6_342000_20000 METAL6_340000_20000 0.004
R_VDD2_4174 METAL6_340000_20000 METAL6_340000_32000 0.024
R_VDD2_4175 METAL6_340000_32000 METAL6_338000_32000 0.004
R_VDD2_4176 METAL6_338000_32000 METAL6_336000_32000 0.004
R_VDD2_4177 METAL6_336000_32000 METAL6_330000_32000 0.012
R_VDD2_4178 METAL6_330000_32000 METAL6_328000_32000 0.004
R_VDD2_4179 METAL6_328000_32000 METAL6_328000_44000 0.024
R_VDD2_4180 METAL6_328000_44000 METAL6_326000_44000 0.004
R_VDD2_4181 METAL6_326000_44000 METAL6_324000_44000 0.004
R_VDD2_4182 METAL6_324000_44000 METAL6_318000_44000 0.012
R_VDD2_4183 METAL6_318000_44000 METAL6_314000_44000 0.008
R_VDD2_4184 METAL6_314000_44000 METAL6_312000_44000 0.004
R_VDD2_4185 METAL6_312000_44000 METAL6_306000_44000 0.012
R_VDD2_4186 METAL6_306000_44000 METAL6_305000_44000 0.002
R_VDD2_4187 METAL6_305000_44000 METAL6_302000_44000 0.006
R_VDD2_4188 METAL6_302000_44000 METAL6_300000_44000 0.004
R_VDD2_4189 METAL6_300000_44000 METAL6_294000_44000 0.012
R_VDD2_4190 METAL6_294000_44000 METAL6_294000_45000 0.002
R_VDD2_4191 METAL6_294000_45000 METAL6_294000_56000 0.022
R_VDD2_4192 METAL6_294000_56000 METAL6_294000_57000 0.002
R_VDD2_4193 METAL6_294000_57000 METAL6_294000_68000 0.022
R_VDD2_4194 METAL6_294000_68000 METAL6_293000_68000 0.002
R_VDD2_4195 METAL6_293000_68000 METAL6_290000_68000 0.006
R_VDD2_4196 METAL6_290000_68000 METAL6_288000_68000 0.004
R_VDD2_4197 METAL6_288000_68000 METAL6_282000_68000 0.012
R_VDD2_4198 METAL6_282000_68000 METAL6_282000_69000 0.002
R_VDD2_4199 METAL6_282000_69000 METAL6_282000_81000 0.024
R_VDD2_4200 METAL6_282000_81000 METAL6_282000_93000 0.024
R_VDD2_4201 METAL6_282000_93000 METAL6_282000_105000 0.024
R_VDD2_4202 METAL6_282000_105000 METAL6_282000_117000 0.024
R_VDD2_4203 METAL6_282000_117000 METAL6_282000_121000 0.008
R_VDD2_4204 METAL6_282000_121000 METAL6_282000_129000 0.016
R_VDD2_4205 METAL6_282000_129000 METAL6_282000_133000 0.008
R_VDD2_4206 METAL6_282000_133000 METAL6_281000_133000 0.002
R_VDD2_4207 METAL6_281000_133000 METAL6_278000_133000 0.006
R_VDD2_4208 METAL6_278000_133000 METAL6_276000_133000 0.004
R_VDD2_4209 METAL6_276000_133000 METAL6_270000_133000 0.012
R_VDD2_4210 METAL6_270000_133000 METAL6_270000_141000 0.016
R_VDD2_4211 METAL6_270000_141000 METAL6_270000_145000 0.008
R_VDD2_4212 METAL6_270000_145000 METAL6_270000_153000 0.016
R_VDD2_4213 METAL6_270000_153000 METAL6_270000_157000 0.008
R_VDD2_4214 METAL6_270000_157000 METAL6_270000_165000 0.016
R_VDD2_4215 METAL6_270000_165000 METAL6_270000_169000 0.008
R_VDD2_4216 METAL6_270000_169000 METAL6_270000_177000 0.016
R_VDD2_4217 METAL6_270000_177000 METAL6_270000_181000 0.008
R_VDD2_4218 METAL6_270000_181000 METAL6_270000_193000 0.024
R_VDD2_4219 METAL6_270000_193000 METAL6_269000_193000 0.002
R_VDD2_4220 METAL6_269000_193000 METAL6_266000_193000 0.006
R_VDD2_4221 METAL6_266000_193000 METAL6_266000_205000 0.024
R_VDD2_4222 METAL6_266000_205000 METAL6_266000_217000 0.024
R_VDD2_4223 METAL6_266000_217000 METAL6_266000_229000 0.024
R_VDD2_4224 METAL6_266000_229000 METAL6_266000_233000 0.008
R_VDD2_4225 METAL6_266000_233000 METAL6_266000_241000 0.016
R_VDD2_4226 METAL6_266000_241000 METAL6_266000_245000 0.008
R_VDD2_4227 METAL6_266000_245000 METAL6_266000_253000 0.016
R_VDD2_4228 METAL6_266000_253000 METAL5_266000_253000 0.1
R_VDD2_4229 METAL5_266000_253000 METAL5_269000_253000 0.012
R_VDD2_4230 METAL5_269000_253000 METAL5_269000_257000 0.016
R_VDD2_4231 METAL5_269000_257000 METAL5_270000_257000 0.004
R_VDD2_4232 METAL5_270000_257000 METAL5_276000_257000 0.024
R_VDD2_4233 METAL5_276000_257000 METAL5_278000_257000 0.008
R_VDD2_4234 METAL5_278000_257000 METAL5_281000_257000 0.012
R_VDD2_4235 METAL5_281000_257000 METAL5_282000_257000 0.004
R_VDD2_4236 METAL5_282000_257000 METAL5_288000_257000 0.024
R_VDD2_4237 METAL5_288000_257000 METAL5_290000_257000 0.008
R_VDD2_4238 METAL5_290000_257000 METAL5_293000_257000 0.012
R_VDD2_4239 METAL5_293000_257000 METAL5_294000_257000 0.004
R_VDD2_4240 METAL5_294000_257000 METAL5_300000_257000 0.024
R_VDD2_4241 METAL5_300000_257000 METAL5_302000_257000 0.008
R_VDD2_4242 METAL5_302000_257000 METAL5_302000_265000 0.032
R_VDD2_4243 METAL5_302000_265000 METAL5_302000_269000 0.016
R_VDD2_4244 METAL5_302000_269000 METAL5_302000_277000 0.032
R_VDD2_4245 METAL5_302000_277000 METAL5_302000_281000 0.016
R_VDD2_4246 METAL5_302000_281000 METAL5_305000_281000 0.012
R_VDD2_4247 METAL5_305000_281000 METAL5_306000_281000 0.004
R_VDD2_4248 METAL5_306000_281000 METAL5_312000_281000 0.024
R_VDD2_4249 METAL5_312000_281000 METAL5_312000_289000 0.032
R_VDD2_4250 METAL5_312000_289000 METAL5_312000_293000 0.016
R_VDD2_4251 METAL5_312000_293000 METAL5_312000_301000 0.032
R_VDD2_4252 METAL5_312000_301000 METAL5_312000_305000 0.016
R_VDD2_4253 METAL5_312000_305000 METAL5_312000_313000 0.032
R_VDD2_4254 METAL5_312000_313000 METAL5_312000_317000 0.016
R_VDD2_4255 METAL5_312000_317000 METAL5_312000_329000 0.048
R_VDD2_4256 METAL5_312000_329000 METAL5_312000_341000 0.048
R_VDD2_4257 METAL5_312000_341000 METAL5_312000_353000 0.048
R_VDD2_4258 METAL5_312000_353000 METAL5_312000_365000 0.048
R_VDD2_4259 METAL5_312000_365000 METAL5_312000_377000 0.048
R_VDD2_4260 METAL5_312000_377000 METAL5_312000_389000 0.048
R_VDD2_4261 METAL5_312000_389000 METAL5_312000_429000 0.16
R_VDD2_4262 METAL5_312000_429000 METAL5_312000_441000 0.048
R_VDD2_4263 METAL5_312000_441000 METAL5_314000_441000 0.008
R_VDD2_4264 METAL5_314000_441000 METAL5_318000_441000 0.016
R_VDD2_4265 METAL5_318000_441000 METAL5_324000_441000 0.024
R_VDD2_4266 METAL5_324000_441000 METAL5_324000_453000 0.048
R_VDD2_4267 METAL5_324000_453000 METAL5_326000_453000 0.008
R_VDD2_4268 METAL5_326000_453000 METAL5_328000_453000 0.008
R_VDD2_4269 METAL5_328000_453000 METAL5_330000_453000 0.008
R_VDD2_4270 METAL5_330000_453000 METAL5_336000_453000 0.024
R_VDD2_4271 METAL5_336000_453000 METAL5_338000_453000 0.008
R_VDD2_4272 METAL5_338000_453000 METAL5_340000_453000 0.008
R_VDD2_4273 METAL5_340000_453000 METAL5_342000_453000 0.008
R_VDD2_4274 METAL5_342000_453000 METAL5_348000_453000 0.024
R_VDD2_4275 METAL5_348000_453000 METAL5_350000_453000 0.008
R_VDD2_4276 METAL5_350000_453000 METAL5_352000_453000 0.008
R_VDD2_4277 METAL5_352000_453000 METAL5_354000_453000 0.008
R_VDD2_4278 METAL5_354000_453000 METAL5_360000_453000 0.024
R_VDD2_4279 METAL5_360000_453000 METAL5_362000_453000 0.008
R_VDD2_4280 METAL5_362000_453000 METAL5_364000_453000 0.008
R_VDD2_4281 METAL5_364000_453000 METAL5_366000_453000 0.008
R_VDD2_4282 METAL5_366000_453000 METAL5_372000_453000 0.024
R_VDD2_4283 METAL5_372000_453000 METAL4_372000_453000 0.1
R_VDD2_4284 METAL4_372000_453000 METAL4_372000_465000 0.096
R_VDD2_4285 METAL4_372000_465000 METAL4_372000_469000 0.032
R_VDD2_4286 METAL4_372000_469000 METAL4_372000_477000 0.064
R_VDD2_4287 METAL4_372000_477000 METAL4_374000_477000 0.016
R_VDD2_4288 METAL4_374000_477000 METAL4_376000_477000 0.016
R_VDD2_4289 METAL4_376000_477000 METAL4_378000_477000 0.016
R_VDD2_4290 METAL4_378000_477000 METAL5_378000_477000 0.1
R_VDD2_4291 METAL5_378000_477000 METAL5_384000_477000 0.024
R_VDD2_4292 METAL5_384000_477000 METAL5_384000_481000 0.016
R_VDD2_4293 METAL5_384000_481000 METAL5_384000_489000 0.032
R_VDD2_4294 METAL5_384000_489000 METAL5_384000_493000 0.016
R_VDD2_4295 METAL5_384000_493000 METAL5_384000_501000 0.032
R_VDD2_4296 METAL5_384000_501000 METAL5_384000_505000 0.016
R_VDD2_4297 METAL5_384000_505000 METAL5_384000_517000 0.048
R_VDD2_4298 METAL5_384000_517000 METAL5_384000_529000 0.048
R_VDD2_4299 METAL5_384000_529000 METAL5_384000_541000 0.048
R_VDD2_4300 METAL5_384000_541000 METAL5_384000_553000 0.048
R_VDD2_4301 METAL5_384000_553000 METAL5_384000_565000 0.048
R_VDD2_4302 METAL5_384000_565000 METAL5_384000_577000 0.048
R_VDD2_4303 METAL5_384000_577000 METAL4_384000_577000 0.1
R_VDD2_4304 METAL4_384000_577000 METAL4_384000_589000 0.096
R_VDD2_4305 METAL4_384000_589000 METAL4_384000_601000 0.096
R_VDD2_4306 METAL4_384000_601000 METAL5_384000_601000 0.1
R_VDD2_4307 METAL5_384000_601000 METAL5_384000_613000 0.048
R_VDD2_4308 METAL5_384000_613000 METAL5_384000_625000 0.048
R_VDD2_4309 METAL5_384000_625000 METAL5_384000_681000 0.224
R_VDD2_4310 METAL5_384000_681000 METAL5_384000_693000 0.048
R_VDD2_4311 METAL5_384000_693000 METAL5_384000_705000 0.048
R_VDD2_4312 METAL5_384000_705000 METAL5_384000_707000 0.008
R_VDD2_4313 METAL5_384000_707000 METAL5_384000_717000 0.04
R_VDD2_4314 METAL5_384000_717000 METAL5_384000_781000 0.256
R_VDD2_4315 METAL5_384000_781000 METAL5_384000_793000 0.048
R_VDD2_4316 METAL5_384000_793000 METAL5_386000_793000 0.008
R_VDD2_4317 METAL5_386000_793000 METAL5_386000_805000 0.048
R_VDD2_4318 METAL5_386000_805000 METAL4_386000_805000 0.1
R_VDD2_4319 METAL4_386000_805000 METAL4_386000_817000 0.096
R_VDD2_4320 METAL4_386000_817000 METAL4_386000_829000 0.096
R_VDD2_4321 METAL4_386000_829000 METAL4_386000_841000 0.096
R_VDD2_4322 METAL4_386000_841000 METAL5_386000_841000 0.1
R_VDD2_4323 METAL5_386000_841000 METAL5_386000_853000 0.048
R_VDD2_4324 METAL5_386000_853000 METAL5_386000_865000 0.048
R_VDD2_4325 METAL5_386000_865000 METAL5_386000_869000 0.016
R_VDD2_4326 METAL5_386000_869000 METAL5_386000_877000 0.032
R_VDD2_4327 METAL5_386000_877000 METAL5_386000_881000 0.016
R_VDD2_4328 METAL5_386000_881000 METAL5_386000_889000 0.032
R_VDD2_4329 METAL5_386000_889000 METAL5_386000_893000 0.016
R_VDD2_4330 METAL5_386000_893000 METAL5_386000_901000 0.032
R_VDD2_4331 METAL5_386000_901000 METAL5_386000_905000 0.016
R_VDD2_4332 METAL5_386000_905000 METAL5_386000_917000 0.048
R_VDD2_4333 METAL5_386000_917000 METAL5_386000_929000 0.048
R_VDD2_4334 METAL5_386000_929000 METAL5_386000_941000 0.048
R_VDD2_4335 METAL5_386000_941000 METAL5_386000_953000 0.048
R_VDD2_4336 METAL5_386000_953000 METAL5_386000_965000 0.048
R_VDD2_4337 METAL5_386000_965000 METAL5_388000_965000 0.008
R_VDD2_4338 METAL5_388000_965000 METAL5_390000_965000 0.008
R_VDD2_4339 METAL5_390000_965000 METAL5_396000_965000 0.024
R_VDD2_4340 METAL5_396000_965000 METAL5_398000_965000 0.008
R_VDD2_4341 METAL5_398000_965000 METAL5_400000_965000 0.008
R_VDD2_4342 METAL5_400000_965000 METAL5_402000_965000 0.008
R_VDD2_4343 METAL5_402000_965000 METAL5_408000_965000 0.024
R_VDD2_4344 METAL5_408000_965000 METAL5_410000_965000 0.008
R_VDD2_4345 METAL5_410000_965000 METAL5_410000_977000 0.048
R_VDD2_4346 METAL5_410000_977000 METAL5_412000_977000 0.008
R_VDD2_4347 METAL5_412000_977000 METAL5_414000_977000 0.008
R_VDD2_4348 METAL5_414000_977000 METAL5_420000_977000 0.024
R_VDD2_4349 METAL5_420000_977000 METAL5_422000_977000 0.008
R_VDD2_4350 METAL5_422000_977000 METAL5_422000_989000 0.048
R_VDD2_4351 METAL5_422000_989000 METAL5_422000_1001000 0.048
R_VDD2_4352 METAL5_422000_1001000 METAL5_422000_1013000 0.048
R_VDD2_4353 METAL5_422000_1013000 METAL5_422000_1025000 0.048
R_VDD2_4354 METAL5_422000_1025000 METAL5_422000_1041000 0.064
R_VDD2_4355 METAL5_422000_1041000 METAL5_422000_1053000 0.048
R_VDD2_4356 METAL5_422000_1053000 METAL5_422000_1065000 0.048
R_VDD2_4357 METAL5_422000_1065000 METAL4_422000_1065000 0.1
R_VDD2_4358 METAL4_422000_1065000 METAL4_422000_1077000 0.096
R_VDD2_4359 METAL4_422000_1077000 METAL4_422000_1089000 0.096
R_VDD2_4360 METAL4_422000_1089000 METAL5_422000_1089000 0.1
R_VDD2_4361 METAL5_422000_1089000 METAL5_422000_1101000 0.048
R_VDD2_4362 METAL5_422000_1101000 METAL5_422000_1153000 0.208
R_VDD2_4363 METAL5_422000_1153000 METAL5_422000_1165000 0.048
R_VDD2_4364 METAL5_422000_1165000 METAL4_422000_1165000 0.1
R_VDD2_4365 METAL4_422000_1165000 METAL4_422000_1177000 0.096
R_VDD2_4366 METAL4_422000_1177000 METAL4_422000_1189000 0.096
R_VDD2_4367 METAL4_422000_1189000 METAL5_422000_1189000 0.1
R_VDD2_4368 METAL5_422000_1189000 METAL5_422000_1201000 0.048
R_VDD2_4369 METAL5_422000_1201000 METAL5_422000_1217000 0.064
R_VDD2_4370 METAL5_422000_1217000 METAL5_422000_1229000 0.048
R_VDD2_4371 METAL5_422000_1229000 METAL5_422000_1241000 0.048
R_VDD2_4372 METAL5_422000_1241000 METAL5_424000_1241000 0.008
R_VDD2_4373 METAL5_424000_1241000 METAL5_426000_1241000 0.008
R_VDD2_4374 METAL5_426000_1241000 METAL5_434000_1241000 0.032
R_VDD2_4375 METAL5_434000_1241000 METAL5_436000_1241000 0.008
R_VDD2_4376 METAL5_436000_1241000 METAL5_438000_1241000 0.008
R_VDD2_4377 METAL5_438000_1241000 METAL5_440000_1241000 0.008
R_VDD2_4378 METAL5_440000_1241000 METAL5_446000_1241000 0.024
R_VDD2_4379 METAL5_446000_1241000 METAL5_446000_1253000 0.048
R_VDD2_4380 METAL5_446000_1253000 METAL5_446000_1265000 0.048
R_VDD2_4381 METAL5_446000_1265000 METAL5_446000_1277000 0.048
R_VDD2_4382 METAL5_446000_1277000 METAL5_446000_1289000 0.048
R_VDD2_4383 METAL5_446000_1289000 METAL5_446000_1357000 0.272
R_VDD2_4384 METAL5_446000_1357000 METAL5_446000_1369000 0.048
R_VDD2_4385 METAL5_446000_1369000 METAL4_446000_1369000 0.1
R_VDD2_4386 METAL4_446000_1369000 METAL4_446000_1381000 0.096
R_VDD2_4387 METAL4_446000_1381000 METAL4_446000_1393000 0.096
R_VDD2_4388 METAL4_446000_1393000 METAL5_446000_1393000 0.1
R_VDD2_4389 METAL5_446000_1393000 METAL5_446000_1405000 0.048
R_VDD2_4390 METAL5_446000_1405000 METAL5_446000_1407000 0.008
R_VDD2_4391 METAL5_446000_1407000 METAL5_446000_1417000 0.04
R_VDD2_4392 METAL5_446000_1417000 METAL5_446000_1529000 0.448
R_VDD2_4393 METAL5_446000_1529000 METAL5_446000_1541000 0.048
R_VDD2_4394 METAL5_446000_1541000 METAL5_446000_1553000 0.048
R_VDD2_4395 METAL5_446000_1553000 METAL5_446000_1565000 0.048
R_VDD2_4396 METAL5_446000_1565000 METAL5_446000_1577000 0.048
R_VDD2_4397 METAL5_446000_1577000 METAL5_446000_1617000 0.16
R_VDD2_4398 METAL5_446000_1617000 METAL5_446000_1629000 0.048
R_VDD2_4399 METAL5_446000_1629000 METAL5_446000_1641000 0.048
R_VDD2_4400 METAL5_446000_1641000 METAL5_446000_1653000 0.048
R_VDD2_4401 METAL5_446000_1653000 METAL5_446000_1665000 0.048
R_VDD2_4402 METAL5_446000_1665000 METAL5_446000_1677000 0.048
R_VDD2_4403 METAL5_446000_1677000 METAL5_446000_1689000 0.048
R_VDD2_4404 METAL5_446000_1689000 METAL5_446000_1753000 0.256
R_VDD2_4405 METAL5_446000_1753000 METAL5_446000_1765000 0.048
R_VDD2_4406 METAL5_446000_1765000 METAL5_446000_1777000 0.048
R_VDD2_4407 METAL5_446000_1777000 METAL5_446000_1789000 0.048
R_VDD2_4408 METAL5_446000_1789000 METAL5_446000_1817000 0.112
R_VDD2_4409 METAL5_446000_1817000 METAL5_446000_1829000 0.048
R_VDD2_4410 METAL5_446000_1829000 METAL5_446000_1841000 0.048
R_VDD2_4411 METAL5_446000_1841000 METAL5_446000_1853000 0.048
R_VDD2_4412 METAL5_446000_1853000 METAL5_446000_1865000 0.048
R_VDD2_4413 METAL5_446000_1865000 METAL5_446000_1877000 0.048
R_VDD2_4414 METAL5_446000_1877000 METAL5_446000_1917000 0.16
R_VDD2_4415 METAL5_446000_1917000 METAL4_446000_1917000 0.1
R_VDD2_4416 METAL4_446000_1917000 METAL4_440000_1917000 0.048
R_VDD2_4417 METAL4_440000_1917000 METAL4_438000_1917000 0.016
R_VDD2_4418 METAL4_438000_1917000 METAL4_436000_1917000 0.016
R_VDD2_4419 METAL4_436000_1917000 METAL4_434000_1917000 0.016
R_VDD2_4420 METAL4_434000_1917000 METAL4_426000_1917000 0.064
R_VDD2_4421 METAL4_426000_1917000 METAL4_424000_1917000 0.016
R_VDD2_4422 METAL4_424000_1917000 METAL4_422000_1917000 0.016
R_VDD2_4423 METAL4_422000_1917000 METAL4_422000_1929000 0.096
R_VDD2_4424 METAL4_422000_1929000 METAL4_422000_1941000 0.096
R_VDD2_4425 METAL4_422000_1941000 METAL4_422000_1953000 0.096
R_VDD2_4426 METAL4_422000_1953000 METAL4_422000_1965000 0.096
R_VDD2_4427 METAL4_422000_1965000 METAL4_422000_1977000 0.096
R_VDD2_4428 METAL4_422000_1977000 METAL4_422000_1989000 0.096
R_VDD2_4429 METAL4_422000_1989000 METAL5_422000_1989000 0.1
R_VDD2_4430 METAL5_422000_1989000 METAL5_422000_2001000 0.048
R_VDD2_4431 METAL5_422000_2001000 METAL5_422000_2013000 0.048
R_VDD2_4432 METAL5_422000_2013000 METAL5_422000_2093000 0.32
R_VDD2_4433 METAL5_422000_2093000 METAL5_422000_2107000 0.056
R_VDD2_4434 METAL5_422000_2107000 METAL5_422000_2217000 0.44
R_VDD2_4435 METAL5_422000_2217000 METAL5_422000_2229000 0.048
R_VDD2_4436 METAL5_422000_2229000 METAL5_422000_2241000 0.048
R_VDD2_4437 METAL5_422000_2241000 METAL5_422000_2253000 0.048
R_VDD2_4438 METAL5_422000_2253000 METAL5_422000_2265000 0.048
R_VDD2_4439 METAL5_422000_2265000 METAL5_422000_2277000 0.048
R_VDD2_4440 METAL5_422000_2277000 METAL5_422000_2341000 0.256
R_VDD2_4441 METAL5_422000_2341000 METAL5_422000_2353000 0.048
R_VDD2_4442 METAL5_422000_2353000 METAL5_422000_2365000 0.048
R_VDD2_4443 METAL5_422000_2365000 METAL5_422000_2377000 0.048
R_VDD2_4444 METAL5_422000_2377000 METAL5_422000_2389000 0.048
R_VDD2_4445 METAL5_422000_2389000 METAL5_422000_2453000 0.256
R_VDD2_4446 METAL5_422000_2453000 METAL5_422000_2465000 0.048
R_VDD2_4447 METAL5_422000_2465000 METAL5_422000_2477000 0.048
R_VDD2_4448 METAL5_422000_2477000 METAL5_422000_2489000 0.048
R_VDD2_4449 METAL5_422000_2489000 METAL5_422000_2553000 0.256
R_VDD2_4450 METAL5_422000_2553000 METAL5_422000_2565000 0.048
R_VDD2_4451 METAL5_422000_2565000 METAL5_422000_2577000 0.048
R_VDD2_4452 METAL5_422000_2577000 METAL5_422000_2605000 0.112
R_VDD2_4453 METAL5_422000_2605000 METAL5_422000_2617000 0.048
R_VDD2_4454 METAL5_422000_2617000 METAL5_422000_2629000 0.048
R_VDD2_4455 METAL5_422000_2629000 METAL5_422000_2641000 0.048
R_VDD2_4456 METAL5_422000_2641000 METAL5_422000_2653000 0.048
R_VDD2_4457 METAL5_422000_2653000 METAL5_422000_2665000 0.048
R_VDD2_4458 METAL5_422000_2665000 METAL4_422000_2665000 0.1
R_VDD2_4459 METAL4_422000_2665000 METAL4_422000_2677000 0.096
R_VDD2_4460 METAL4_422000_2677000 METAL4_422000_2689000 0.096
R_VDD2_4461 METAL4_422000_2689000 METAL4_422000_2701000 0.096
R_VDD2_4462 METAL4_422000_2701000 METAL5_422000_2701000 0.1
R_VDD2_4463 METAL5_422000_2701000 METAL5_422000_2713000 0.048
R_VDD2_4464 METAL5_422000_2713000 METAL5_422000_2769000 0.224
R_VDD2_4465 METAL5_422000_2769000 METAL5_422000_2781000 0.048
R_VDD2_4466 METAL5_422000_2781000 METAL5_422000_2793000 0.048
R_VDD2_4467 METAL5_422000_2793000 METAL5_422000_2805000 0.048
R_VDD2_4468 METAL5_422000_2805000 METAL5_422000_2807000 0.008
R_VDD2_4469 METAL5_422000_2807000 METAL5_422000_2817000 0.04
R_VDD2_4470 METAL5_422000_2817000 METAL5_422000_2941000 0.496
R_VDD2_4471 METAL5_422000_2941000 METAL5_422000_2953000 0.048
R_VDD2_4472 METAL5_422000_2953000 METAL5_422000_2965000 0.048
R_VDD2_4473 METAL5_422000_2965000 METAL5_422000_2977000 0.048
R_VDD2_4474 METAL5_422000_2977000 METAL5_422000_2989000 0.048
R_VDD2_4475 METAL5_422000_2989000 METAL5_422000_3001000 0.048
R_VDD2_4476 METAL5_422000_3001000 METAL5_422000_3053000 0.208
R_VDD2_4477 METAL5_422000_3053000 METAL5_422000_3065000 0.048
R_VDD2_4478 METAL5_422000_3065000 METAL5_422000_3077000 0.048
R_VDD2_4479 METAL5_422000_3077000 METAL5_422000_3089000 0.048
R_VDD2_4480 METAL5_422000_3089000 METAL5_422000_3153000 0.256
R_VDD2_4481 METAL5_422000_3153000 METAL5_422000_3165000 0.048
R_VDD2_4482 METAL5_422000_3165000 METAL5_422000_3177000 0.048
R_VDD2_4483 METAL5_422000_3177000 METAL5_422000_3189000 0.048
R_VDD2_4484 METAL5_422000_3189000 METAL5_422000_3253000 0.256
R_VDD2_4485 METAL5_422000_3253000 METAL5_422000_3265000 0.048
R_VDD2_4486 METAL5_422000_3265000 METAL5_422000_3277000 0.048
R_VDD2_4487 METAL5_422000_3277000 METAL5_422000_3289000 0.048
R_VDD2_4488 METAL5_422000_3289000 METAL5_422000_3341000 0.208
R_VDD2_4489 METAL5_422000_3341000 METAL5_422000_3353000 0.048
R_VDD2_4490 METAL5_422000_3353000 METAL5_422000_3365000 0.048
R_VDD2_4491 METAL5_422000_3365000 METAL5_422000_3377000 0.048
R_VDD2_4492 METAL5_422000_3377000 METAL4_422000_3377000 0.1
R_VDD2_4493 METAL4_422000_3377000 METAL4_422000_3389000 0.096
R_VDD2_4494 METAL4_422000_3389000 METAL4_422000_3401000 0.096
R_VDD2_4495 METAL4_422000_3401000 METAL4_422000_3413000 0.096
R_VDD2_4496 METAL4_422000_3413000 METAL5_422000_3413000 0.1
R_VDD2_4497 METAL5_422000_3413000 METAL5_422000_3493000 0.32
R_VDD2_4498 METAL5_422000_3493000 METAL5_422000_3495000 0.008
R_VDD2_4499 METAL5_422000_3495000 METAL5_422000_3507000 0.048
R_VDD2_4500 METAL5_422000_3507000 METAL5_422000_3519000 0.048
R_VDD2_4501 METAL5_422000_3519000 METAL5_422000_3641000 0.488
R_VDD2_4502 METAL5_422000_3641000 METAL5_422000_3653000 0.048
R_VDD2_4503 METAL5_422000_3653000 METAL5_422000_3665000 0.048
R_VDD2_4504 METAL5_422000_3665000 METAL5_422000_3677000 0.048
R_VDD2_4505 METAL5_422000_3677000 METAL5_422000_3753000 0.304
R_VDD2_4506 METAL5_422000_3753000 METAL5_422000_3765000 0.048
R_VDD2_4507 METAL5_422000_3765000 METAL5_422000_3777000 0.048
R_VDD2_4508 METAL5_422000_3777000 METAL5_422000_3789000 0.048
R_VDD2_4509 METAL5_422000_3789000 METAL5_422000_3853000 0.256
R_VDD2_4510 METAL5_422000_3853000 METAL5_422000_3865000 0.048
R_VDD2_4511 METAL5_422000_3865000 METAL5_422000_3877000 0.048
R_VDD2_4512 METAL5_422000_3877000 METAL5_422000_3941000 0.256
R_VDD2_4513 METAL5_422000_3941000 METAL5_422000_3953000 0.048
R_VDD2_4514 METAL5_422000_3953000 METAL5_422000_3965000 0.048
R_VDD2_4515 METAL5_422000_3965000 METAL5_422000_3977000 0.048
R_VDD2_4516 METAL5_422000_3977000 METAL5_422000_4041000 0.256
R_VDD2_4517 METAL5_422000_4041000 METAL5_424000_4041000 0.008
R_VDD2_4518 METAL5_424000_4041000 METAL5_426000_4041000 0.008
R_VDD2_4519 METAL5_426000_4041000 METAL5_434000_4041000 0.032
R_VDD2_4520 METAL5_434000_4041000 METAL5_436000_4041000 0.008
R_VDD2_4521 METAL5_436000_4041000 METAL5_438000_4041000 0.008
R_VDD2_4522 METAL5_438000_4041000 METAL5_440000_4041000 0.008
R_VDD2_4523 METAL5_440000_4041000 METAL5_446000_4041000 0.024
R_VDD2_4524 METAL5_446000_4041000 METAL5_448000_4041000 0.008
R_VDD2_4525 METAL5_448000_4041000 METAL5_450000_4041000 0.008
R_VDD2_4526 METAL5_450000_4041000 METAL5_452000_4041000 0.008
R_VDD2_4527 METAL5_452000_4041000 METAL5_458000_4041000 0.024
R_VDD2_4528 METAL5_458000_4041000 METAL5_460000_4041000 0.008
R_VDD2_4529 METAL5_460000_4041000 METAL5_462000_4041000 0.008
R_VDD2_4530 METAL5_462000_4041000 METAL5_464000_4041000 0.008
R_VDD2_4531 METAL5_464000_4041000 METAL5_464000_4053000 0.048
R_VDD2_4532 METAL5_464000_4053000 METAL4_464000_4053000 0.1
R_VDD2_4533 METAL4_464000_4053000 METAL4_464000_4065000 0.096
R_VDD2_4534 METAL4_464000_4065000 METAL4_464000_4077000 0.096
R_VDD2_4535 METAL4_464000_4077000 METAL5_464000_4077000 0.1
R_VDD2_4536 METAL5_464000_4077000 METAL6_464000_4077000 0.1
R_VDD2_4537 METAL6_464000_4077000 METAL6_464000_4089000 0.024
R_VDD2_4538 METAL6_464000_4089000 METAL6_464000_4101000 0.024
R_VDD2_4539 METAL6_464000_4101000 METAL6_464000_4181000 0.16
R_VDD2_4540 METAL6_464000_4181000 METAL5_464000_4181000 0.1
R_VDD2_4541 METAL5_464000_4181000 METAL5_472000_4181000 0.032
R_VDD2_4542 METAL5_472000_4181000 METAL5_474000_4181000 0.008
R_VDD2_4543 METAL5_474000_4181000 METAL5_476000_4181000 0.008
R_VDD2_4544 METAL5_476000_4181000 METAL5_476000_4193000 0.048
R_VDD2_4545 METAL5_476000_4193000 METAL5_476000_4205000 0.048
R_VDD2_4546 METAL5_476000_4205000 METAL5_476000_4207000 0.008
R_VDD2_4547 METAL5_476000_4207000 METAL5_476000_4341000 0.536
R_VDD2_4548 METAL5_476000_4341000 METAL5_476000_4353000 0.048
R_VDD2_4549 METAL5_476000_4353000 METAL5_476000_4365000 0.048
R_VDD2_4550 METAL5_476000_4365000 METAL5_476000_4377000 0.048
R_VDD2_4551 METAL5_476000_4377000 METAL5_476000_4389000 0.048
R_VDD2_4552 METAL5_476000_4389000 METAL5_476000_4453000 0.256
R_VDD2_4553 METAL5_476000_4453000 METAL5_476000_4465000 0.048
R_VDD2_4554 METAL5_476000_4465000 METAL5_476000_4477000 0.048
R_VDD2_4555 METAL5_476000_4477000 METAL5_476000_4489000 0.048
R_VDD2_4556 METAL5_476000_4489000 METAL5_476000_4553000 0.256
R_VDD2_4557 METAL5_476000_4553000 METAL5_476000_4565000 0.048
R_VDD2_4558 METAL5_476000_4565000 METAL5_476000_4577000 0.048
R_VDD2_4559 METAL5_476000_4577000 METAL5_476000_4617000 0.16
R_VDD2_4560 METAL5_476000_4617000 METAL5_476000_4629000 0.048
R_VDD2_4561 METAL5_476000_4629000 METAL5_476000_4641000 0.048
R_VDD2_4562 METAL5_476000_4641000 METAL5_474000_4641000 0.008
R_VDD2_4563 METAL5_474000_4641000 METAL5_472000_4641000 0.008
R_VDD2_4564 METAL5_472000_4641000 METAL5_464000_4641000 0.032
R_VDD2_4565 METAL5_464000_4641000 METAL5_462000_4641000 0.008
R_VDD2_4566 METAL5_462000_4641000 METAL5_460000_4641000 0.008
R_VDD2_4567 METAL5_460000_4641000 METAL5_458000_4641000 0.008
R_VDD2_4568 METAL5_458000_4641000 METAL5_452000_4641000 0.024
R_VDD2_4569 METAL5_452000_4641000 METAL5_450000_4641000 0.008
R_VDD2_4570 METAL5_450000_4641000 METAL5_448000_4641000 0.008
R_VDD2_4571 METAL5_448000_4641000 METAL5_446000_4641000 0.008
R_VDD2_4572 METAL5_446000_4641000 METAL5_440000_4641000 0.024
R_VDD2_4573 METAL5_440000_4641000 METAL5_440000_4653000 0.048
R_VDD2_4574 METAL5_440000_4653000 METAL5_440000_4665000 0.048
R_VDD2_4575 METAL5_440000_4665000 METAL5_440000_4677000 0.048
R_VDD2_4576 METAL5_440000_4677000 METAL5_440000_4689000 0.048
R_VDD2_4577 METAL5_440000_4689000 METAL5_446000_4689000 0.024
R_VDD2_4578 METAL5_446000_4689000 METAL5_448000_4689000 0.008
R_VDD2_4579 METAL5_448000_4689000 METAL5_450000_4689000 0.008
R_VDD2_4580 METAL5_450000_4689000 METAL5_452000_4689000 0.008
R_VDD2_4581 METAL5_452000_4689000 METAL5_458000_4689000 0.024
R_VDD2_4582 METAL5_458000_4689000 METAL5_460000_4689000 0.008
R_VDD2_4583 METAL5_460000_4689000 METAL5_462000_4689000 0.008
R_VDD2_4584 METAL5_462000_4689000 METAL5_464000_4689000 0.008
R_VDD2_4585 METAL5_464000_4689000 METAL6_464000_4689000 0.1
R_VDD2_4586 METAL6_464000_4689000 METAL6_464000_4701000 0.024
R_VDD2_4587 METAL6_464000_4701000 METAL6_464000_4729000 0.056
R_VDD2_4588 METAL6_464000_4729000 METAL6_464000_4741000 0.024
R_VDD2_4589 METAL6_464000_4741000 METAL6_464000_4753000 0.024
R_VDD2_4590 METAL6_464000_4753000 METAL6_464000_4765000 0.024
R_VDD2_4591 METAL6_464000_4765000 METAL6_464000_4777000 0.024
R_VDD2_4592 METAL6_464000_4777000 METAL6_464000_4893000 0.232
R_VDD2_4593 METAL6_464000_4893000 METAL6_464000_4907000 0.028
R_VDD2_4594 METAL6_464000_4907000 METAL6_464000_5053000 0.292
R_VDD2_4595 METAL6_464000_5053000 METAL6_464000_5065000 0.024
R_VDD2_4596 METAL6_464000_5065000 METAL6_464000_5077000 0.024
R_VDD2_4597 METAL6_464000_5077000 METAL6_464000_5153000 0.152
R_VDD2_4598 METAL6_464000_5153000 METAL6_464000_5165000 0.024
R_VDD2_4599 METAL6_464000_5165000 METAL6_464000_5177000 0.024
R_VDD2_4600 METAL6_464000_5177000 METAL6_464000_5253000 0.152
R_VDD2_4601 METAL6_464000_5253000 METAL5_464000_5253000 0.1
R_VDD2_4602 METAL5_464000_5253000 METAL5_464000_5265000 0.048
R_VDD2_4603 METAL5_464000_5265000 METAL5_464000_5277000 0.048
R_VDD2_4604 METAL5_464000_5277000 METAL5_464000_5329000 0.208
R_VDD2_4605 METAL5_464000_5329000 METAL5_464000_5341000 0.048
R_VDD2_4606 METAL5_464000_5341000 METAL5_464000_5353000 0.048
R_VDD2_4607 METAL5_464000_5353000 METAL5_464000_5365000 0.048
R_VDD2_4608 METAL5_464000_5365000 METAL5_464000_5377000 0.048
R_VDD2_4609 METAL5_464000_5377000 METAL5_464000_5389000 0.048
R_VDD2_4610 METAL5_464000_5389000 METAL5_464000_5429000 0.16
R_VDD2_4611 METAL5_464000_5429000 METAL5_464000_5441000 0.048
R_VDD2_4612 METAL5_464000_5441000 METAL5_464000_5453000 0.048
R_VDD2_4613 METAL5_464000_5453000 METAL5_464000_5465000 0.048
R_VDD2_4614 METAL5_464000_5465000 METAL5_464000_5477000 0.048
R_VDD2_4615 METAL5_464000_5477000 METAL6_464000_5477000 0.1
R_VDD2_4616 METAL6_464000_5477000 METAL6_464000_5489000 0.024
R_VDD2_4617 METAL6_464000_5489000 METAL6_464000_5501000 0.024
R_VDD2_4618 METAL6_464000_5501000 METAL6_464000_5593000 0.184
R_VDD2_4619 METAL6_464000_5593000 METAL6_464000_5607000 0.028
R_VDD2_4620 METAL6_464000_5607000 METAL6_464000_5753000 0.292
R_VDD2_4621 METAL6_464000_5753000 METAL6_464000_5765000 0.024
R_VDD2_4622 METAL6_464000_5765000 METAL6_464000_5777000 0.024
R_VDD2_4623 METAL6_464000_5777000 METAL6_464000_5853000 0.152
R_VDD2_4624 METAL6_464000_5853000 METAL6_464000_5865000 0.024
R_VDD2_4625 METAL6_464000_5865000 METAL6_464000_5877000 0.024
R_VDD2_4626 METAL6_464000_5877000 METAL6_464000_5953000 0.152
R_VDD2_4627 METAL6_464000_5953000 METAL5_464000_5953000 0.1
R_VDD2_4628 METAL5_464000_5953000 METAL5_464000_5965000 0.048
R_VDD2_4629 METAL5_464000_5965000 METAL5_464000_5977000 0.048
R_VDD2_4630 METAL5_464000_5977000 METAL5_464000_6041000 0.256
R_VDD2_4631 METAL5_464000_6041000 METAL5_464000_6053000 0.048
R_VDD2_4632 METAL5_464000_6053000 METAL5_464000_6065000 0.048
R_VDD2_4633 METAL5_464000_6065000 METAL5_464000_6077000 0.048
R_VDD2_4634 METAL5_464000_6077000 METAL6_464000_6077000 0.1
R_VDD2_4635 METAL6_464000_6077000 METAL6_464000_6089000 0.024
R_VDD2_4636 METAL6_464000_6089000 METAL6_464000_6153000 0.128
R_VDD2_4637 METAL6_464000_6153000 METAL6_464000_6165000 0.024
R_VDD2_4638 METAL6_464000_6165000 METAL6_464000_6177000 0.024
R_VDD2_4639 METAL6_464000_6177000 METAL6_464000_6293000 0.232
R_VDD2_4640 METAL6_464000_6293000 METAL6_464000_6307000 0.028
R_VDD2_4641 METAL6_464000_6307000 METAL6_464000_6453000 0.292
R_VDD2_4642 METAL6_464000_6453000 METAL6_464000_6465000 0.024
R_VDD2_4643 METAL6_464000_6465000 METAL6_464000_6477000 0.024
R_VDD2_4644 METAL6_464000_6477000 METAL6_464000_6553000 0.152
R_VDD2_4645 METAL6_464000_6553000 METAL6_464000_6565000 0.024
R_VDD2_4646 METAL6_464000_6565000 METAL6_472000_6565000 0.016
R_VDD2_4647 METAL6_472000_6565000 METAL6_474000_6565000 0.004
R_VDD2_4648 METAL6_474000_6565000 METAL6_476000_6565000 0.004
R_VDD2_4649 METAL6_476000_6565000 METAL6_484000_6565000 0.016
R_VDD2_4650 METAL6_484000_6565000 METAL6_486000_6565000 0.004
R_VDD2_4651 METAL6_486000_6565000 METAL6_488000_6565000 0.004
R_VDD2_4652 METAL6_488000_6565000 METAL6_496000_6565000 0.016
R_VDD2_4653 METAL6_496000_6565000 METAL6_500000_6565000 0.008
R_VDD2_4654 METAL6_500000_6565000 METAL6_507000_6565000 0.014
R_VDD2_4655 METAL6_507000_6565000 METAL6_512000_6565000 0.01
R_VDD2_4656 METAL6_512000_6565000 METAL6_519000_6565000 0.014
R_VDD2_4657 METAL6_519000_6565000 METAL5_519000_6565000 0.1
R_VDD2_4658 METAL5_519000_6565000 METAL5_524000_6565000 0.02
R_VDD2_4659 METAL5_524000_6565000 METAL5_531000_6565000 0.028
R_VDD2_4660 METAL5_531000_6565000 METAL5_543000_6565000 0.048
R_VDD2_4661 METAL5_543000_6565000 METAL6_543000_6565000 0.1
R_VDD2_4662 METAL6_555000_6565000 METAL6_543000_6565000 0.024
R_VDD2_4663 METAL6_245000_6565000 METAL6_257000_6565000 0.024
R_VDD2_4664 METAL5_476000_4207000 METAL5_474000_4207000 0.008
R_VDD2_4665 METAL5_474000_4207000 METAL5_472000_4207000 0.008
R_VDD2_4666 METAL5_472000_4207000 METAL5_464000_4207000 0.032
R_VDD2_4667 METAL5_464000_4207000 METAL5_464000_4341000 0.536
R_VDD2_4668 METAL5_464000_4341000 METAL5_464000_4353000 0.048
R_VDD2_4669 METAL5_464000_4353000 METAL5_464000_4365000 0.048
R_VDD2_4670 METAL5_464000_4365000 METAL5_464000_4377000 0.048
R_VDD2_4671 METAL5_464000_4377000 METAL5_464000_4389000 0.048
R_VDD2_4672 METAL5_464000_4389000 METAL5_464000_4453000 0.256
R_VDD2_4673 METAL5_464000_4453000 METAL5_464000_4465000 0.048
R_VDD2_4674 METAL5_464000_4465000 METAL5_464000_4477000 0.048
R_VDD2_4675 METAL5_464000_4477000 METAL5_464000_4489000 0.048
R_VDD2_4676 METAL5_464000_4489000 METAL5_464000_4553000 0.256
R_VDD2_4677 METAL5_464000_4553000 METAL5_464000_4565000 0.048
R_VDD2_4678 METAL5_464000_4565000 METAL5_464000_4577000 0.048
R_VDD2_4679 METAL5_464000_4577000 METAL5_464000_4617000 0.16
R_VDD2_4680 METAL5_464000_4617000 METAL5_464000_4629000 0.048
R_VDD2_4681 METAL5_464000_4629000 METAL5_462000_4629000 0.008
R_VDD2_4682 METAL5_462000_4629000 METAL5_460000_4629000 0.008
R_VDD2_4683 METAL5_460000_4629000 METAL5_458000_4629000 0.008
R_VDD2_4684 METAL5_458000_4629000 METAL5_452000_4629000 0.024
R_VDD2_4685 METAL5_452000_4629000 METAL5_450000_4629000 0.008
R_VDD2_4686 METAL5_450000_4629000 METAL5_448000_4629000 0.008
R_VDD2_4687 METAL5_448000_4629000 METAL5_446000_4629000 0.008
R_VDD2_4688 METAL5_446000_4629000 METAL5_440000_4629000 0.024
R_VDD2_4689 METAL5_440000_4629000 METAL5_438000_4629000 0.008
R_VDD2_4690 METAL5_438000_4629000 METAL5_436000_4629000 0.008
R_VDD2_4691 METAL5_436000_4629000 METAL5_434000_4629000 0.008
R_VDD2_4692 METAL5_434000_4629000 METAL5_428000_4629000 0.024
R_VDD2_4693 METAL5_428000_4629000 METAL5_428000_4641000 0.048
R_VDD2_4694 METAL5_428000_4641000 METAL5_428000_4653000 0.048
R_VDD2_4695 METAL5_428000_4653000 METAL5_428000_4665000 0.048
R_VDD2_4696 METAL5_428000_4665000 METAL5_428000_4677000 0.048
R_VDD2_4697 METAL5_428000_4677000 METAL5_428000_4689000 0.048
R_VDD2_4698 METAL5_428000_4689000 METAL5_428000_4701000 0.048
R_VDD2_4699 METAL5_428000_4701000 METAL5_428000_4729000 0.112
R_VDD2_4700 METAL5_428000_4729000 METAL5_428000_4741000 0.048
R_VDD2_4701 METAL5_428000_4741000 METAL5_428000_4753000 0.048
R_VDD2_4702 METAL5_428000_4753000 METAL5_434000_4753000 0.024
R_VDD2_4703 METAL5_434000_4753000 METAL5_436000_4753000 0.008
R_VDD2_4704 METAL5_436000_4753000 METAL5_438000_4753000 0.008
R_VDD2_4705 METAL5_438000_4753000 METAL5_440000_4753000 0.008
R_VDD2_4706 METAL5_440000_4753000 METAL5_446000_4753000 0.024
R_VDD2_4707 METAL5_446000_4753000 METAL5_448000_4753000 0.008
R_VDD2_4708 METAL5_448000_4753000 METAL5_450000_4753000 0.008
R_VDD2_4709 METAL5_450000_4753000 METAL5_452000_4753000 0.008
R_VDD2_4710 METAL5_452000_4753000 METAL5_458000_4753000 0.024
R_VDD2_4711 METAL5_458000_4753000 METAL5_460000_4753000 0.008
R_VDD2_4712 METAL5_460000_4753000 METAL5_462000_4753000 0.008
R_VDD2_4713 METAL5_462000_4753000 METAL5_464000_4753000 0.008
R_VDD2_4714 METAL5_464000_4753000 METAL5_472000_4753000 0.032
R_VDD2_4715 METAL5_472000_4753000 METAL5_474000_4753000 0.008
R_VDD2_4716 METAL5_474000_4753000 METAL5_476000_4753000 0.008
R_VDD2_4717 METAL5_476000_4753000 METAL6_476000_4753000 0.1
R_VDD2_4718 METAL6_476000_4753000 METAL6_476000_4765000 0.024
R_VDD2_4719 METAL6_476000_4765000 METAL6_476000_4777000 0.024
R_VDD2_4720 METAL6_476000_4777000 METAL6_476000_4893000 0.232
R_VDD2_4721 METAL6_476000_4893000 METAL6_476000_4907000 0.028
R_VDD2_4722 METAL6_476000_4907000 METAL6_476000_5053000 0.292
R_VDD2_4723 METAL6_476000_5053000 METAL6_476000_5065000 0.024
R_VDD2_4724 METAL6_476000_5065000 METAL6_476000_5077000 0.024
R_VDD2_4725 METAL6_476000_5077000 METAL6_476000_5153000 0.152
R_VDD2_4726 METAL6_476000_5153000 METAL6_476000_5165000 0.024
R_VDD2_4727 METAL6_476000_5165000 METAL6_476000_5177000 0.024
R_VDD2_4728 METAL6_476000_5177000 METAL6_476000_5241000 0.128
R_VDD2_4729 METAL6_476000_5241000 METAL5_476000_5241000 0.1
R_VDD2_4730 METAL5_476000_5241000 METAL5_474000_5241000 0.008
R_VDD2_4731 METAL5_474000_5241000 METAL5_472000_5241000 0.008
R_VDD2_4732 METAL5_472000_5241000 METAL5_464000_5241000 0.032
R_VDD2_4733 METAL5_464000_5241000 METAL5_462000_5241000 0.008
R_VDD2_4734 METAL5_462000_5241000 METAL5_460000_5241000 0.008
R_VDD2_4735 METAL5_460000_5241000 METAL5_458000_5241000 0.008
R_VDD2_4736 METAL5_458000_5241000 METAL5_452000_5241000 0.024
R_VDD2_4737 METAL5_452000_5241000 METAL5_452000_5253000 0.048
R_VDD2_4738 METAL5_452000_5253000 METAL5_452000_5265000 0.048
R_VDD2_4739 METAL5_452000_5265000 METAL5_452000_5277000 0.048
R_VDD2_4740 METAL5_452000_5277000 METAL5_452000_5329000 0.208
R_VDD2_4741 METAL5_452000_5329000 METAL5_452000_5341000 0.048
R_VDD2_4742 METAL5_452000_5341000 METAL5_452000_5353000 0.048
R_VDD2_4743 METAL5_452000_5353000 METAL5_452000_5365000 0.048
R_VDD2_4744 METAL5_452000_5365000 METAL5_452000_5377000 0.048
R_VDD2_4745 METAL5_452000_5377000 METAL6_452000_5377000 0.1
R_VDD2_4746 METAL6_452000_5377000 METAL6_452000_5389000 0.024
R_VDD2_4747 METAL6_452000_5389000 METAL6_452000_5429000 0.08
R_VDD2_4748 METAL6_452000_5429000 METAL6_452000_5441000 0.024
R_VDD2_4749 METAL6_452000_5441000 METAL6_452000_5453000 0.024
R_VDD2_4750 METAL6_452000_5453000 METAL6_450000_5453000 0.004
R_VDD2_4751 METAL6_450000_5453000 METAL6_448000_5453000 0.004
R_VDD2_4752 METAL6_448000_5453000 METAL6_446000_5453000 0.004
R_VDD2_4753 METAL6_446000_5453000 METAL6_440000_5453000 0.012
R_VDD2_4754 METAL6_440000_5453000 METAL6_438000_5453000 0.004
R_VDD2_4755 METAL6_438000_5453000 METAL6_436000_5453000 0.004
R_VDD2_4756 METAL6_436000_5453000 METAL6_434000_5453000 0.004
R_VDD2_4757 METAL6_434000_5453000 METAL6_428000_5453000 0.012
R_VDD2_4758 METAL6_428000_5453000 METAL6_426000_5453000 0.004
R_VDD2_4759 METAL6_426000_5453000 METAL6_424000_5453000 0.004
R_VDD2_4760 METAL6_424000_5453000 METAL6_422000_5453000 0.004
R_VDD2_4761 METAL6_422000_5453000 METAL5_422000_5453000 0.1
R_VDD2_4762 METAL5_422000_5453000 METAL5_422000_5465000 0.048
R_VDD2_4763 METAL5_422000_5465000 METAL5_422000_5477000 0.048
R_VDD2_4764 METAL5_422000_5477000 METAL6_422000_5477000 0.1
R_VDD2_4765 METAL6_422000_5477000 METAL6_422000_5489000 0.024
R_VDD2_4766 METAL6_422000_5489000 METAL6_422000_5501000 0.024
R_VDD2_4767 METAL6_422000_5501000 METAL6_422000_5593000 0.184
R_VDD2_4768 METAL6_422000_5593000 METAL6_422000_5607000 0.028
R_VDD2_4769 METAL6_422000_5607000 METAL6_422000_5753000 0.292
R_VDD2_4770 METAL6_422000_5753000 METAL6_422000_5765000 0.024
R_VDD2_4771 METAL6_422000_5765000 METAL6_422000_5777000 0.024
R_VDD2_4772 METAL6_422000_5777000 METAL6_422000_5853000 0.152
R_VDD2_4773 METAL6_422000_5853000 METAL6_422000_5865000 0.024
R_VDD2_4774 METAL6_422000_5865000 METAL6_422000_5877000 0.024
R_VDD2_4775 METAL6_422000_5877000 METAL6_422000_5941000 0.128
R_VDD2_4776 METAL6_422000_5941000 METAL6_422000_5953000 0.024
R_VDD2_4777 METAL6_422000_5953000 METAL6_422000_5965000 0.024
R_VDD2_4778 METAL6_422000_5965000 METAL6_422000_5977000 0.024
R_VDD2_4779 METAL6_422000_5977000 METAL6_422000_6041000 0.128
R_VDD2_4780 METAL6_422000_6041000 METAL6_422000_6053000 0.024
R_VDD2_4781 METAL6_422000_6053000 METAL5_422000_6053000 0.1
R_VDD2_4782 METAL5_422000_6053000 METAL5_422000_6065000 0.048
R_VDD2_4783 METAL5_422000_6065000 METAL5_422000_6077000 0.048
R_VDD2_4784 METAL5_422000_6077000 METAL5_420000_6077000 0.008
R_VDD2_4785 METAL5_420000_6077000 METAL5_414000_6077000 0.024
R_VDD2_4786 METAL5_414000_6077000 METAL5_412000_6077000 0.008
R_VDD2_4787 METAL5_412000_6077000 METAL5_410000_6077000 0.008
R_VDD2_4788 METAL5_410000_6077000 METAL5_408000_6077000 0.008
R_VDD2_4789 METAL5_408000_6077000 METAL5_402000_6077000 0.024
R_VDD2_4790 METAL5_402000_6077000 METAL5_400000_6077000 0.008
R_VDD2_4791 METAL5_400000_6077000 METAL5_398000_6077000 0.008
R_VDD2_4792 METAL5_398000_6077000 METAL5_396000_6077000 0.008
R_VDD2_4793 METAL5_396000_6077000 METAL5_390000_6077000 0.024
R_VDD2_4794 METAL5_390000_6077000 METAL5_388000_6077000 0.008
R_VDD2_4795 METAL5_388000_6077000 METAL5_386000_6077000 0.008
R_VDD2_4796 METAL5_386000_6077000 METAL5_384000_6077000 0.008
R_VDD2_4797 METAL5_384000_6077000 METAL5_378000_6077000 0.024
R_VDD2_4798 METAL5_378000_6077000 METAL5_376000_6077000 0.008
R_VDD2_4799 METAL5_376000_6077000 METAL5_374000_6077000 0.008
R_VDD2_4800 METAL5_374000_6077000 METAL5_372000_6077000 0.008
R_VDD2_4801 METAL5_372000_6077000 METAL5_366000_6077000 0.024
R_VDD2_4802 METAL5_366000_6077000 METAL5_364000_6077000 0.008
R_VDD2_4803 METAL5_364000_6077000 METAL5_362000_6077000 0.008
R_VDD2_4804 METAL5_362000_6077000 METAL6_362000_6077000 0.1
R_VDD2_4805 METAL6_362000_6077000 METAL6_362000_6089000 0.024
R_VDD2_4806 METAL6_362000_6089000 METAL6_362000_6153000 0.128
R_VDD2_4807 METAL6_362000_6153000 METAL6_362000_6165000 0.024
R_VDD2_4808 METAL6_362000_6165000 METAL6_362000_6177000 0.024
R_VDD2_4809 METAL6_362000_6177000 METAL6_362000_6293000 0.232
R_VDD2_4810 METAL6_362000_6293000 METAL6_362000_6307000 0.028
R_VDD2_4811 METAL6_362000_6307000 METAL6_362000_6453000 0.292
R_VDD2_4812 METAL6_362000_6453000 METAL6_362000_6465000 0.024
R_VDD2_4813 METAL6_362000_6465000 METAL6_362000_6477000 0.024
R_VDD2_4814 METAL6_362000_6477000 METAL6_362000_6553000 0.152
R_VDD2_4815 METAL6_362000_6553000 METAL6_362000_6565000 0.024
R_VDD2_4816 METAL6_362000_6565000 METAL6_360000_6565000 0.004
R_VDD2_4817 METAL6_360000_6565000 METAL6_354000_6565000 0.012
R_VDD2_4818 METAL6_354000_6565000 METAL6_352000_6565000 0.004
R_VDD2_4819 METAL6_352000_6565000 METAL6_350000_6565000 0.004
R_VDD2_4820 METAL6_350000_6565000 METAL6_348000_6565000 0.004
R_VDD2_4821 METAL6_348000_6565000 METAL6_342000_6565000 0.012
R_VDD2_4822 METAL6_342000_6565000 METAL6_340000_6565000 0.004
R_VDD2_4823 METAL6_340000_6565000 METAL6_338000_6565000 0.004
R_VDD2_4824 METAL6_338000_6565000 METAL6_336000_6565000 0.004
R_VDD2_4825 METAL6_336000_6565000 METAL5_336000_6565000 0.1
R_VDD2_4826 METAL5_336000_6565000 METAL5_330000_6565000 0.024
R_VDD2_4827 METAL5_330000_6565000 METAL5_328000_6565000 0.008
R_VDD2_4828 METAL5_328000_6565000 METAL5_326000_6565000 0.008
R_VDD2_4829 METAL5_326000_6565000 METAL5_324000_6565000 0.008
R_VDD2_4830 METAL5_324000_6565000 METAL5_318000_6565000 0.024
R_VDD2_4831 METAL5_318000_6565000 METAL5_316000_6565000 0.008
R_VDD2_4832 METAL5_316000_6565000 METAL5_314000_6565000 0.008
R_VDD2_4833 METAL5_314000_6565000 METAL5_312000_6565000 0.008
R_VDD2_4834 METAL5_312000_6565000 METAL5_306000_6565000 0.024
R_VDD2_4835 METAL5_306000_6565000 METAL5_305000_6565000 0.004
R_VDD2_4836 METAL5_305000_6565000 METAL5_302000_6565000 0.012
R_VDD2_4837 METAL5_302000_6565000 METAL5_300000_6565000 0.008
R_VDD2_4838 METAL5_300000_6565000 METAL5_294000_6565000 0.024
R_VDD2_4839 METAL5_294000_6565000 METAL5_293000_6565000 0.004
R_VDD2_4840 METAL5_293000_6565000 METAL5_290000_6565000 0.012
R_VDD2_4841 METAL5_290000_6565000 METAL5_288000_6565000 0.008
R_VDD2_4842 METAL5_288000_6565000 METAL5_282000_6565000 0.024
R_VDD2_4843 METAL5_282000_6565000 METAL5_281000_6565000 0.004
R_VDD2_4844 METAL5_281000_6565000 METAL5_278000_6565000 0.012
R_VDD2_4845 METAL5_278000_6565000 METAL5_276000_6565000 0.008
R_VDD2_4846 METAL5_276000_6565000 METAL5_270000_6565000 0.024
R_VDD2_4847 METAL5_270000_6565000 METAL5_269000_6565000 0.004
R_VDD2_4848 METAL5_269000_6565000 METAL5_266000_6565000 0.012
R_VDD2_4849 METAL5_266000_6565000 METAL5_264000_6565000 0.008
R_VDD2_4850 METAL5_264000_6565000 METAL5_258000_6565000 0.024
R_VDD2_4851 METAL5_258000_6565000 METAL5_257000_6565000 0.004
R_VDD2_4852 METAL5_257000_6565000 METAL6_257000_6565000 0.1
R_VDD2_4853 METAL6_555000_5865000 METAL6_543000_5865000 0.024
R_VDD2_4854 METAL6_464000_5607000 METAL6_472000_5607000 0.016
R_VDD2_4855 METAL6_472000_5607000 METAL6_474000_5607000 0.004
R_VDD2_4856 METAL6_474000_5607000 METAL6_476000_5607000 0.004
R_VDD2_4857 METAL6_476000_5607000 METAL6_476000_5753000 0.292
R_VDD2_4858 METAL6_476000_5753000 METAL6_476000_5765000 0.024
R_VDD2_4859 METAL6_476000_5765000 METAL6_476000_5777000 0.024
R_VDD2_4860 METAL6_476000_5777000 METAL6_476000_5853000 0.152
R_VDD2_4861 METAL6_476000_5853000 METAL6_476000_5865000 0.024
R_VDD2_4862 METAL6_476000_5865000 METAL6_484000_5865000 0.016
R_VDD2_4863 METAL6_484000_5865000 METAL6_486000_5865000 0.004
R_VDD2_4864 METAL6_486000_5865000 METAL6_488000_5865000 0.004
R_VDD2_4865 METAL6_488000_5865000 METAL6_496000_5865000 0.016
R_VDD2_4866 METAL6_496000_5865000 METAL6_500000_5865000 0.008
R_VDD2_4867 METAL6_500000_5865000 METAL5_500000_5865000 0.1
R_VDD2_4868 METAL5_500000_5865000 METAL5_507000_5865000 0.028
R_VDD2_4869 METAL5_507000_5865000 METAL5_512000_5865000 0.02
R_VDD2_4870 METAL5_512000_5865000 METAL5_519000_5865000 0.028
R_VDD2_4871 METAL5_519000_5865000 METAL5_524000_5865000 0.02
R_VDD2_4872 METAL5_524000_5865000 METAL5_531000_5865000 0.028
R_VDD2_4873 METAL5_531000_5865000 METAL5_543000_5865000 0.048
R_VDD2_4874 METAL5_543000_5865000 METAL6_543000_5865000 0.1
R_VDD2_4875 METAL6_245000_5865000 METAL6_257000_5865000 0.024
R_VDD2_4876 METAL6_422000_5593000 METAL5_422000_5593000 0.1
R_VDD2_4877 METAL5_422000_5593000 METAL5_420000_5593000 0.008
R_VDD2_4878 METAL5_420000_5593000 METAL5_416000_5593000 0.016
R_VDD2_4879 METAL5_416000_5593000 METAL5_414000_5593000 0.008
R_VDD2_4880 METAL5_414000_5593000 METAL5_412000_5593000 0.008
R_VDD2_4881 METAL5_412000_5593000 METAL5_410000_5593000 0.008
R_VDD2_4882 METAL5_410000_5593000 METAL5_408000_5593000 0.008
R_VDD2_4883 METAL5_408000_5593000 METAL5_402000_5593000 0.024
R_VDD2_4884 METAL5_402000_5593000 METAL5_400000_5593000 0.008
R_VDD2_4885 METAL5_400000_5593000 METAL5_398000_5593000 0.008
R_VDD2_4886 METAL5_398000_5593000 METAL5_396000_5593000 0.008
R_VDD2_4887 METAL5_396000_5593000 METAL5_390000_5593000 0.024
R_VDD2_4888 METAL5_390000_5593000 METAL5_388000_5593000 0.008
R_VDD2_4889 METAL5_388000_5593000 METAL5_386000_5593000 0.008
R_VDD2_4890 METAL5_386000_5593000 METAL5_384000_5593000 0.008
R_VDD2_4891 METAL5_384000_5593000 METAL5_378000_5593000 0.024
R_VDD2_4892 METAL5_378000_5593000 METAL5_376000_5593000 0.008
R_VDD2_4893 METAL5_376000_5593000 METAL5_374000_5593000 0.008
R_VDD2_4894 METAL5_374000_5593000 METAL5_372000_5593000 0.008
R_VDD2_4895 METAL5_372000_5593000 METAL5_366000_5593000 0.024
R_VDD2_4896 METAL5_366000_5593000 METAL5_364000_5593000 0.008
R_VDD2_4897 METAL5_364000_5593000 METAL5_362000_5593000 0.008
R_VDD2_4898 METAL5_362000_5593000 METAL5_360000_5593000 0.008
R_VDD2_4899 METAL5_360000_5593000 METAL5_354000_5593000 0.024
R_VDD2_4900 METAL5_354000_5593000 METAL5_352000_5593000 0.008
R_VDD2_4901 METAL5_352000_5593000 METAL5_350000_5593000 0.008
R_VDD2_4902 METAL5_350000_5593000 METAL6_350000_5593000 0.1
R_VDD2_4903 METAL6_350000_5593000 METAL6_350000_5595000 0.004
R_VDD2_4904 METAL6_350000_5595000 METAL6_350000_5607000 0.024
R_VDD2_4905 METAL6_350000_5607000 METAL6_350000_5619000 0.024
R_VDD2_4906 METAL6_350000_5619000 METAL6_350000_5753000 0.268
R_VDD2_4907 METAL6_350000_5753000 METAL6_350000_5765000 0.024
R_VDD2_4908 METAL6_350000_5765000 METAL6_350000_5777000 0.024
R_VDD2_4909 METAL6_350000_5777000 METAL6_350000_5853000 0.152
R_VDD2_4910 METAL6_350000_5853000 METAL6_350000_5865000 0.024
R_VDD2_4911 METAL6_350000_5865000 METAL6_348000_5865000 0.004
R_VDD2_4912 METAL6_348000_5865000 METAL6_342000_5865000 0.012
R_VDD2_4913 METAL6_342000_5865000 METAL6_340000_5865000 0.004
R_VDD2_4914 METAL6_340000_5865000 METAL6_338000_5865000 0.004
R_VDD2_4915 METAL6_338000_5865000 METAL6_336000_5865000 0.004
R_VDD2_4916 METAL6_336000_5865000 METAL5_336000_5865000 0.1
R_VDD2_4917 METAL5_336000_5865000 METAL5_330000_5865000 0.024
R_VDD2_4918 METAL5_330000_5865000 METAL5_328000_5865000 0.008
R_VDD2_4919 METAL5_328000_5865000 METAL5_326000_5865000 0.008
R_VDD2_4920 METAL5_326000_5865000 METAL5_324000_5865000 0.008
R_VDD2_4921 METAL5_324000_5865000 METAL5_318000_5865000 0.024
R_VDD2_4922 METAL5_318000_5865000 METAL5_316000_5865000 0.008
R_VDD2_4923 METAL5_316000_5865000 METAL5_314000_5865000 0.008
R_VDD2_4924 METAL5_314000_5865000 METAL5_312000_5865000 0.008
R_VDD2_4925 METAL5_312000_5865000 METAL5_306000_5865000 0.024
R_VDD2_4926 METAL5_306000_5865000 METAL5_305000_5865000 0.004
R_VDD2_4927 METAL5_305000_5865000 METAL5_302000_5865000 0.012
R_VDD2_4928 METAL5_302000_5865000 METAL5_300000_5865000 0.008
R_VDD2_4929 METAL5_300000_5865000 METAL5_294000_5865000 0.024
R_VDD2_4930 METAL5_294000_5865000 METAL5_293000_5865000 0.004
R_VDD2_4931 METAL5_293000_5865000 METAL5_290000_5865000 0.012
R_VDD2_4932 METAL5_290000_5865000 METAL5_288000_5865000 0.008
R_VDD2_4933 METAL5_288000_5865000 METAL5_282000_5865000 0.024
R_VDD2_4934 METAL5_282000_5865000 METAL5_281000_5865000 0.004
R_VDD2_4935 METAL5_281000_5865000 METAL5_278000_5865000 0.012
R_VDD2_4936 METAL5_278000_5865000 METAL5_276000_5865000 0.008
R_VDD2_4937 METAL5_276000_5865000 METAL5_270000_5865000 0.024
R_VDD2_4938 METAL5_270000_5865000 METAL5_269000_5865000 0.004
R_VDD2_4939 METAL5_269000_5865000 METAL5_266000_5865000 0.012
R_VDD2_4940 METAL5_266000_5865000 METAL5_264000_5865000 0.008
R_VDD2_4941 METAL5_264000_5865000 METAL5_258000_5865000 0.024
R_VDD2_4942 METAL5_258000_5865000 METAL5_257000_5865000 0.004
R_VDD2_4943 METAL5_257000_5865000 METAL6_257000_5865000 0.1
R_VDD2_4944 METAL6_555000_5165000 METAL6_543000_5165000 0.024
R_VDD2_4945 METAL5_476000_4207000 METAL5_484000_4207000 0.032
R_VDD2_4946 METAL5_484000_4207000 METAL5_486000_4207000 0.008
R_VDD2_4947 METAL5_486000_4207000 METAL5_488000_4207000 0.008
R_VDD2_4948 METAL5_488000_4207000 METAL5_488000_4205000 0.008
R_VDD2_4949 METAL5_488000_4205000 METAL5_488000_4195000 0.04
R_VDD2_4950 METAL5_488000_4195000 METAL5_488000_4193000 0.008
R_VDD2_4951 METAL5_488000_4193000 METAL5_488000_4181000 0.048
R_VDD2_4952 METAL5_488000_4181000 METAL5_488000_4169000 0.048
R_VDD2_4953 METAL5_488000_4169000 METAL5_486000_4169000 0.008
R_VDD2_4954 METAL5_486000_4169000 METAL5_484000_4169000 0.008
R_VDD2_4955 METAL5_484000_4169000 METAL5_476000_4169000 0.032
R_VDD2_4956 METAL5_476000_4169000 METAL5_474000_4169000 0.008
R_VDD2_4957 METAL5_474000_4169000 METAL5_472000_4169000 0.008
R_VDD2_4958 METAL5_472000_4169000 METAL5_464000_4169000 0.032
R_VDD2_4959 METAL5_464000_4169000 METAL5_462000_4169000 0.008
R_VDD2_4960 METAL5_462000_4169000 METAL5_460000_4169000 0.008
R_VDD2_4961 METAL5_460000_4169000 METAL5_458000_4169000 0.008
R_VDD2_4962 METAL5_458000_4169000 METAL5_452000_4169000 0.024
R_VDD2_4963 METAL5_452000_4169000 METAL5_452000_4181000 0.048
R_VDD2_4964 METAL5_452000_4181000 METAL5_450000_4181000 0.008
R_VDD2_4965 METAL5_450000_4181000 METAL5_448000_4181000 0.008
R_VDD2_4966 METAL5_448000_4181000 METAL5_446000_4181000 0.008
R_VDD2_4967 METAL5_446000_4181000 METAL5_440000_4181000 0.024
R_VDD2_4968 METAL5_440000_4181000 METAL5_438000_4181000 0.008
R_VDD2_4969 METAL5_438000_4181000 METAL5_436000_4181000 0.008
R_VDD2_4970 METAL5_436000_4181000 METAL5_434000_4181000 0.008
R_VDD2_4971 METAL5_434000_4181000 METAL5_428000_4181000 0.024
R_VDD2_4972 METAL5_428000_4181000 METAL5_426000_4181000 0.008
R_VDD2_4973 METAL5_426000_4181000 METAL5_424000_4181000 0.008
R_VDD2_4974 METAL5_424000_4181000 METAL5_422000_4181000 0.008
R_VDD2_4975 METAL5_422000_4181000 METAL5_420000_4181000 0.008
R_VDD2_4976 METAL5_420000_4181000 METAL5_416000_4181000 0.016
R_VDD2_4977 METAL5_416000_4181000 METAL5_414000_4181000 0.008
R_VDD2_4978 METAL5_414000_4181000 METAL5_412000_4181000 0.008
R_VDD2_4979 METAL5_412000_4181000 METAL5_410000_4181000 0.008
R_VDD2_4980 METAL5_410000_4181000 METAL5_408000_4181000 0.008
R_VDD2_4981 METAL5_408000_4181000 METAL5_402000_4181000 0.024
R_VDD2_4982 METAL5_402000_4181000 METAL5_400000_4181000 0.008
R_VDD2_4983 METAL5_400000_4181000 METAL5_398000_4181000 0.008
R_VDD2_4984 METAL5_398000_4181000 METAL5_396000_4181000 0.008
R_VDD2_4985 METAL5_396000_4181000 METAL5_390000_4181000 0.024
R_VDD2_4986 METAL5_390000_4181000 METAL5_388000_4181000 0.008
R_VDD2_4987 METAL5_388000_4181000 METAL5_386000_4181000 0.008
R_VDD2_4988 METAL5_386000_4181000 METAL5_384000_4181000 0.008
R_VDD2_4989 METAL5_384000_4181000 METAL5_378000_4181000 0.024
R_VDD2_4990 METAL5_378000_4181000 METAL5_376000_4181000 0.008
R_VDD2_4991 METAL5_376000_4181000 METAL5_374000_4181000 0.008
R_VDD2_4992 METAL5_374000_4181000 METAL5_372000_4181000 0.008
R_VDD2_4993 METAL5_372000_4181000 METAL5_366000_4181000 0.024
R_VDD2_4994 METAL5_366000_4181000 METAL5_364000_4181000 0.008
R_VDD2_4995 METAL5_364000_4181000 METAL5_362000_4181000 0.008
R_VDD2_4996 METAL5_362000_4181000 METAL5_360000_4181000 0.008
R_VDD2_4997 METAL5_360000_4181000 METAL5_354000_4181000 0.024
R_VDD2_4998 METAL5_354000_4181000 METAL5_352000_4181000 0.008
R_VDD2_4999 METAL5_352000_4181000 METAL5_350000_4181000 0.008
R_VDD2_5000 METAL5_350000_4181000 METAL5_348000_4181000 0.008
R_VDD2_5001 METAL5_348000_4181000 METAL5_342000_4181000 0.024
R_VDD2_5002 METAL5_342000_4181000 METAL5_340000_4181000 0.008
R_VDD2_5003 METAL5_340000_4181000 METAL5_338000_4181000 0.008
R_VDD2_5004 METAL5_338000_4181000 METAL5_336000_4181000 0.008
R_VDD2_5005 METAL5_336000_4181000 METAL5_330000_4181000 0.024
R_VDD2_5006 METAL5_330000_4181000 METAL5_328000_4181000 0.008
R_VDD2_5007 METAL5_328000_4181000 METAL5_326000_4181000 0.008
R_VDD2_5008 METAL5_326000_4181000 METAL5_324000_4181000 0.008
R_VDD2_5009 METAL5_324000_4181000 METAL5_324000_4193000 0.048
R_VDD2_5010 METAL5_324000_4193000 METAL5_324000_4195000 0.008
R_VDD2_5011 METAL5_324000_4195000 METAL5_324000_4205000 0.04
R_VDD2_5012 METAL5_324000_4205000 METAL5_324000_4207000 0.008
R_VDD2_5013 METAL5_324000_4207000 METAL5_324000_4219000 0.048
R_VDD2_5014 METAL5_324000_4219000 METAL5_324000_4341000 0.488
R_VDD2_5015 METAL5_324000_4341000 METAL5_326000_4341000 0.008
R_VDD2_5016 METAL5_326000_4341000 METAL5_328000_4341000 0.008
R_VDD2_5017 METAL5_328000_4341000 METAL5_330000_4341000 0.008
R_VDD2_5018 METAL5_330000_4341000 METAL5_336000_4341000 0.024
R_VDD2_5019 METAL5_336000_4341000 METAL5_336000_4353000 0.048
R_VDD2_5020 METAL5_336000_4353000 METAL5_336000_4365000 0.048
R_VDD2_5021 METAL5_336000_4365000 METAL5_336000_4377000 0.048
R_VDD2_5022 METAL5_336000_4377000 METAL5_336000_4389000 0.048
R_VDD2_5023 METAL5_336000_4389000 METAL5_336000_4453000 0.256
R_VDD2_5024 METAL5_336000_4453000 METAL5_336000_4465000 0.048
R_VDD2_5025 METAL5_336000_4465000 METAL5_336000_4477000 0.048
R_VDD2_5026 METAL5_336000_4477000 METAL5_336000_4489000 0.048
R_VDD2_5027 METAL5_336000_4489000 METAL5_336000_4553000 0.256
R_VDD2_5028 METAL5_336000_4553000 METAL5_336000_4565000 0.048
R_VDD2_5029 METAL5_336000_4565000 METAL5_336000_4577000 0.048
R_VDD2_5030 METAL5_336000_4577000 METAL5_336000_4617000 0.16
R_VDD2_5031 METAL5_336000_4617000 METAL5_338000_4617000 0.008
R_VDD2_5032 METAL5_338000_4617000 METAL5_340000_4617000 0.008
R_VDD2_5033 METAL5_340000_4617000 METAL5_342000_4617000 0.008
R_VDD2_5034 METAL5_342000_4617000 METAL5_348000_4617000 0.024
R_VDD2_5035 METAL5_348000_4617000 METAL5_350000_4617000 0.008
R_VDD2_5036 METAL5_350000_4617000 METAL5_352000_4617000 0.008
R_VDD2_5037 METAL5_352000_4617000 METAL5_354000_4617000 0.008
R_VDD2_5038 METAL5_354000_4617000 METAL5_360000_4617000 0.024
R_VDD2_5039 METAL5_360000_4617000 METAL5_362000_4617000 0.008
R_VDD2_5040 METAL5_362000_4617000 METAL5_364000_4617000 0.008
R_VDD2_5041 METAL5_364000_4617000 METAL5_366000_4617000 0.008
R_VDD2_5042 METAL5_366000_4617000 METAL5_372000_4617000 0.024
R_VDD2_5043 METAL5_372000_4617000 METAL5_372000_4629000 0.048
R_VDD2_5044 METAL5_372000_4629000 METAL5_372000_4641000 0.048
R_VDD2_5045 METAL5_372000_4641000 METAL5_372000_4653000 0.048
R_VDD2_5046 METAL5_372000_4653000 METAL5_372000_4665000 0.048
R_VDD2_5047 METAL5_372000_4665000 METAL5_372000_4677000 0.048
R_VDD2_5048 METAL5_372000_4677000 METAL5_372000_4689000 0.048
R_VDD2_5049 METAL5_372000_4689000 METAL5_372000_4701000 0.048
R_VDD2_5050 METAL5_372000_4701000 METAL5_372000_4729000 0.112
R_VDD2_5051 METAL5_372000_4729000 METAL5_372000_4741000 0.048
R_VDD2_5052 METAL5_372000_4741000 METAL5_372000_4753000 0.048
R_VDD2_5053 METAL5_372000_4753000 METAL5_372000_4765000 0.048
R_VDD2_5054 METAL5_372000_4765000 METAL5_372000_4777000 0.048
R_VDD2_5055 METAL5_372000_4777000 METAL5_374000_4777000 0.008
R_VDD2_5056 METAL5_374000_4777000 METAL5_376000_4777000 0.008
R_VDD2_5057 METAL5_376000_4777000 METAL5_378000_4777000 0.008
R_VDD2_5058 METAL5_378000_4777000 METAL5_384000_4777000 0.024
R_VDD2_5059 METAL5_384000_4777000 METAL5_386000_4777000 0.008
R_VDD2_5060 METAL5_386000_4777000 METAL5_388000_4777000 0.008
R_VDD2_5061 METAL5_388000_4777000 METAL5_390000_4777000 0.008
R_VDD2_5062 METAL5_390000_4777000 METAL5_396000_4777000 0.024
R_VDD2_5063 METAL5_396000_4777000 METAL5_398000_4777000 0.008
R_VDD2_5064 METAL5_398000_4777000 METAL5_400000_4777000 0.008
R_VDD2_5065 METAL5_400000_4777000 METAL5_402000_4777000 0.008
R_VDD2_5066 METAL5_402000_4777000 METAL5_408000_4777000 0.024
R_VDD2_5067 METAL5_408000_4777000 METAL5_410000_4777000 0.008
R_VDD2_5068 METAL5_410000_4777000 METAL5_412000_4777000 0.008
R_VDD2_5069 METAL5_412000_4777000 METAL5_414000_4777000 0.008
R_VDD2_5070 METAL5_414000_4777000 METAL5_416000_4777000 0.008
R_VDD2_5071 METAL5_416000_4777000 METAL5_420000_4777000 0.016
R_VDD2_5072 METAL5_420000_4777000 METAL5_422000_4777000 0.008
R_VDD2_5073 METAL5_422000_4777000 METAL5_424000_4777000 0.008
R_VDD2_5074 METAL5_424000_4777000 METAL5_426000_4777000 0.008
R_VDD2_5075 METAL5_426000_4777000 METAL5_428000_4777000 0.008
R_VDD2_5076 METAL5_428000_4777000 METAL5_434000_4777000 0.024
R_VDD2_5077 METAL5_434000_4777000 METAL5_436000_4777000 0.008
R_VDD2_5078 METAL5_436000_4777000 METAL5_438000_4777000 0.008
R_VDD2_5079 METAL5_438000_4777000 METAL5_440000_4777000 0.008
R_VDD2_5080 METAL5_440000_4777000 METAL5_446000_4777000 0.024
R_VDD2_5081 METAL5_446000_4777000 METAL5_448000_4777000 0.008
R_VDD2_5082 METAL5_448000_4777000 METAL5_450000_4777000 0.008
R_VDD2_5083 METAL5_450000_4777000 METAL5_452000_4777000 0.008
R_VDD2_5084 METAL5_452000_4777000 METAL5_458000_4777000 0.024
R_VDD2_5085 METAL5_458000_4777000 METAL5_460000_4777000 0.008
R_VDD2_5086 METAL5_460000_4777000 METAL5_462000_4777000 0.008
R_VDD2_5087 METAL5_462000_4777000 METAL5_464000_4777000 0.008
R_VDD2_5088 METAL5_464000_4777000 METAL5_472000_4777000 0.032
R_VDD2_5089 METAL5_472000_4777000 METAL5_474000_4777000 0.008
R_VDD2_5090 METAL5_474000_4777000 METAL5_476000_4777000 0.008
R_VDD2_5091 METAL5_476000_4777000 METAL5_484000_4777000 0.032
R_VDD2_5092 METAL5_484000_4777000 METAL5_486000_4777000 0.008
R_VDD2_5093 METAL5_486000_4777000 METAL5_488000_4777000 0.008
R_VDD2_5094 METAL5_488000_4777000 METAL5_496000_4777000 0.032
R_VDD2_5095 METAL5_496000_4777000 METAL5_500000_4777000 0.016
R_VDD2_5096 METAL5_500000_4777000 METAL5_507000_4777000 0.028
R_VDD2_5097 METAL5_507000_4777000 METAL5_512000_4777000 0.02
R_VDD2_5098 METAL5_512000_4777000 METAL5_519000_4777000 0.028
R_VDD2_5099 METAL5_519000_4777000 METAL5_524000_4777000 0.02
R_VDD2_5100 METAL5_524000_4777000 METAL5_531000_4777000 0.028
R_VDD2_5101 METAL5_531000_4777000 METAL5_543000_4777000 0.048
R_VDD2_5102 METAL5_543000_4777000 METAL6_543000_4777000 0.1
R_VDD2_5103 METAL6_543000_4777000 METAL6_543000_4893000 0.232
R_VDD2_5104 METAL6_543000_4893000 METAL6_543000_4907000 0.028
R_VDD2_5105 METAL6_543000_4907000 METAL6_543000_5053000 0.292
R_VDD2_5106 METAL6_543000_5053000 METAL5_543000_5053000 0.1
R_VDD2_5107 METAL5_543000_5053000 METAL5_531000_5053000 0.048
R_VDD2_5108 METAL5_531000_5053000 METAL5_531000_5065000 0.048
R_VDD2_5109 METAL5_531000_5065000 METAL5_531000_5077000 0.048
R_VDD2_5110 METAL5_531000_5077000 METAL5_543000_5077000 0.048
R_VDD2_5111 METAL5_543000_5077000 METAL6_543000_5077000 0.1
R_VDD2_5112 METAL6_543000_5077000 METAL6_543000_5153000 0.152
R_VDD2_5113 METAL6_543000_5153000 METAL6_543000_5165000 0.024
R_VDD2_5114 METAL6_245000_5165000 METAL6_257000_5165000 0.024
R_VDD2_5115 METAL5_378000_4777000 METAL5_378000_4789000 0.048
R_VDD2_5116 METAL5_378000_4789000 METAL5_376000_4789000 0.008
R_VDD2_5117 METAL5_376000_4789000 METAL5_374000_4789000 0.008
R_VDD2_5118 METAL5_374000_4789000 METAL5_372000_4789000 0.008
R_VDD2_5119 METAL5_372000_4789000 METAL5_366000_4789000 0.024
R_VDD2_5120 METAL5_366000_4789000 METAL5_364000_4789000 0.008
R_VDD2_5121 METAL5_364000_4789000 METAL5_362000_4789000 0.008
R_VDD2_5122 METAL5_362000_4789000 METAL5_360000_4789000 0.008
R_VDD2_5123 METAL5_360000_4789000 METAL5_354000_4789000 0.024
R_VDD2_5124 METAL5_354000_4789000 METAL5_352000_4789000 0.008
R_VDD2_5125 METAL5_352000_4789000 METAL5_350000_4789000 0.008
R_VDD2_5126 METAL5_350000_4789000 METAL5_348000_4789000 0.008
R_VDD2_5127 METAL5_348000_4789000 METAL5_342000_4789000 0.024
R_VDD2_5128 METAL5_342000_4789000 METAL5_340000_4789000 0.008
R_VDD2_5129 METAL5_340000_4789000 METAL5_338000_4789000 0.008
R_VDD2_5130 METAL5_338000_4789000 METAL5_336000_4789000 0.008
R_VDD2_5131 METAL5_336000_4789000 METAL5_330000_4789000 0.024
R_VDD2_5132 METAL5_330000_4789000 METAL5_328000_4789000 0.008
R_VDD2_5133 METAL5_328000_4789000 METAL5_326000_4789000 0.008
R_VDD2_5134 METAL5_326000_4789000 METAL5_324000_4789000 0.008
R_VDD2_5135 METAL5_324000_4789000 METAL5_318000_4789000 0.024
R_VDD2_5136 METAL5_318000_4789000 METAL5_316000_4789000 0.008
R_VDD2_5137 METAL5_316000_4789000 METAL5_314000_4789000 0.008
R_VDD2_5138 METAL5_314000_4789000 METAL5_312000_4789000 0.008
R_VDD2_5139 METAL5_312000_4789000 METAL5_306000_4789000 0.024
R_VDD2_5140 METAL5_306000_4789000 METAL5_305000_4789000 0.004
R_VDD2_5141 METAL5_305000_4789000 METAL5_302000_4789000 0.012
R_VDD2_5142 METAL5_302000_4789000 METAL5_300000_4789000 0.008
R_VDD2_5143 METAL5_300000_4789000 METAL6_300000_4789000 0.1
R_VDD2_5144 METAL6_300000_4789000 METAL6_300000_4893000 0.208
R_VDD2_5145 METAL6_300000_4893000 METAL6_300000_4907000 0.028
R_VDD2_5146 METAL6_300000_4907000 METAL6_300000_5041000 0.268
R_VDD2_5147 METAL6_300000_5041000 METAL6_300000_5053000 0.024
R_VDD2_5148 METAL6_300000_5053000 METAL6_300000_5065000 0.024
R_VDD2_5149 METAL6_300000_5065000 METAL6_300000_5077000 0.024
R_VDD2_5150 METAL6_300000_5077000 METAL5_300000_5077000 0.1
R_VDD2_5151 METAL5_300000_5077000 METAL5_294000_5077000 0.024
R_VDD2_5152 METAL5_294000_5077000 METAL5_293000_5077000 0.004
R_VDD2_5153 METAL5_293000_5077000 METAL5_290000_5077000 0.012
R_VDD2_5154 METAL5_290000_5077000 METAL5_288000_5077000 0.008
R_VDD2_5155 METAL5_288000_5077000 METAL5_282000_5077000 0.024
R_VDD2_5156 METAL5_282000_5077000 METAL5_281000_5077000 0.004
R_VDD2_5157 METAL5_281000_5077000 METAL5_278000_5077000 0.012
R_VDD2_5158 METAL5_278000_5077000 METAL5_276000_5077000 0.008
R_VDD2_5159 METAL5_276000_5077000 METAL5_270000_5077000 0.024
R_VDD2_5160 METAL5_270000_5077000 METAL5_269000_5077000 0.004
R_VDD2_5161 METAL5_269000_5077000 METAL5_266000_5077000 0.012
R_VDD2_5162 METAL5_266000_5077000 METAL5_264000_5077000 0.008
R_VDD2_5163 METAL5_264000_5077000 METAL5_258000_5077000 0.024
R_VDD2_5164 METAL5_258000_5077000 METAL5_257000_5077000 0.004
R_VDD2_5165 METAL5_257000_5077000 METAL6_257000_5077000 0.1
R_VDD2_5166 METAL6_257000_5077000 METAL6_257000_5089000 0.024
R_VDD2_5167 METAL6_257000_5089000 METAL6_257000_5153000 0.128
R_VDD2_5168 METAL6_257000_5153000 METAL6_257000_5165000 0.024
R_VDD2_5169 METAL6_555000_4465000 METAL6_543000_4465000 0.024
R_VDD2_5170 METAL6_350000_8000 METAL6_348000_8000 0.004
R_VDD2_5171 METAL6_348000_8000 METAL6_342000_8000 0.012
R_VDD2_5172 METAL6_342000_8000 METAL6_340000_8000 0.004
R_VDD2_5173 METAL6_340000_8000 METAL6_338000_8000 0.004
R_VDD2_5174 METAL6_338000_8000 METAL6_336000_8000 0.004
R_VDD2_5175 METAL6_336000_8000 METAL6_330000_8000 0.012
R_VDD2_5176 METAL6_330000_8000 METAL6_328000_8000 0.004
R_VDD2_5177 METAL6_328000_8000 METAL6_328000_20000 0.024
R_VDD2_5178 METAL6_328000_20000 METAL6_326000_20000 0.004
R_VDD2_5179 METAL6_326000_20000 METAL6_324000_20000 0.004
R_VDD2_5180 METAL6_324000_20000 METAL6_318000_20000 0.012
R_VDD2_5181 METAL6_318000_20000 METAL6_316000_20000 0.004
R_VDD2_5182 METAL6_316000_20000 METAL6_316000_32000 0.024
R_VDD2_5183 METAL6_316000_32000 METAL6_314000_32000 0.004
R_VDD2_5184 METAL6_314000_32000 METAL6_312000_32000 0.004
R_VDD2_5185 METAL6_312000_32000 METAL6_306000_32000 0.012
R_VDD2_5186 METAL6_306000_32000 METAL5_306000_32000 0.1
R_VDD2_5187 METAL5_306000_32000 METAL5_306000_44000 0.048
R_VDD2_5188 METAL5_306000_44000 METAL5_306000_45000 0.004
R_VDD2_5189 METAL5_306000_45000 METAL5_306000_56000 0.044
R_VDD2_5190 METAL5_306000_56000 METAL5_306000_57000 0.004
R_VDD2_5191 METAL5_306000_57000 METAL5_306000_68000 0.044
R_VDD2_5192 METAL5_306000_68000 METAL5_312000_68000 0.024
R_VDD2_5193 METAL5_312000_68000 METAL5_314000_68000 0.008
R_VDD2_5194 METAL5_314000_68000 METAL5_316000_68000 0.008
R_VDD2_5195 METAL5_316000_68000 METAL5_318000_68000 0.008
R_VDD2_5196 METAL5_318000_68000 METAL5_318000_69000 0.004
R_VDD2_5197 METAL5_318000_69000 METAL5_318000_80000 0.044
R_VDD2_5198 METAL5_318000_80000 METAL5_318000_81000 0.004
R_VDD2_5199 METAL5_318000_81000 METAL5_318000_93000 0.048
R_VDD2_5200 METAL5_318000_93000 METAL5_318000_105000 0.048
R_VDD2_5201 METAL5_318000_105000 METAL5_318000_117000 0.048
R_VDD2_5202 METAL5_318000_117000 METAL5_318000_121000 0.016
R_VDD2_5203 METAL5_318000_121000 METAL5_318000_129000 0.032
R_VDD2_5204 METAL5_318000_129000 METAL5_318000_133000 0.016
R_VDD2_5205 METAL5_318000_133000 METAL5_318000_141000 0.032
R_VDD2_5206 METAL5_318000_141000 METAL5_318000_145000 0.016
R_VDD2_5207 METAL5_318000_145000 METAL5_318000_153000 0.032
R_VDD2_5208 METAL5_318000_153000 METAL5_318000_157000 0.016
R_VDD2_5209 METAL5_318000_157000 METAL5_318000_165000 0.032
R_VDD2_5210 METAL5_318000_165000 METAL5_318000_169000 0.016
R_VDD2_5211 METAL5_318000_169000 METAL5_318000_177000 0.032
R_VDD2_5212 METAL5_318000_177000 METAL5_318000_181000 0.016
R_VDD2_5213 METAL5_318000_181000 METAL5_318000_193000 0.048
R_VDD2_5214 METAL5_318000_193000 METAL5_318000_205000 0.048
R_VDD2_5215 METAL5_318000_205000 METAL5_318000_217000 0.048
R_VDD2_5216 METAL5_318000_217000 METAL5_318000_229000 0.048
R_VDD2_5217 METAL5_318000_229000 METAL5_318000_233000 0.016
R_VDD2_5218 METAL5_318000_233000 METAL5_318000_241000 0.032
R_VDD2_5219 METAL5_318000_241000 METAL5_318000_245000 0.016
R_VDD2_5220 METAL5_318000_245000 METAL5_318000_253000 0.032
R_VDD2_5221 METAL5_318000_253000 METAL5_318000_257000 0.016
R_VDD2_5222 METAL5_318000_257000 METAL5_318000_265000 0.032
R_VDD2_5223 METAL5_318000_265000 METAL5_324000_265000 0.024
R_VDD2_5224 METAL5_324000_265000 METAL5_324000_269000 0.016
R_VDD2_5225 METAL5_324000_269000 METAL5_324000_277000 0.032
R_VDD2_5226 METAL5_324000_277000 METAL5_324000_281000 0.016
R_VDD2_5227 METAL5_324000_281000 METAL4_324000_281000 0.1
R_VDD2_5228 METAL4_324000_281000 METAL4_324000_289000 0.064
R_VDD2_5229 METAL4_324000_289000 METAL4_324000_293000 0.032
R_VDD2_5230 METAL4_324000_293000 METAL4_324000_301000 0.064
R_VDD2_5231 METAL4_324000_301000 METAL4_324000_305000 0.032
R_VDD2_5232 METAL4_324000_305000 METAL4_324000_313000 0.064
R_VDD2_5233 METAL4_324000_313000 METAL4_324000_317000 0.032
R_VDD2_5234 METAL4_324000_317000 METAL4_324000_329000 0.096
R_VDD2_5235 METAL4_324000_329000 METAL4_324000_341000 0.096
R_VDD2_5236 METAL4_324000_341000 METAL4_324000_353000 0.096
R_VDD2_5237 METAL4_324000_353000 METAL4_324000_365000 0.096
R_VDD2_5238 METAL4_324000_365000 METAL4_324000_377000 0.096
R_VDD2_5239 METAL4_324000_377000 METAL4_324000_389000 0.096
R_VDD2_5240 METAL4_324000_389000 METAL5_324000_389000 0.1
R_VDD2_5241 METAL5_324000_389000 METAL5_324000_429000 0.16
R_VDD2_5242 METAL5_324000_429000 METAL5_326000_429000 0.008
R_VDD2_5243 METAL5_326000_429000 METAL5_328000_429000 0.008
R_VDD2_5244 METAL5_328000_429000 METAL5_330000_429000 0.008
R_VDD2_5245 METAL5_330000_429000 METAL5_336000_429000 0.024
R_VDD2_5246 METAL5_336000_429000 METAL5_336000_441000 0.048
R_VDD2_5247 METAL5_336000_441000 METAL5_338000_441000 0.008
R_VDD2_5248 METAL5_338000_441000 METAL5_340000_441000 0.008
R_VDD2_5249 METAL5_340000_441000 METAL5_342000_441000 0.008
R_VDD2_5250 METAL5_342000_441000 METAL5_348000_441000 0.024
R_VDD2_5251 METAL5_348000_441000 METAL5_350000_441000 0.008
R_VDD2_5252 METAL5_350000_441000 METAL5_352000_441000 0.008
R_VDD2_5253 METAL5_352000_441000 METAL5_354000_441000 0.008
R_VDD2_5254 METAL5_354000_441000 METAL5_360000_441000 0.024
R_VDD2_5255 METAL5_360000_441000 METAL5_362000_441000 0.008
R_VDD2_5256 METAL5_362000_441000 METAL5_364000_441000 0.008
R_VDD2_5257 METAL5_364000_441000 METAL5_366000_441000 0.008
R_VDD2_5258 METAL5_366000_441000 METAL5_372000_441000 0.024
R_VDD2_5259 METAL5_372000_441000 METAL4_372000_441000 0.1
R_VDD2_5260 METAL4_372000_441000 METAL4_374000_441000 0.016
R_VDD2_5261 METAL4_374000_441000 METAL4_376000_441000 0.016
R_VDD2_5262 METAL4_376000_441000 METAL4_378000_441000 0.016
R_VDD2_5263 METAL4_378000_441000 METAL4_384000_441000 0.048
R_VDD2_5264 METAL4_384000_441000 METAL4_384000_453000 0.096
R_VDD2_5265 METAL4_384000_453000 METAL4_384000_465000 0.096
R_VDD2_5266 METAL4_384000_465000 METAL4_386000_465000 0.016
R_VDD2_5267 METAL4_386000_465000 METAL4_388000_465000 0.016
R_VDD2_5268 METAL4_388000_465000 METAL4_390000_465000 0.016
R_VDD2_5269 METAL4_390000_465000 METAL4_396000_465000 0.048
R_VDD2_5270 METAL4_396000_465000 METAL4_396000_469000 0.032
R_VDD2_5271 METAL4_396000_469000 METAL4_396000_477000 0.064
R_VDD2_5272 METAL4_396000_477000 METAL5_396000_477000 0.1
R_VDD2_5273 METAL5_396000_477000 METAL5_396000_481000 0.016
R_VDD2_5274 METAL5_396000_481000 METAL5_396000_489000 0.032
R_VDD2_5275 METAL5_396000_489000 METAL5_396000_493000 0.016
R_VDD2_5276 METAL5_396000_493000 METAL5_396000_501000 0.032
R_VDD2_5277 METAL5_396000_501000 METAL5_396000_505000 0.016
R_VDD2_5278 METAL5_396000_505000 METAL5_396000_517000 0.048
R_VDD2_5279 METAL5_396000_517000 METAL5_396000_529000 0.048
R_VDD2_5280 METAL5_396000_529000 METAL5_396000_541000 0.048
R_VDD2_5281 METAL5_396000_541000 METAL5_396000_553000 0.048
R_VDD2_5282 METAL5_396000_553000 METAL5_396000_565000 0.048
R_VDD2_5283 METAL5_396000_565000 METAL5_396000_577000 0.048
R_VDD2_5284 METAL5_396000_577000 METAL4_396000_577000 0.1
R_VDD2_5285 METAL4_396000_577000 METAL4_396000_589000 0.096
R_VDD2_5286 METAL4_396000_589000 METAL4_396000_601000 0.096
R_VDD2_5287 METAL4_396000_601000 METAL5_396000_601000 0.1
R_VDD2_5288 METAL5_396000_601000 METAL5_396000_613000 0.048
R_VDD2_5289 METAL5_396000_613000 METAL5_396000_625000 0.048
R_VDD2_5290 METAL5_396000_625000 METAL5_396000_681000 0.224
R_VDD2_5291 METAL5_396000_681000 METAL5_396000_693000 0.048
R_VDD2_5292 METAL5_396000_693000 METAL5_396000_705000 0.048
R_VDD2_5293 METAL5_396000_705000 METAL5_396000_707000 0.008
R_VDD2_5294 METAL5_396000_707000 METAL5_396000_717000 0.04
R_VDD2_5295 METAL5_396000_717000 METAL5_396000_781000 0.256
R_VDD2_5296 METAL5_396000_781000 METAL5_398000_781000 0.008
R_VDD2_5297 METAL5_398000_781000 METAL5_398000_793000 0.048
R_VDD2_5298 METAL5_398000_793000 METAL5_398000_805000 0.048
R_VDD2_5299 METAL5_398000_805000 METAL4_398000_805000 0.1
R_VDD2_5300 METAL4_398000_805000 METAL4_398000_817000 0.096
R_VDD2_5301 METAL4_398000_817000 METAL4_398000_829000 0.096
R_VDD2_5302 METAL4_398000_829000 METAL4_398000_841000 0.096
R_VDD2_5303 METAL4_398000_841000 METAL5_398000_841000 0.1
R_VDD2_5304 METAL5_398000_841000 METAL5_398000_853000 0.048
R_VDD2_5305 METAL5_398000_853000 METAL5_398000_865000 0.048
R_VDD2_5306 METAL5_398000_865000 METAL5_398000_869000 0.016
R_VDD2_5307 METAL5_398000_869000 METAL5_398000_877000 0.032
R_VDD2_5308 METAL5_398000_877000 METAL5_398000_881000 0.016
R_VDD2_5309 METAL5_398000_881000 METAL5_398000_889000 0.032
R_VDD2_5310 METAL5_398000_889000 METAL5_398000_893000 0.016
R_VDD2_5311 METAL5_398000_893000 METAL5_398000_901000 0.032
R_VDD2_5312 METAL5_398000_901000 METAL5_398000_905000 0.016
R_VDD2_5313 METAL5_398000_905000 METAL5_398000_917000 0.048
R_VDD2_5314 METAL5_398000_917000 METAL5_398000_929000 0.048
R_VDD2_5315 METAL5_398000_929000 METAL5_398000_941000 0.048
R_VDD2_5316 METAL5_398000_941000 METAL5_398000_953000 0.048
R_VDD2_5317 METAL5_398000_953000 METAL5_400000_953000 0.008
R_VDD2_5318 METAL5_400000_953000 METAL5_402000_953000 0.008
R_VDD2_5319 METAL5_402000_953000 METAL5_408000_953000 0.024
R_VDD2_5320 METAL5_408000_953000 METAL5_410000_953000 0.008
R_VDD2_5321 METAL5_410000_953000 METAL5_412000_953000 0.008
R_VDD2_5322 METAL5_412000_953000 METAL5_414000_953000 0.008
R_VDD2_5323 METAL5_414000_953000 METAL5_416000_953000 0.008
R_VDD2_5324 METAL5_416000_953000 METAL5_420000_953000 0.016
R_VDD2_5325 METAL5_420000_953000 METAL5_422000_953000 0.008
R_VDD2_5326 METAL5_422000_953000 METAL5_422000_965000 0.048
R_VDD2_5327 METAL5_422000_965000 METAL5_424000_965000 0.008
R_VDD2_5328 METAL5_424000_965000 METAL5_426000_965000 0.008
R_VDD2_5329 METAL5_426000_965000 METAL5_428000_965000 0.008
R_VDD2_5330 METAL5_428000_965000 METAL5_434000_965000 0.024
R_VDD2_5331 METAL5_434000_965000 METAL5_434000_977000 0.048
R_VDD2_5332 METAL5_434000_977000 METAL5_434000_989000 0.048
R_VDD2_5333 METAL5_434000_989000 METAL5_434000_1001000 0.048
R_VDD2_5334 METAL5_434000_1001000 METAL5_434000_1013000 0.048
R_VDD2_5335 METAL5_434000_1013000 METAL5_434000_1025000 0.048
R_VDD2_5336 METAL5_434000_1025000 METAL5_434000_1041000 0.064
R_VDD2_5337 METAL5_434000_1041000 METAL5_434000_1053000 0.048
R_VDD2_5338 METAL5_434000_1053000 METAL5_434000_1065000 0.048
R_VDD2_5339 METAL5_434000_1065000 METAL4_434000_1065000 0.1
R_VDD2_5340 METAL4_434000_1065000 METAL4_434000_1077000 0.096
R_VDD2_5341 METAL4_434000_1077000 METAL4_434000_1089000 0.096
R_VDD2_5342 METAL4_434000_1089000 METAL5_434000_1089000 0.1
R_VDD2_5343 METAL5_434000_1089000 METAL5_434000_1101000 0.048
R_VDD2_5344 METAL5_434000_1101000 METAL5_434000_1153000 0.208
R_VDD2_5345 METAL5_434000_1153000 METAL5_434000_1165000 0.048
R_VDD2_5346 METAL5_434000_1165000 METAL4_434000_1165000 0.1
R_VDD2_5347 METAL4_434000_1165000 METAL4_434000_1177000 0.096
R_VDD2_5348 METAL4_434000_1177000 METAL4_434000_1189000 0.096
R_VDD2_5349 METAL4_434000_1189000 METAL5_434000_1189000 0.1
R_VDD2_5350 METAL5_434000_1189000 METAL5_434000_1201000 0.048
R_VDD2_5351 METAL5_434000_1201000 METAL5_434000_1217000 0.064
R_VDD2_5352 METAL5_434000_1217000 METAL5_434000_1229000 0.048
R_VDD2_5353 METAL5_434000_1229000 METAL5_436000_1229000 0.008
R_VDD2_5354 METAL5_436000_1229000 METAL5_438000_1229000 0.008
R_VDD2_5355 METAL5_438000_1229000 METAL5_440000_1229000 0.008
R_VDD2_5356 METAL5_440000_1229000 METAL5_446000_1229000 0.024
R_VDD2_5357 METAL5_446000_1229000 METAL5_448000_1229000 0.008
R_VDD2_5358 METAL5_448000_1229000 METAL5_450000_1229000 0.008
R_VDD2_5359 METAL5_450000_1229000 METAL5_452000_1229000 0.008
R_VDD2_5360 METAL5_452000_1229000 METAL5_458000_1229000 0.024
R_VDD2_5361 METAL5_458000_1229000 METAL5_458000_1241000 0.048
R_VDD2_5362 METAL5_458000_1241000 METAL5_458000_1253000 0.048
R_VDD2_5363 METAL5_458000_1253000 METAL5_458000_1265000 0.048
R_VDD2_5364 METAL5_458000_1265000 METAL5_458000_1277000 0.048
R_VDD2_5365 METAL5_458000_1277000 METAL5_458000_1289000 0.048
R_VDD2_5366 METAL5_458000_1289000 METAL5_458000_1357000 0.272
R_VDD2_5367 METAL5_458000_1357000 METAL5_458000_1369000 0.048
R_VDD2_5368 METAL5_458000_1369000 METAL4_458000_1369000 0.1
R_VDD2_5369 METAL4_458000_1369000 METAL4_458000_1381000 0.096
R_VDD2_5370 METAL4_458000_1381000 METAL4_458000_1393000 0.096
R_VDD2_5371 METAL4_458000_1393000 METAL5_458000_1393000 0.1
R_VDD2_5372 METAL5_458000_1393000 METAL5_458000_1405000 0.048
R_VDD2_5373 METAL5_458000_1405000 METAL5_458000_1407000 0.008
R_VDD2_5374 METAL5_458000_1407000 METAL5_458000_1417000 0.04
R_VDD2_5375 METAL5_458000_1417000 METAL5_458000_1529000 0.448
R_VDD2_5376 METAL5_458000_1529000 METAL5_458000_1541000 0.048
R_VDD2_5377 METAL5_458000_1541000 METAL5_458000_1553000 0.048
R_VDD2_5378 METAL5_458000_1553000 METAL5_458000_1565000 0.048
R_VDD2_5379 METAL5_458000_1565000 METAL5_458000_1577000 0.048
R_VDD2_5380 METAL5_458000_1577000 METAL5_458000_1617000 0.16
R_VDD2_5381 METAL5_458000_1617000 METAL5_458000_1629000 0.048
R_VDD2_5382 METAL5_458000_1629000 METAL5_458000_1641000 0.048
R_VDD2_5383 METAL5_458000_1641000 METAL5_458000_1653000 0.048
R_VDD2_5384 METAL5_458000_1653000 METAL5_458000_1665000 0.048
R_VDD2_5385 METAL5_458000_1665000 METAL5_458000_1677000 0.048
R_VDD2_5386 METAL5_458000_1677000 METAL5_458000_1689000 0.048
R_VDD2_5387 METAL5_458000_1689000 METAL5_458000_1753000 0.256
R_VDD2_5388 METAL5_458000_1753000 METAL5_458000_1765000 0.048
R_VDD2_5389 METAL5_458000_1765000 METAL5_458000_1777000 0.048
R_VDD2_5390 METAL5_458000_1777000 METAL5_458000_1789000 0.048
R_VDD2_5391 METAL5_458000_1789000 METAL5_458000_1817000 0.112
R_VDD2_5392 METAL5_458000_1817000 METAL5_458000_1829000 0.048
R_VDD2_5393 METAL5_458000_1829000 METAL5_458000_1841000 0.048
R_VDD2_5394 METAL5_458000_1841000 METAL5_458000_1853000 0.048
R_VDD2_5395 METAL5_458000_1853000 METAL5_458000_1865000 0.048
R_VDD2_5396 METAL5_458000_1865000 METAL5_458000_1877000 0.048
R_VDD2_5397 METAL5_458000_1877000 METAL5_458000_1905000 0.112
R_VDD2_5398 METAL5_458000_1905000 METAL5_458000_1917000 0.048
R_VDD2_5399 METAL5_458000_1917000 METAL5_458000_1929000 0.048
R_VDD2_5400 METAL5_458000_1929000 METAL4_458000_1929000 0.1
R_VDD2_5401 METAL4_458000_1929000 METAL4_458000_1941000 0.096
R_VDD2_5402 METAL4_458000_1941000 METAL4_458000_1953000 0.096
R_VDD2_5403 METAL4_458000_1953000 METAL5_458000_1953000 0.1
R_VDD2_5404 METAL5_458000_1953000 METAL5_458000_1965000 0.048
R_VDD2_5405 METAL5_458000_1965000 METAL5_452000_1965000 0.024
R_VDD2_5406 METAL5_452000_1965000 METAL5_450000_1965000 0.008
R_VDD2_5407 METAL5_450000_1965000 METAL5_448000_1965000 0.008
R_VDD2_5408 METAL5_448000_1965000 METAL5_446000_1965000 0.008
R_VDD2_5409 METAL5_446000_1965000 METAL5_440000_1965000 0.024
R_VDD2_5410 METAL5_440000_1965000 METAL5_438000_1965000 0.008
R_VDD2_5411 METAL5_438000_1965000 METAL5_436000_1965000 0.008
R_VDD2_5412 METAL5_436000_1965000 METAL5_434000_1965000 0.008
R_VDD2_5413 METAL5_434000_1965000 METAL5_428000_1965000 0.024
R_VDD2_5414 METAL5_428000_1965000 METAL5_426000_1965000 0.008
R_VDD2_5415 METAL5_426000_1965000 METAL5_424000_1965000 0.008
R_VDD2_5416 METAL5_424000_1965000 METAL5_422000_1965000 0.008
R_VDD2_5417 METAL5_422000_1965000 METAL5_420000_1965000 0.008
R_VDD2_5418 METAL5_420000_1965000 METAL5_416000_1965000 0.016
R_VDD2_5419 METAL5_416000_1965000 METAL5_414000_1965000 0.008
R_VDD2_5420 METAL5_414000_1965000 METAL5_412000_1965000 0.008
R_VDD2_5421 METAL5_412000_1965000 METAL5_410000_1965000 0.008
R_VDD2_5422 METAL5_410000_1965000 METAL4_410000_1965000 0.1
R_VDD2_5423 METAL4_410000_1965000 METAL4_410000_1977000 0.096
R_VDD2_5424 METAL4_410000_1977000 METAL4_410000_1989000 0.096
R_VDD2_5425 METAL4_410000_1989000 METAL5_410000_1989000 0.1
R_VDD2_5426 METAL5_410000_1989000 METAL5_410000_2001000 0.048
R_VDD2_5427 METAL5_410000_2001000 METAL5_410000_2013000 0.048
R_VDD2_5428 METAL5_410000_2013000 METAL5_410000_2093000 0.32
R_VDD2_5429 METAL5_410000_2093000 METAL5_410000_2107000 0.056
R_VDD2_5430 METAL5_410000_2107000 METAL5_410000_2217000 0.44
R_VDD2_5431 METAL5_410000_2217000 METAL5_410000_2229000 0.048
R_VDD2_5432 METAL5_410000_2229000 METAL5_410000_2241000 0.048
R_VDD2_5433 METAL5_410000_2241000 METAL5_410000_2253000 0.048
R_VDD2_5434 METAL5_410000_2253000 METAL5_410000_2265000 0.048
R_VDD2_5435 METAL5_410000_2265000 METAL5_410000_2277000 0.048
R_VDD2_5436 METAL5_410000_2277000 METAL5_410000_2341000 0.256
R_VDD2_5437 METAL5_410000_2341000 METAL5_410000_2353000 0.048
R_VDD2_5438 METAL5_410000_2353000 METAL5_410000_2365000 0.048
R_VDD2_5439 METAL5_410000_2365000 METAL5_410000_2377000 0.048
R_VDD2_5440 METAL5_410000_2377000 METAL5_410000_2389000 0.048
R_VDD2_5441 METAL5_410000_2389000 METAL5_410000_2453000 0.256
R_VDD2_5442 METAL5_410000_2453000 METAL5_410000_2465000 0.048
R_VDD2_5443 METAL5_410000_2465000 METAL5_410000_2477000 0.048
R_VDD2_5444 METAL5_410000_2477000 METAL5_410000_2489000 0.048
R_VDD2_5445 METAL5_410000_2489000 METAL5_410000_2553000 0.256
R_VDD2_5446 METAL5_410000_2553000 METAL5_410000_2565000 0.048
R_VDD2_5447 METAL5_410000_2565000 METAL5_410000_2577000 0.048
R_VDD2_5448 METAL5_410000_2577000 METAL5_410000_2605000 0.112
R_VDD2_5449 METAL5_410000_2605000 METAL5_410000_2617000 0.048
R_VDD2_5450 METAL5_410000_2617000 METAL5_410000_2629000 0.048
R_VDD2_5451 METAL5_410000_2629000 METAL5_410000_2641000 0.048
R_VDD2_5452 METAL5_410000_2641000 METAL5_410000_2653000 0.048
R_VDD2_5453 METAL5_410000_2653000 METAL5_410000_2665000 0.048
R_VDD2_5454 METAL5_410000_2665000 METAL4_410000_2665000 0.1
R_VDD2_5455 METAL4_410000_2665000 METAL4_410000_2677000 0.096
R_VDD2_5456 METAL4_410000_2677000 METAL4_410000_2689000 0.096
R_VDD2_5457 METAL4_410000_2689000 METAL4_410000_2701000 0.096
R_VDD2_5458 METAL4_410000_2701000 METAL5_410000_2701000 0.1
R_VDD2_5459 METAL5_410000_2701000 METAL5_410000_2713000 0.048
R_VDD2_5460 METAL5_410000_2713000 METAL5_410000_2769000 0.224
R_VDD2_5461 METAL5_410000_2769000 METAL5_410000_2781000 0.048
R_VDD2_5462 METAL5_410000_2781000 METAL5_410000_2793000 0.048
R_VDD2_5463 METAL5_410000_2793000 METAL5_410000_2805000 0.048
R_VDD2_5464 METAL5_410000_2805000 METAL5_410000_2807000 0.008
R_VDD2_5465 METAL5_410000_2807000 METAL5_410000_2817000 0.04
R_VDD2_5466 METAL5_410000_2817000 METAL5_410000_2941000 0.496
R_VDD2_5467 METAL5_410000_2941000 METAL5_410000_2953000 0.048
R_VDD2_5468 METAL5_410000_2953000 METAL5_410000_2965000 0.048
R_VDD2_5469 METAL5_410000_2965000 METAL5_408000_2965000 0.008
R_VDD2_5470 METAL5_408000_2965000 METAL5_402000_2965000 0.024
R_VDD2_5471 METAL5_402000_2965000 METAL5_400000_2965000 0.008
R_VDD2_5472 METAL5_400000_2965000 METAL5_398000_2965000 0.008
R_VDD2_5473 METAL5_398000_2965000 METAL5_398000_2977000 0.048
R_VDD2_5474 METAL5_398000_2977000 METAL5_398000_2989000 0.048
R_VDD2_5475 METAL5_398000_2989000 METAL5_398000_3001000 0.048
R_VDD2_5476 METAL5_398000_3001000 METAL5_398000_3053000 0.208
R_VDD2_5477 METAL5_398000_3053000 METAL5_398000_3065000 0.048
R_VDD2_5478 METAL5_398000_3065000 METAL5_398000_3077000 0.048
R_VDD2_5479 METAL5_398000_3077000 METAL5_398000_3089000 0.048
R_VDD2_5480 METAL5_398000_3089000 METAL5_398000_3153000 0.256
R_VDD2_5481 METAL5_398000_3153000 METAL5_398000_3165000 0.048
R_VDD2_5482 METAL5_398000_3165000 METAL5_398000_3177000 0.048
R_VDD2_5483 METAL5_398000_3177000 METAL5_398000_3189000 0.048
R_VDD2_5484 METAL5_398000_3189000 METAL5_398000_3253000 0.256
R_VDD2_5485 METAL5_398000_3253000 METAL5_398000_3265000 0.048
R_VDD2_5486 METAL5_398000_3265000 METAL5_398000_3277000 0.048
R_VDD2_5487 METAL5_398000_3277000 METAL5_398000_3289000 0.048
R_VDD2_5488 METAL5_398000_3289000 METAL5_398000_3341000 0.208
R_VDD2_5489 METAL5_398000_3341000 METAL5_398000_3353000 0.048
R_VDD2_5490 METAL5_398000_3353000 METAL5_398000_3365000 0.048
R_VDD2_5491 METAL5_398000_3365000 METAL5_398000_3377000 0.048
R_VDD2_5492 METAL5_398000_3377000 METAL5_398000_3389000 0.048
R_VDD2_5493 METAL5_398000_3389000 METAL4_398000_3389000 0.1
R_VDD2_5494 METAL4_398000_3389000 METAL4_398000_3401000 0.096
R_VDD2_5495 METAL4_398000_3401000 METAL4_398000_3413000 0.096
R_VDD2_5496 METAL4_398000_3413000 METAL5_398000_3413000 0.1
R_VDD2_5497 METAL5_398000_3413000 METAL5_398000_3425000 0.048
R_VDD2_5498 METAL5_398000_3425000 METAL5_398000_3493000 0.272
R_VDD2_5499 METAL5_398000_3493000 METAL5_398000_3495000 0.008
R_VDD2_5500 METAL5_398000_3495000 METAL5_398000_3507000 0.048
R_VDD2_5501 METAL5_398000_3507000 METAL5_398000_3519000 0.048
R_VDD2_5502 METAL5_398000_3519000 METAL5_398000_3641000 0.488
R_VDD2_5503 METAL5_398000_3641000 METAL5_398000_3653000 0.048
R_VDD2_5504 METAL5_398000_3653000 METAL5_398000_3665000 0.048
R_VDD2_5505 METAL5_398000_3665000 METAL5_398000_3677000 0.048
R_VDD2_5506 METAL5_398000_3677000 METAL5_398000_3753000 0.304
R_VDD2_5507 METAL5_398000_3753000 METAL5_398000_3765000 0.048
R_VDD2_5508 METAL5_398000_3765000 METAL5_398000_3777000 0.048
R_VDD2_5509 METAL5_398000_3777000 METAL5_398000_3789000 0.048
R_VDD2_5510 METAL5_398000_3789000 METAL5_398000_3853000 0.256
R_VDD2_5511 METAL5_398000_3853000 METAL5_398000_3865000 0.048
R_VDD2_5512 METAL5_398000_3865000 METAL5_398000_3877000 0.048
R_VDD2_5513 METAL5_398000_3877000 METAL5_398000_3941000 0.256
R_VDD2_5514 METAL5_398000_3941000 METAL5_398000_3953000 0.048
R_VDD2_5515 METAL5_398000_3953000 METAL5_398000_3965000 0.048
R_VDD2_5516 METAL5_398000_3965000 METAL5_398000_3977000 0.048
R_VDD2_5517 METAL5_398000_3977000 METAL5_398000_4029000 0.208
R_VDD2_5518 METAL5_398000_4029000 METAL5_398000_4041000 0.048
R_VDD2_5519 METAL5_398000_4041000 METAL5_398000_4053000 0.048
R_VDD2_5520 METAL5_398000_4053000 METAL5_398000_4065000 0.048
R_VDD2_5521 METAL5_398000_4065000 METAL4_398000_4065000 0.1
R_VDD2_5522 METAL4_398000_4065000 METAL4_398000_4077000 0.096
R_VDD2_5523 METAL4_398000_4077000 METAL4_398000_4089000 0.096
R_VDD2_5524 METAL4_398000_4089000 METAL5_398000_4089000 0.1
R_VDD2_5525 METAL5_398000_4089000 METAL5_398000_4101000 0.048
R_VDD2_5526 METAL5_398000_4101000 METAL5_398000_4157000 0.224
R_VDD2_5527 METAL5_398000_4157000 METAL5_400000_4157000 0.008
R_VDD2_5528 METAL5_400000_4157000 METAL5_402000_4157000 0.008
R_VDD2_5529 METAL5_402000_4157000 METAL5_408000_4157000 0.024
R_VDD2_5530 METAL5_408000_4157000 METAL5_410000_4157000 0.008
R_VDD2_5531 METAL5_410000_4157000 METAL5_412000_4157000 0.008
R_VDD2_5532 METAL5_412000_4157000 METAL5_414000_4157000 0.008
R_VDD2_5533 METAL5_414000_4157000 METAL5_416000_4157000 0.008
R_VDD2_5534 METAL5_416000_4157000 METAL5_420000_4157000 0.016
R_VDD2_5535 METAL5_420000_4157000 METAL5_422000_4157000 0.008
R_VDD2_5536 METAL5_422000_4157000 METAL5_424000_4157000 0.008
R_VDD2_5537 METAL5_424000_4157000 METAL5_426000_4157000 0.008
R_VDD2_5538 METAL5_426000_4157000 METAL5_428000_4157000 0.008
R_VDD2_5539 METAL5_428000_4157000 METAL5_434000_4157000 0.024
R_VDD2_5540 METAL5_434000_4157000 METAL5_436000_4157000 0.008
R_VDD2_5541 METAL5_436000_4157000 METAL5_438000_4157000 0.008
R_VDD2_5542 METAL5_438000_4157000 METAL5_440000_4157000 0.008
R_VDD2_5543 METAL5_440000_4157000 METAL5_446000_4157000 0.024
R_VDD2_5544 METAL5_446000_4157000 METAL5_448000_4157000 0.008
R_VDD2_5545 METAL5_448000_4157000 METAL5_450000_4157000 0.008
R_VDD2_5546 METAL5_450000_4157000 METAL5_452000_4157000 0.008
R_VDD2_5547 METAL5_452000_4157000 METAL5_458000_4157000 0.024
R_VDD2_5548 METAL5_458000_4157000 METAL5_460000_4157000 0.008
R_VDD2_5549 METAL5_460000_4157000 METAL5_462000_4157000 0.008
R_VDD2_5550 METAL5_462000_4157000 METAL5_464000_4157000 0.008
R_VDD2_5551 METAL5_464000_4157000 METAL5_472000_4157000 0.032
R_VDD2_5552 METAL5_472000_4157000 METAL5_474000_4157000 0.008
R_VDD2_5553 METAL5_474000_4157000 METAL5_476000_4157000 0.008
R_VDD2_5554 METAL5_476000_4157000 METAL5_484000_4157000 0.032
R_VDD2_5555 METAL5_484000_4157000 METAL5_486000_4157000 0.008
R_VDD2_5556 METAL5_486000_4157000 METAL5_488000_4157000 0.008
R_VDD2_5557 METAL5_488000_4157000 METAL5_496000_4157000 0.032
R_VDD2_5558 METAL5_496000_4157000 METAL5_500000_4157000 0.016
R_VDD2_5559 METAL5_500000_4157000 METAL5_500000_4169000 0.048
R_VDD2_5560 METAL5_500000_4169000 METAL5_500000_4181000 0.048
R_VDD2_5561 METAL5_500000_4181000 METAL5_500000_4193000 0.048
R_VDD2_5562 METAL5_500000_4193000 METAL5_507000_4193000 0.028
R_VDD2_5563 METAL5_507000_4193000 METAL5_512000_4193000 0.02
R_VDD2_5564 METAL5_512000_4193000 METAL5_519000_4193000 0.028
R_VDD2_5565 METAL5_519000_4193000 METAL5_519000_4195000 0.008
R_VDD2_5566 METAL5_519000_4195000 METAL5_519000_4205000 0.04
R_VDD2_5567 METAL5_519000_4205000 METAL5_519000_4207000 0.008
R_VDD2_5568 METAL5_519000_4207000 METAL5_519000_4219000 0.048
R_VDD2_5569 METAL5_519000_4219000 METAL5_519000_4329000 0.44
R_VDD2_5570 METAL5_519000_4329000 METAL5_519000_4341000 0.048
R_VDD2_5571 METAL5_519000_4341000 METAL5_519000_4353000 0.048
R_VDD2_5572 METAL5_519000_4353000 METAL5_519000_4365000 0.048
R_VDD2_5573 METAL5_519000_4365000 METAL5_519000_4377000 0.048
R_VDD2_5574 METAL5_519000_4377000 METAL4_519000_4377000 0.1
R_VDD2_5575 METAL4_519000_4377000 METAL4_524000_4377000 0.04
R_VDD2_5576 METAL4_524000_4377000 METAL4_531000_4377000 0.056
R_VDD2_5577 METAL4_531000_4377000 METAL4_543000_4377000 0.096
R_VDD2_5578 METAL4_543000_4377000 METAL5_543000_4377000 0.1
R_VDD2_5579 METAL5_543000_4377000 METAL6_543000_4377000 0.1
R_VDD2_5580 METAL6_543000_4377000 METAL6_543000_4389000 0.024
R_VDD2_5581 METAL6_543000_4389000 METAL6_543000_4453000 0.128
R_VDD2_5582 METAL6_543000_4453000 METAL6_543000_4465000 0.024
R_VDD2_5583 METAL6_245000_4465000 METAL6_257000_4465000 0.024
R_VDD2_5584 METAL5_398000_4157000 METAL5_396000_4157000 0.008
R_VDD2_5585 METAL5_396000_4157000 METAL5_390000_4157000 0.024
R_VDD2_5586 METAL5_390000_4157000 METAL5_388000_4157000 0.008
R_VDD2_5587 METAL5_388000_4157000 METAL5_386000_4157000 0.008
R_VDD2_5588 METAL5_386000_4157000 METAL5_384000_4157000 0.008
R_VDD2_5589 METAL5_384000_4157000 METAL5_378000_4157000 0.024
R_VDD2_5590 METAL5_378000_4157000 METAL5_376000_4157000 0.008
R_VDD2_5591 METAL5_376000_4157000 METAL5_374000_4157000 0.008
R_VDD2_5592 METAL5_374000_4157000 METAL5_372000_4157000 0.008
R_VDD2_5593 METAL5_372000_4157000 METAL5_366000_4157000 0.024
R_VDD2_5594 METAL5_366000_4157000 METAL5_364000_4157000 0.008
R_VDD2_5595 METAL5_364000_4157000 METAL5_362000_4157000 0.008
R_VDD2_5596 METAL5_362000_4157000 METAL5_360000_4157000 0.008
R_VDD2_5597 METAL5_360000_4157000 METAL5_354000_4157000 0.024
R_VDD2_5598 METAL5_354000_4157000 METAL5_352000_4157000 0.008
R_VDD2_5599 METAL5_352000_4157000 METAL5_350000_4157000 0.008
R_VDD2_5600 METAL5_350000_4157000 METAL5_348000_4157000 0.008
R_VDD2_5601 METAL5_348000_4157000 METAL5_342000_4157000 0.024
R_VDD2_5602 METAL5_342000_4157000 METAL5_340000_4157000 0.008
R_VDD2_5603 METAL5_340000_4157000 METAL5_338000_4157000 0.008
R_VDD2_5604 METAL5_338000_4157000 METAL5_336000_4157000 0.008
R_VDD2_5605 METAL5_336000_4157000 METAL5_330000_4157000 0.024
R_VDD2_5606 METAL5_330000_4157000 METAL5_328000_4157000 0.008
R_VDD2_5607 METAL5_328000_4157000 METAL5_326000_4157000 0.008
R_VDD2_5608 METAL5_326000_4157000 METAL5_324000_4157000 0.008
R_VDD2_5609 METAL5_324000_4157000 METAL5_318000_4157000 0.024
R_VDD2_5610 METAL5_318000_4157000 METAL5_316000_4157000 0.008
R_VDD2_5611 METAL5_316000_4157000 METAL5_314000_4157000 0.008
R_VDD2_5612 METAL5_314000_4157000 METAL5_312000_4157000 0.008
R_VDD2_5613 METAL5_312000_4157000 METAL5_306000_4157000 0.024
R_VDD2_5614 METAL5_306000_4157000 METAL5_305000_4157000 0.004
R_VDD2_5615 METAL5_305000_4157000 METAL5_304000_4157000 0.004
R_VDD2_5616 METAL5_304000_4157000 METAL5_302000_4157000 0.008
R_VDD2_5617 METAL5_302000_4157000 METAL5_300000_4157000 0.008
R_VDD2_5618 METAL5_300000_4157000 METAL5_294000_4157000 0.024
R_VDD2_5619 METAL5_294000_4157000 METAL5_293000_4157000 0.004
R_VDD2_5620 METAL5_293000_4157000 METAL5_290000_4157000 0.012
R_VDD2_5621 METAL5_290000_4157000 METAL5_288000_4157000 0.008
R_VDD2_5622 METAL5_288000_4157000 METAL5_282000_4157000 0.024
R_VDD2_5623 METAL5_282000_4157000 METAL5_281000_4157000 0.004
R_VDD2_5624 METAL5_281000_4157000 METAL5_278000_4157000 0.012
R_VDD2_5625 METAL5_278000_4157000 METAL5_276000_4157000 0.008
R_VDD2_5626 METAL5_276000_4157000 METAL5_270000_4157000 0.024
R_VDD2_5627 METAL5_270000_4157000 METAL5_269000_4157000 0.004
R_VDD2_5628 METAL5_269000_4157000 METAL5_266000_4157000 0.012
R_VDD2_5629 METAL5_266000_4157000 METAL5_264000_4157000 0.008
R_VDD2_5630 METAL5_264000_4157000 METAL5_258000_4157000 0.024
R_VDD2_5631 METAL5_258000_4157000 METAL5_257000_4157000 0.004
R_VDD2_5632 METAL5_257000_4157000 METAL6_257000_4157000 0.1
R_VDD2_5633 METAL6_257000_4157000 METAL6_257000_4169000 0.024
R_VDD2_5634 METAL6_257000_4169000 METAL6_257000_4181000 0.024
R_VDD2_5635 METAL6_257000_4181000 METAL6_257000_4193000 0.024
R_VDD2_5636 METAL6_257000_4193000 METAL6_257000_4195000 0.004
R_VDD2_5637 METAL6_257000_4195000 METAL6_257000_4205000 0.02
R_VDD2_5638 METAL6_257000_4205000 METAL6_257000_4207000 0.004
R_VDD2_5639 METAL6_257000_4207000 METAL6_257000_4219000 0.024
R_VDD2_5640 METAL6_257000_4219000 METAL6_257000_4329000 0.22
R_VDD2_5641 METAL6_257000_4329000 METAL6_257000_4341000 0.024
R_VDD2_5642 METAL6_257000_4341000 METAL6_257000_4353000 0.024
R_VDD2_5643 METAL6_257000_4353000 METAL5_257000_4353000 0.1
R_VDD2_5644 METAL5_257000_4353000 METAL5_258000_4353000 0.004
R_VDD2_5645 METAL5_258000_4353000 METAL5_264000_4353000 0.024
R_VDD2_5646 METAL5_264000_4353000 METAL5_266000_4353000 0.008
R_VDD2_5647 METAL5_266000_4353000 METAL5_269000_4353000 0.012
R_VDD2_5648 METAL5_269000_4353000 METAL5_269000_4365000 0.048
R_VDD2_5649 METAL5_269000_4365000 METAL5_269000_4377000 0.048
R_VDD2_5650 METAL5_269000_4377000 METAL5_266000_4377000 0.012
R_VDD2_5651 METAL5_266000_4377000 METAL5_264000_4377000 0.008
R_VDD2_5652 METAL5_264000_4377000 METAL5_258000_4377000 0.024
R_VDD2_5653 METAL5_258000_4377000 METAL5_257000_4377000 0.004
R_VDD2_5654 METAL5_257000_4377000 METAL6_257000_4377000 0.1
R_VDD2_5655 METAL6_257000_4377000 METAL6_257000_4389000 0.024
R_VDD2_5656 METAL6_257000_4389000 METAL6_257000_4453000 0.128
R_VDD2_5657 METAL6_257000_4453000 METAL6_257000_4465000 0.024
R_VDD2_5658 METAL6_555000_3765000 METAL6_543000_3765000 0.024
R_VDD2_5659 METAL6_350000_8000 METAL5_350000_8000 0.1
R_VDD2_5660 METAL5_350000_8000 METAL5_350000_20000 0.048
R_VDD2_5661 METAL5_350000_20000 METAL4_350000_20000 0.1
R_VDD2_5662 METAL4_350000_20000 METAL4_350000_32000 0.096
R_VDD2_5663 METAL4_350000_32000 METAL4_350000_44000 0.096
R_VDD2_5664 METAL4_350000_44000 METAL4_350000_45000 0.008
R_VDD2_5665 METAL4_350000_45000 METAL4_350000_56000 0.088
R_VDD2_5666 METAL4_350000_56000 METAL4_350000_57000 0.008
R_VDD2_5667 METAL4_350000_57000 METAL4_350000_68000 0.088
R_VDD2_5668 METAL4_350000_68000 METAL5_350000_68000 0.1
R_VDD2_5669 METAL5_350000_68000 METAL5_352000_68000 0.008
R_VDD2_5670 METAL5_352000_68000 METAL5_354000_68000 0.008
R_VDD2_5671 METAL5_354000_68000 METAL5_354000_69000 0.004
R_VDD2_5672 METAL5_354000_69000 METAL5_354000_80000 0.044
R_VDD2_5673 METAL5_354000_80000 METAL5_354000_81000 0.004
R_VDD2_5674 METAL5_354000_81000 METAL5_354000_93000 0.048
R_VDD2_5675 METAL5_354000_93000 METAL5_354000_105000 0.048
R_VDD2_5676 METAL5_354000_105000 METAL5_354000_117000 0.048
R_VDD2_5677 METAL5_354000_117000 METAL5_354000_121000 0.016
R_VDD2_5678 METAL5_354000_121000 METAL5_354000_129000 0.032
R_VDD2_5679 METAL5_354000_129000 METAL5_354000_133000 0.016
R_VDD2_5680 METAL5_354000_133000 METAL5_354000_141000 0.032
R_VDD2_5681 METAL5_354000_141000 METAL5_354000_145000 0.016
R_VDD2_5682 METAL5_354000_145000 METAL5_354000_153000 0.032
R_VDD2_5683 METAL5_354000_153000 METAL5_354000_157000 0.016
R_VDD2_5684 METAL5_354000_157000 METAL5_354000_165000 0.032
R_VDD2_5685 METAL5_354000_165000 METAL5_354000_169000 0.016
R_VDD2_5686 METAL5_354000_169000 METAL5_354000_177000 0.032
R_VDD2_5687 METAL5_354000_177000 METAL5_354000_181000 0.016
R_VDD2_5688 METAL5_354000_181000 METAL5_354000_193000 0.048
R_VDD2_5689 METAL5_354000_193000 METAL5_354000_205000 0.048
R_VDD2_5690 METAL5_354000_205000 METAL5_354000_217000 0.048
R_VDD2_5691 METAL5_354000_217000 METAL5_354000_229000 0.048
R_VDD2_5692 METAL5_354000_229000 METAL5_354000_233000 0.016
R_VDD2_5693 METAL5_354000_233000 METAL5_354000_241000 0.032
R_VDD2_5694 METAL5_354000_241000 METAL5_354000_245000 0.016
R_VDD2_5695 METAL5_354000_245000 METAL5_354000_253000 0.032
R_VDD2_5696 METAL5_354000_253000 METAL5_354000_257000 0.016
R_VDD2_5697 METAL5_354000_257000 METAL5_354000_265000 0.032
R_VDD2_5698 METAL5_354000_265000 METAL5_354000_269000 0.016
R_VDD2_5699 METAL5_354000_269000 METAL5_354000_277000 0.032
R_VDD2_5700 METAL5_354000_277000 METAL4_354000_277000 0.1
R_VDD2_5701 METAL4_354000_277000 METAL4_360000_277000 0.048
R_VDD2_5702 METAL4_360000_277000 METAL4_360000_281000 0.032
R_VDD2_5703 METAL4_360000_281000 METAL4_360000_289000 0.064
R_VDD2_5704 METAL4_360000_289000 METAL4_360000_293000 0.032
R_VDD2_5705 METAL4_360000_293000 METAL4_360000_301000 0.064
R_VDD2_5706 METAL4_360000_301000 METAL4_360000_305000 0.032
R_VDD2_5707 METAL4_360000_305000 METAL4_362000_305000 0.016
R_VDD2_5708 METAL4_362000_305000 METAL4_364000_305000 0.016
R_VDD2_5709 METAL4_364000_305000 METAL4_366000_305000 0.016
R_VDD2_5710 METAL4_366000_305000 METAL4_372000_305000 0.048
R_VDD2_5711 METAL4_372000_305000 METAL4_374000_305000 0.016
R_VDD2_5712 METAL4_374000_305000 METAL4_376000_305000 0.016
R_VDD2_5713 METAL4_376000_305000 METAL4_378000_305000 0.016
R_VDD2_5714 METAL4_378000_305000 METAL4_384000_305000 0.048
R_VDD2_5715 METAL4_384000_305000 METAL4_386000_305000 0.016
R_VDD2_5716 METAL4_386000_305000 METAL4_388000_305000 0.016
R_VDD2_5717 METAL4_388000_305000 METAL4_390000_305000 0.016
R_VDD2_5718 METAL4_390000_305000 METAL4_396000_305000 0.048
R_VDD2_5719 METAL4_396000_305000 METAL4_398000_305000 0.016
R_VDD2_5720 METAL4_398000_305000 METAL4_400000_305000 0.016
R_VDD2_5721 METAL4_400000_305000 METAL4_402000_305000 0.016
R_VDD2_5722 METAL4_402000_305000 METAL4_408000_305000 0.048
R_VDD2_5723 METAL4_408000_305000 METAL4_408000_313000 0.064
R_VDD2_5724 METAL4_408000_313000 METAL4_408000_317000 0.032
R_VDD2_5725 METAL4_408000_317000 METAL4_408000_329000 0.096
R_VDD2_5726 METAL4_408000_329000 METAL4_408000_341000 0.096
R_VDD2_5727 METAL4_408000_341000 METAL4_408000_353000 0.096
R_VDD2_5728 METAL4_408000_353000 METAL4_408000_365000 0.096
R_VDD2_5729 METAL4_408000_365000 METAL4_408000_377000 0.096
R_VDD2_5730 METAL4_408000_377000 METAL5_408000_377000 0.1
R_VDD2_5731 METAL5_408000_377000 METAL5_408000_389000 0.048
R_VDD2_5732 METAL5_408000_389000 METAL5_408000_401000 0.048
R_VDD2_5733 METAL5_408000_401000 METAL5_408000_417000 0.064
R_VDD2_5734 METAL5_408000_417000 METAL5_408000_429000 0.048
R_VDD2_5735 METAL5_408000_429000 METAL5_410000_429000 0.008
R_VDD2_5736 METAL5_410000_429000 METAL5_412000_429000 0.008
R_VDD2_5737 METAL5_412000_429000 METAL5_414000_429000 0.008
R_VDD2_5738 METAL5_414000_429000 METAL5_416000_429000 0.008
R_VDD2_5739 METAL5_416000_429000 METAL5_420000_429000 0.016
R_VDD2_5740 METAL5_420000_429000 METAL5_422000_429000 0.008
R_VDD2_5741 METAL5_422000_429000 METAL5_424000_429000 0.008
R_VDD2_5742 METAL5_424000_429000 METAL5_426000_429000 0.008
R_VDD2_5743 METAL5_426000_429000 METAL5_428000_429000 0.008
R_VDD2_5744 METAL5_428000_429000 METAL5_434000_429000 0.024
R_VDD2_5745 METAL5_434000_429000 METAL5_436000_429000 0.008
R_VDD2_5746 METAL5_436000_429000 METAL5_438000_429000 0.008
R_VDD2_5747 METAL5_438000_429000 METAL5_440000_429000 0.008
R_VDD2_5748 METAL5_440000_429000 METAL5_446000_429000 0.024
R_VDD2_5749 METAL5_446000_429000 METAL5_448000_429000 0.008
R_VDD2_5750 METAL5_448000_429000 METAL5_450000_429000 0.008
R_VDD2_5751 METAL5_450000_429000 METAL5_452000_429000 0.008
R_VDD2_5752 METAL5_452000_429000 METAL5_458000_429000 0.024
R_VDD2_5753 METAL5_458000_429000 METAL5_460000_429000 0.008
R_VDD2_5754 METAL5_460000_429000 METAL5_462000_429000 0.008
R_VDD2_5755 METAL5_462000_429000 METAL5_464000_429000 0.008
R_VDD2_5756 METAL5_464000_429000 METAL5_470000_429000 0.024
R_VDD2_5757 METAL5_470000_429000 METAL5_472000_429000 0.008
R_VDD2_5758 METAL5_472000_429000 METAL5_474000_429000 0.008
R_VDD2_5759 METAL5_474000_429000 METAL5_474000_441000 0.048
R_VDD2_5760 METAL5_474000_441000 METAL5_474000_453000 0.048
R_VDD2_5761 METAL5_474000_453000 METAL5_474000_465000 0.048
R_VDD2_5762 METAL5_474000_465000 METAL5_474000_469000 0.016
R_VDD2_5763 METAL5_474000_469000 METAL5_474000_477000 0.032
R_VDD2_5764 METAL5_474000_477000 METAL5_474000_481000 0.016
R_VDD2_5765 METAL5_474000_481000 METAL5_474000_489000 0.032
R_VDD2_5766 METAL5_474000_489000 METAL5_474000_493000 0.016
R_VDD2_5767 METAL5_474000_493000 METAL5_474000_501000 0.032
R_VDD2_5768 METAL5_474000_501000 METAL5_474000_505000 0.016
R_VDD2_5769 METAL5_474000_505000 METAL5_474000_517000 0.048
R_VDD2_5770 METAL5_474000_517000 METAL5_474000_529000 0.048
R_VDD2_5771 METAL5_474000_529000 METAL4_474000_529000 0.1
R_VDD2_5772 METAL4_474000_529000 METAL4_474000_541000 0.096
R_VDD2_5773 METAL4_474000_541000 METAL4_474000_553000 0.096
R_VDD2_5774 METAL4_474000_553000 METAL4_474000_565000 0.096
R_VDD2_5775 METAL4_474000_565000 METAL4_474000_577000 0.096
R_VDD2_5776 METAL4_474000_577000 METAL4_474000_589000 0.096
R_VDD2_5777 METAL4_474000_589000 METAL4_474000_601000 0.096
R_VDD2_5778 METAL4_474000_601000 METAL4_474000_613000 0.096
R_VDD2_5779 METAL4_474000_613000 METAL5_474000_613000 0.1
R_VDD2_5780 METAL5_474000_613000 METAL5_474000_625000 0.048
R_VDD2_5781 METAL5_474000_625000 METAL5_474000_681000 0.224
R_VDD2_5782 METAL5_474000_681000 METAL5_474000_693000 0.048
R_VDD2_5783 METAL5_474000_693000 METAL5_474000_705000 0.048
R_VDD2_5784 METAL5_474000_705000 METAL5_474000_707000 0.008
R_VDD2_5785 METAL5_474000_707000 METAL5_474000_717000 0.04
R_VDD2_5786 METAL5_474000_717000 METAL5_474000_769000 0.208
R_VDD2_5787 METAL5_474000_769000 METAL5_474000_781000 0.048
R_VDD2_5788 METAL5_474000_781000 METAL5_476000_781000 0.008
R_VDD2_5789 METAL5_476000_781000 METAL5_484000_781000 0.032
R_VDD2_5790 METAL5_484000_781000 METAL5_486000_781000 0.008
R_VDD2_5791 METAL5_486000_781000 METAL5_488000_781000 0.008
R_VDD2_5792 METAL5_488000_781000 METAL5_496000_781000 0.032
R_VDD2_5793 METAL5_496000_781000 METAL5_496000_793000 0.048
R_VDD2_5794 METAL5_496000_793000 METAL5_496000_805000 0.048
R_VDD2_5795 METAL5_496000_805000 METAL5_496000_817000 0.048
R_VDD2_5796 METAL5_496000_817000 METAL5_496000_829000 0.048
R_VDD2_5797 METAL5_496000_829000 METAL5_496000_841000 0.048
R_VDD2_5798 METAL5_496000_841000 METAL5_496000_853000 0.048
R_VDD2_5799 METAL5_496000_853000 METAL5_496000_865000 0.048
R_VDD2_5800 METAL5_496000_865000 METAL4_496000_865000 0.1
R_VDD2_5801 METAL4_496000_865000 METAL4_496000_869000 0.032
R_VDD2_5802 METAL4_496000_869000 METAL4_496000_877000 0.064
R_VDD2_5803 METAL4_496000_877000 METAL4_496000_881000 0.032
R_VDD2_5804 METAL4_496000_881000 METAL4_496000_889000 0.064
R_VDD2_5805 METAL4_496000_889000 METAL5_496000_889000 0.1
R_VDD2_5806 METAL5_496000_889000 METAL5_496000_893000 0.016
R_VDD2_5807 METAL5_496000_893000 METAL5_496000_901000 0.032
R_VDD2_5808 METAL5_496000_901000 METAL5_500000_901000 0.016
R_VDD2_5809 METAL5_500000_901000 METAL5_507000_901000 0.028
R_VDD2_5810 METAL5_507000_901000 METAL5_507000_905000 0.016
R_VDD2_5811 METAL5_507000_905000 METAL5_507000_917000 0.048
R_VDD2_5812 METAL5_507000_917000 METAL5_507000_929000 0.048
R_VDD2_5813 METAL5_507000_929000 METAL5_507000_941000 0.048
R_VDD2_5814 METAL5_507000_941000 METAL5_507000_953000 0.048
R_VDD2_5815 METAL5_507000_953000 METAL5_507000_965000 0.048
R_VDD2_5816 METAL5_507000_965000 METAL5_507000_977000 0.048
R_VDD2_5817 METAL5_507000_977000 METAL5_507000_989000 0.048
R_VDD2_5818 METAL5_507000_989000 METAL5_507000_1001000 0.048
R_VDD2_5819 METAL5_507000_1001000 METAL5_507000_1013000 0.048
R_VDD2_5820 METAL5_507000_1013000 METAL5_507000_1025000 0.048
R_VDD2_5821 METAL5_507000_1025000 METAL5_507000_1041000 0.064
R_VDD2_5822 METAL5_507000_1041000 METAL5_507000_1053000 0.048
R_VDD2_5823 METAL5_507000_1053000 METAL5_507000_1065000 0.048
R_VDD2_5824 METAL5_507000_1065000 METAL4_507000_1065000 0.1
R_VDD2_5825 METAL4_507000_1065000 METAL4_507000_1077000 0.096
R_VDD2_5826 METAL4_507000_1077000 METAL4_507000_1089000 0.096
R_VDD2_5827 METAL4_507000_1089000 METAL5_507000_1089000 0.1
R_VDD2_5828 METAL5_507000_1089000 METAL5_507000_1101000 0.048
R_VDD2_5829 METAL5_507000_1101000 METAL5_507000_1153000 0.208
R_VDD2_5830 METAL5_507000_1153000 METAL5_507000_1165000 0.048
R_VDD2_5831 METAL5_507000_1165000 METAL4_507000_1165000 0.1
R_VDD2_5832 METAL4_507000_1165000 METAL4_507000_1177000 0.096
R_VDD2_5833 METAL4_507000_1177000 METAL4_507000_1189000 0.096
R_VDD2_5834 METAL4_507000_1189000 METAL5_507000_1189000 0.1
R_VDD2_5835 METAL5_507000_1189000 METAL5_507000_1201000 0.048
R_VDD2_5836 METAL5_507000_1201000 METAL5_507000_1217000 0.064
R_VDD2_5837 METAL5_507000_1217000 METAL5_507000_1229000 0.048
R_VDD2_5838 METAL5_507000_1229000 METAL5_507000_1241000 0.048
R_VDD2_5839 METAL5_507000_1241000 METAL5_507000_1253000 0.048
R_VDD2_5840 METAL5_507000_1253000 METAL5_507000_1265000 0.048
R_VDD2_5841 METAL5_507000_1265000 METAL5_507000_1277000 0.048
R_VDD2_5842 METAL5_507000_1277000 METAL5_507000_1289000 0.048
R_VDD2_5843 METAL5_507000_1289000 METAL5_507000_1357000 0.272
R_VDD2_5844 METAL5_507000_1357000 METAL5_507000_1369000 0.048
R_VDD2_5845 METAL5_507000_1369000 METAL4_507000_1369000 0.1
R_VDD2_5846 METAL4_507000_1369000 METAL4_507000_1381000 0.096
R_VDD2_5847 METAL4_507000_1381000 METAL4_507000_1393000 0.096
R_VDD2_5848 METAL4_507000_1393000 METAL5_507000_1393000 0.1
R_VDD2_5849 METAL5_507000_1393000 METAL5_507000_1405000 0.048
R_VDD2_5850 METAL5_507000_1405000 METAL5_507000_1407000 0.008
R_VDD2_5851 METAL5_507000_1407000 METAL5_507000_1417000 0.04
R_VDD2_5852 METAL5_507000_1417000 METAL5_507000_1529000 0.448
R_VDD2_5853 METAL5_507000_1529000 METAL5_507000_1541000 0.048
R_VDD2_5854 METAL5_507000_1541000 METAL5_507000_1553000 0.048
R_VDD2_5855 METAL5_507000_1553000 METAL5_507000_1565000 0.048
R_VDD2_5856 METAL5_507000_1565000 METAL5_507000_1577000 0.048
R_VDD2_5857 METAL5_507000_1577000 METAL5_507000_1617000 0.16
R_VDD2_5858 METAL5_507000_1617000 METAL5_507000_1629000 0.048
R_VDD2_5859 METAL5_507000_1629000 METAL5_507000_1641000 0.048
R_VDD2_5860 METAL5_507000_1641000 METAL5_507000_1653000 0.048
R_VDD2_5861 METAL5_507000_1653000 METAL5_507000_1665000 0.048
R_VDD2_5862 METAL5_507000_1665000 METAL5_507000_1677000 0.048
R_VDD2_5863 METAL5_507000_1677000 METAL5_507000_1689000 0.048
R_VDD2_5864 METAL5_507000_1689000 METAL5_507000_1753000 0.256
R_VDD2_5865 METAL5_507000_1753000 METAL5_507000_1765000 0.048
R_VDD2_5866 METAL5_507000_1765000 METAL5_507000_1777000 0.048
R_VDD2_5867 METAL5_507000_1777000 METAL5_507000_1789000 0.048
R_VDD2_5868 METAL5_507000_1789000 METAL5_507000_1817000 0.112
R_VDD2_5869 METAL5_507000_1817000 METAL5_507000_1829000 0.048
R_VDD2_5870 METAL5_507000_1829000 METAL5_507000_1841000 0.048
R_VDD2_5871 METAL5_507000_1841000 METAL5_507000_1853000 0.048
R_VDD2_5872 METAL5_507000_1853000 METAL5_507000_1865000 0.048
R_VDD2_5873 METAL5_507000_1865000 METAL5_507000_1877000 0.048
R_VDD2_5874 METAL5_507000_1877000 METAL5_507000_1905000 0.112
R_VDD2_5875 METAL5_507000_1905000 METAL5_507000_1917000 0.048
R_VDD2_5876 METAL5_507000_1917000 METAL5_507000_1929000 0.048
R_VDD2_5877 METAL5_507000_1929000 METAL4_507000_1929000 0.1
R_VDD2_5878 METAL4_507000_1929000 METAL4_507000_1941000 0.096
R_VDD2_5879 METAL4_507000_1941000 METAL4_507000_1953000 0.096
R_VDD2_5880 METAL4_507000_1953000 METAL4_507000_1965000 0.096
R_VDD2_5881 METAL4_507000_1965000 METAL4_507000_1977000 0.096
R_VDD2_5882 METAL4_507000_1977000 METAL4_507000_1989000 0.096
R_VDD2_5883 METAL4_507000_1989000 METAL5_507000_1989000 0.1
R_VDD2_5884 METAL5_507000_1989000 METAL5_507000_2001000 0.048
R_VDD2_5885 METAL5_507000_2001000 METAL5_507000_2013000 0.048
R_VDD2_5886 METAL5_507000_2013000 METAL5_507000_2093000 0.32
R_VDD2_5887 METAL5_507000_2093000 METAL5_507000_2107000 0.056
R_VDD2_5888 METAL5_507000_2107000 METAL5_507000_2217000 0.44
R_VDD2_5889 METAL5_507000_2217000 METAL5_507000_2229000 0.048
R_VDD2_5890 METAL5_507000_2229000 METAL5_507000_2241000 0.048
R_VDD2_5891 METAL5_507000_2241000 METAL5_507000_2253000 0.048
R_VDD2_5892 METAL5_507000_2253000 METAL5_507000_2265000 0.048
R_VDD2_5893 METAL5_507000_2265000 METAL5_507000_2277000 0.048
R_VDD2_5894 METAL5_507000_2277000 METAL5_507000_2341000 0.256
R_VDD2_5895 METAL5_507000_2341000 METAL5_507000_2353000 0.048
R_VDD2_5896 METAL5_507000_2353000 METAL5_507000_2365000 0.048
R_VDD2_5897 METAL5_507000_2365000 METAL4_507000_2365000 0.1
R_VDD2_5898 METAL4_507000_2365000 METAL4_507000_2377000 0.096
R_VDD2_5899 METAL4_507000_2377000 METAL4_507000_2389000 0.096
R_VDD2_5900 METAL4_507000_2389000 METAL5_507000_2389000 0.1
R_VDD2_5901 METAL5_507000_2389000 METAL5_507000_2453000 0.256
R_VDD2_5902 METAL5_507000_2453000 METAL5_507000_2465000 0.048
R_VDD2_5903 METAL5_507000_2465000 METAL5_507000_2477000 0.048
R_VDD2_5904 METAL5_507000_2477000 METAL5_507000_2489000 0.048
R_VDD2_5905 METAL5_507000_2489000 METAL5_507000_2553000 0.256
R_VDD2_5906 METAL5_507000_2553000 METAL5_507000_2565000 0.048
R_VDD2_5907 METAL5_507000_2565000 METAL5_507000_2577000 0.048
R_VDD2_5908 METAL5_507000_2577000 METAL5_507000_2605000 0.112
R_VDD2_5909 METAL5_507000_2605000 METAL5_507000_2617000 0.048
R_VDD2_5910 METAL5_507000_2617000 METAL5_507000_2629000 0.048
R_VDD2_5911 METAL5_507000_2629000 METAL5_507000_2641000 0.048
R_VDD2_5912 METAL5_507000_2641000 METAL5_507000_2653000 0.048
R_VDD2_5913 METAL5_507000_2653000 METAL4_507000_2653000 0.1
R_VDD2_5914 METAL4_507000_2653000 METAL4_507000_2665000 0.096
R_VDD2_5915 METAL4_507000_2665000 METAL4_507000_2677000 0.096
R_VDD2_5916 METAL4_507000_2677000 METAL4_507000_2689000 0.096
R_VDD2_5917 METAL4_507000_2689000 METAL4_507000_2701000 0.096
R_VDD2_5918 METAL4_507000_2701000 METAL5_507000_2701000 0.1
R_VDD2_5919 METAL5_507000_2701000 METAL5_507000_2713000 0.048
R_VDD2_5920 METAL5_507000_2713000 METAL5_507000_2769000 0.224
R_VDD2_5921 METAL5_507000_2769000 METAL5_507000_2781000 0.048
R_VDD2_5922 METAL5_507000_2781000 METAL5_507000_2793000 0.048
R_VDD2_5923 METAL5_507000_2793000 METAL5_507000_2805000 0.048
R_VDD2_5924 METAL5_507000_2805000 METAL5_507000_2807000 0.008
R_VDD2_5925 METAL5_507000_2807000 METAL5_507000_2817000 0.04
R_VDD2_5926 METAL5_507000_2817000 METAL5_507000_2941000 0.496
R_VDD2_5927 METAL5_507000_2941000 METAL5_507000_2953000 0.048
R_VDD2_5928 METAL5_507000_2953000 METAL5_507000_2965000 0.048
R_VDD2_5929 METAL5_507000_2965000 METAL5_507000_2977000 0.048
R_VDD2_5930 METAL5_507000_2977000 METAL5_507000_2989000 0.048
R_VDD2_5931 METAL5_507000_2989000 METAL5_507000_3001000 0.048
R_VDD2_5932 METAL5_507000_3001000 METAL5_507000_3053000 0.208
R_VDD2_5933 METAL5_507000_3053000 METAL5_507000_3065000 0.048
R_VDD2_5934 METAL5_507000_3065000 METAL4_507000_3065000 0.1
R_VDD2_5935 METAL4_507000_3065000 METAL4_507000_3077000 0.096
R_VDD2_5936 METAL4_507000_3077000 METAL4_507000_3089000 0.096
R_VDD2_5937 METAL4_507000_3089000 METAL5_507000_3089000 0.1
R_VDD2_5938 METAL5_507000_3089000 METAL5_507000_3153000 0.256
R_VDD2_5939 METAL5_507000_3153000 METAL5_507000_3165000 0.048
R_VDD2_5940 METAL5_507000_3165000 METAL5_507000_3177000 0.048
R_VDD2_5941 METAL5_507000_3177000 METAL5_507000_3189000 0.048
R_VDD2_5942 METAL5_507000_3189000 METAL5_507000_3253000 0.256
R_VDD2_5943 METAL5_507000_3253000 METAL5_507000_3265000 0.048
R_VDD2_5944 METAL5_507000_3265000 METAL5_507000_3277000 0.048
R_VDD2_5945 METAL5_507000_3277000 METAL5_507000_3289000 0.048
R_VDD2_5946 METAL5_507000_3289000 METAL5_507000_3341000 0.208
R_VDD2_5947 METAL5_507000_3341000 METAL5_507000_3353000 0.048
R_VDD2_5948 METAL5_507000_3353000 METAL4_507000_3353000 0.1
R_VDD2_5949 METAL4_507000_3353000 METAL4_507000_3365000 0.096
R_VDD2_5950 METAL4_507000_3365000 METAL4_507000_3377000 0.096
R_VDD2_5951 METAL4_507000_3377000 METAL4_507000_3389000 0.096
R_VDD2_5952 METAL4_507000_3389000 METAL4_507000_3401000 0.096
R_VDD2_5953 METAL4_507000_3401000 METAL4_507000_3413000 0.096
R_VDD2_5954 METAL4_507000_3413000 METAL5_507000_3413000 0.1
R_VDD2_5955 METAL5_507000_3413000 METAL5_507000_3425000 0.048
R_VDD2_5956 METAL5_507000_3425000 METAL5_507000_3493000 0.272
R_VDD2_5957 METAL5_507000_3493000 METAL5_512000_3493000 0.02
R_VDD2_5958 METAL5_512000_3493000 METAL5_519000_3493000 0.028
R_VDD2_5959 METAL5_519000_3493000 METAL5_519000_3495000 0.008
R_VDD2_5960 METAL5_519000_3495000 METAL5_519000_3507000 0.048
R_VDD2_5961 METAL5_519000_3507000 METAL5_519000_3519000 0.048
R_VDD2_5962 METAL5_519000_3519000 METAL5_519000_3641000 0.488
R_VDD2_5963 METAL5_519000_3641000 METAL5_519000_3653000 0.048
R_VDD2_5964 METAL5_519000_3653000 METAL5_519000_3665000 0.048
R_VDD2_5965 METAL5_519000_3665000 METAL5_519000_3677000 0.048
R_VDD2_5966 METAL5_519000_3677000 METAL4_519000_3677000 0.1
R_VDD2_5967 METAL4_519000_3677000 METAL4_524000_3677000 0.04
R_VDD2_5968 METAL4_524000_3677000 METAL4_531000_3677000 0.056
R_VDD2_5969 METAL4_531000_3677000 METAL4_543000_3677000 0.096
R_VDD2_5970 METAL4_543000_3677000 METAL5_543000_3677000 0.1
R_VDD2_5971 METAL5_543000_3677000 METAL6_543000_3677000 0.1
R_VDD2_5972 METAL6_543000_3677000 METAL6_543000_3753000 0.152
R_VDD2_5973 METAL6_543000_3753000 METAL6_543000_3765000 0.024
R_VDD2_5974 METAL6_245000_3765000 METAL6_257000_3765000 0.024
R_VDD2_5975 METAL5_350000_8000 METAL5_348000_8000 0.008
R_VDD2_5976 METAL5_348000_8000 METAL5_342000_8000 0.024
R_VDD2_5977 METAL5_342000_8000 METAL5_340000_8000 0.008
R_VDD2_5978 METAL5_340000_8000 METAL5_338000_8000 0.008
R_VDD2_5979 METAL5_338000_8000 METAL5_338000_20000 0.048
R_VDD2_5980 METAL5_338000_20000 METAL5_338000_32000 0.048
R_VDD2_5981 METAL5_338000_32000 METAL4_338000_32000 0.1
R_VDD2_5982 METAL4_338000_32000 METAL4_338000_44000 0.096
R_VDD2_5983 METAL4_338000_44000 METAL4_338000_45000 0.008
R_VDD2_5984 METAL4_338000_45000 METAL4_338000_56000 0.088
R_VDD2_5985 METAL4_338000_56000 METAL4_338000_57000 0.008
R_VDD2_5986 METAL4_338000_57000 METAL4_338000_68000 0.088
R_VDD2_5987 METAL4_338000_68000 METAL5_338000_68000 0.1
R_VDD2_5988 METAL5_338000_68000 METAL5_338000_69000 0.004
R_VDD2_5989 METAL5_338000_69000 METAL5_338000_80000 0.044
R_VDD2_5990 METAL5_338000_80000 METAL5_340000_80000 0.008
R_VDD2_5991 METAL5_340000_80000 METAL5_342000_80000 0.008
R_VDD2_5992 METAL5_342000_80000 METAL5_342000_81000 0.004
R_VDD2_5993 METAL5_342000_81000 METAL5_342000_93000 0.048
R_VDD2_5994 METAL5_342000_93000 METAL5_342000_105000 0.048
R_VDD2_5995 METAL5_342000_105000 METAL5_342000_117000 0.048
R_VDD2_5996 METAL5_342000_117000 METAL5_342000_121000 0.016
R_VDD2_5997 METAL5_342000_121000 METAL5_342000_129000 0.032
R_VDD2_5998 METAL5_342000_129000 METAL5_342000_133000 0.016
R_VDD2_5999 METAL5_342000_133000 METAL5_342000_141000 0.032
R_VDD2_6000 METAL5_342000_141000 METAL5_342000_145000 0.016
R_VDD2_6001 METAL5_342000_145000 METAL5_342000_153000 0.032
R_VDD2_6002 METAL5_342000_153000 METAL5_342000_157000 0.016
R_VDD2_6003 METAL5_342000_157000 METAL5_342000_165000 0.032
R_VDD2_6004 METAL5_342000_165000 METAL5_342000_169000 0.016
R_VDD2_6005 METAL5_342000_169000 METAL5_342000_177000 0.032
R_VDD2_6006 METAL5_342000_177000 METAL5_342000_181000 0.016
R_VDD2_6007 METAL5_342000_181000 METAL5_342000_193000 0.048
R_VDD2_6008 METAL5_342000_193000 METAL5_342000_205000 0.048
R_VDD2_6009 METAL5_342000_205000 METAL5_342000_217000 0.048
R_VDD2_6010 METAL5_342000_217000 METAL5_342000_229000 0.048
R_VDD2_6011 METAL5_342000_229000 METAL5_342000_233000 0.016
R_VDD2_6012 METAL5_342000_233000 METAL5_342000_241000 0.032
R_VDD2_6013 METAL5_342000_241000 METAL4_342000_241000 0.1
R_VDD2_6014 METAL4_342000_241000 METAL4_342000_245000 0.032
R_VDD2_6015 METAL4_342000_245000 METAL4_342000_253000 0.064
R_VDD2_6016 METAL4_342000_253000 METAL4_342000_257000 0.032
R_VDD2_6017 METAL4_342000_257000 METAL4_342000_265000 0.064
R_VDD2_6018 METAL4_342000_265000 METAL4_342000_269000 0.032
R_VDD2_6019 METAL4_342000_269000 METAL4_342000_277000 0.064
R_VDD2_6020 METAL4_342000_277000 METAL4_342000_281000 0.032
R_VDD2_6021 METAL4_342000_281000 METAL4_342000_289000 0.064
R_VDD2_6022 METAL4_342000_289000 METAL4_342000_293000 0.032
R_VDD2_6023 METAL4_342000_293000 METAL4_342000_301000 0.064
R_VDD2_6024 METAL4_342000_301000 METAL4_342000_305000 0.032
R_VDD2_6025 METAL4_342000_305000 METAL4_342000_313000 0.064
R_VDD2_6026 METAL4_342000_313000 METAL4_342000_317000 0.032
R_VDD2_6027 METAL4_342000_317000 METAL4_342000_329000 0.096
R_VDD2_6028 METAL4_342000_329000 METAL4_342000_341000 0.096
R_VDD2_6029 METAL4_342000_341000 METAL4_342000_353000 0.096
R_VDD2_6030 METAL4_342000_353000 METAL4_342000_365000 0.096
R_VDD2_6031 METAL4_342000_365000 METAL4_342000_377000 0.096
R_VDD2_6032 METAL4_342000_377000 METAL4_342000_389000 0.096
R_VDD2_6033 METAL4_342000_389000 METAL5_342000_389000 0.1
R_VDD2_6034 METAL5_342000_389000 METAL5_342000_401000 0.048
R_VDD2_6035 METAL5_342000_401000 METAL5_342000_417000 0.064
R_VDD2_6036 METAL5_342000_417000 METAL5_348000_417000 0.024
R_VDD2_6037 METAL5_348000_417000 METAL5_348000_429000 0.048
R_VDD2_6038 METAL5_348000_429000 METAL5_350000_429000 0.008
R_VDD2_6039 METAL5_350000_429000 METAL5_352000_429000 0.008
R_VDD2_6040 METAL5_352000_429000 METAL5_354000_429000 0.008
R_VDD2_6041 METAL5_354000_429000 METAL5_360000_429000 0.024
R_VDD2_6042 METAL5_360000_429000 METAL5_362000_429000 0.008
R_VDD2_6043 METAL5_362000_429000 METAL5_364000_429000 0.008
R_VDD2_6044 METAL5_364000_429000 METAL5_366000_429000 0.008
R_VDD2_6045 METAL5_366000_429000 METAL5_372000_429000 0.024
R_VDD2_6046 METAL5_372000_429000 METAL4_372000_429000 0.1
R_VDD2_6047 METAL4_372000_429000 METAL4_374000_429000 0.016
R_VDD2_6048 METAL4_374000_429000 METAL4_376000_429000 0.016
R_VDD2_6049 METAL4_376000_429000 METAL4_378000_429000 0.016
R_VDD2_6050 METAL4_378000_429000 METAL4_384000_429000 0.048
R_VDD2_6051 METAL4_384000_429000 METAL4_386000_429000 0.016
R_VDD2_6052 METAL4_386000_429000 METAL4_388000_429000 0.016
R_VDD2_6053 METAL4_388000_429000 METAL4_390000_429000 0.016
R_VDD2_6054 METAL4_390000_429000 METAL4_396000_429000 0.048
R_VDD2_6055 METAL4_396000_429000 METAL4_396000_441000 0.096
R_VDD2_6056 METAL4_396000_441000 METAL4_396000_453000 0.096
R_VDD2_6057 METAL4_396000_453000 METAL4_398000_453000 0.016
R_VDD2_6058 METAL4_398000_453000 METAL4_400000_453000 0.016
R_VDD2_6059 METAL4_400000_453000 METAL4_402000_453000 0.016
R_VDD2_6060 METAL4_402000_453000 METAL4_408000_453000 0.048
R_VDD2_6061 METAL4_408000_453000 METAL4_408000_465000 0.096
R_VDD2_6062 METAL4_408000_465000 METAL4_408000_469000 0.032
R_VDD2_6063 METAL4_408000_469000 METAL4_408000_477000 0.064
R_VDD2_6064 METAL4_408000_477000 METAL5_408000_477000 0.1
R_VDD2_6065 METAL5_408000_477000 METAL5_408000_481000 0.016
R_VDD2_6066 METAL5_408000_481000 METAL5_408000_489000 0.032
R_VDD2_6067 METAL5_408000_489000 METAL5_408000_493000 0.016
R_VDD2_6068 METAL5_408000_493000 METAL5_408000_501000 0.032
R_VDD2_6069 METAL5_408000_501000 METAL5_408000_505000 0.016
R_VDD2_6070 METAL5_408000_505000 METAL5_408000_517000 0.048
R_VDD2_6071 METAL5_408000_517000 METAL5_408000_529000 0.048
R_VDD2_6072 METAL5_408000_529000 METAL5_408000_541000 0.048
R_VDD2_6073 METAL5_408000_541000 METAL5_408000_553000 0.048
R_VDD2_6074 METAL5_408000_553000 METAL5_410000_553000 0.008
R_VDD2_6075 METAL5_410000_553000 METAL5_412000_553000 0.008
R_VDD2_6076 METAL5_412000_553000 METAL5_414000_553000 0.008
R_VDD2_6077 METAL5_414000_553000 METAL5_416000_553000 0.008
R_VDD2_6078 METAL5_416000_553000 METAL5_420000_553000 0.016
R_VDD2_6079 METAL5_420000_553000 METAL5_422000_553000 0.008
R_VDD2_6080 METAL5_422000_553000 METAL5_424000_553000 0.008
R_VDD2_6081 METAL5_424000_553000 METAL5_424000_565000 0.048
R_VDD2_6082 METAL5_424000_565000 METAL4_424000_565000 0.1
R_VDD2_6083 METAL4_424000_565000 METAL4_424000_577000 0.096
R_VDD2_6084 METAL4_424000_577000 METAL4_424000_589000 0.096
R_VDD2_6085 METAL4_424000_589000 METAL4_424000_601000 0.096
R_VDD2_6086 METAL4_424000_601000 METAL5_424000_601000 0.1
R_VDD2_6087 METAL5_424000_601000 METAL5_424000_613000 0.048
R_VDD2_6088 METAL5_424000_613000 METAL5_424000_625000 0.048
R_VDD2_6089 METAL5_424000_625000 METAL5_424000_681000 0.224
R_VDD2_6090 METAL5_424000_681000 METAL5_424000_693000 0.048
R_VDD2_6091 METAL5_424000_693000 METAL5_424000_705000 0.048
R_VDD2_6092 METAL5_424000_705000 METAL5_426000_705000 0.008
R_VDD2_6093 METAL5_426000_705000 METAL5_428000_705000 0.008
R_VDD2_6094 METAL5_428000_705000 METAL5_434000_705000 0.024
R_VDD2_6095 METAL5_434000_705000 METAL5_436000_705000 0.008
R_VDD2_6096 METAL5_436000_705000 METAL6_436000_705000 0.1
R_VDD2_6097 METAL6_436000_705000 METAL6_436000_707000 0.004
R_VDD2_6098 METAL6_436000_707000 METAL6_436000_717000 0.02
R_VDD2_6099 METAL6_436000_717000 METAL6_436000_769000 0.104
R_VDD2_6100 METAL6_436000_769000 METAL6_436000_781000 0.024
R_VDD2_6101 METAL6_436000_781000 METAL6_436000_793000 0.024
R_VDD2_6102 METAL6_436000_793000 METAL6_436000_805000 0.024
R_VDD2_6103 METAL6_436000_805000 METAL6_438000_805000 0.004
R_VDD2_6104 METAL6_438000_805000 METAL5_438000_805000 0.1
R_VDD2_6105 METAL5_438000_805000 METAL4_438000_805000 0.1
R_VDD2_6106 METAL4_438000_805000 METAL4_438000_817000 0.096
R_VDD2_6107 METAL4_438000_817000 METAL4_438000_829000 0.096
R_VDD2_6108 METAL4_438000_829000 METAL4_438000_841000 0.096
R_VDD2_6109 METAL4_438000_841000 METAL4_438000_853000 0.096
R_VDD2_6110 METAL4_438000_853000 METAL4_438000_865000 0.096
R_VDD2_6111 METAL4_438000_865000 METAL4_438000_869000 0.032
R_VDD2_6112 METAL4_438000_869000 METAL4_438000_877000 0.064
R_VDD2_6113 METAL4_438000_877000 METAL4_438000_881000 0.032
R_VDD2_6114 METAL4_438000_881000 METAL4_438000_889000 0.064
R_VDD2_6115 METAL4_438000_889000 METAL5_438000_889000 0.1
R_VDD2_6116 METAL5_438000_889000 METAL5_438000_893000 0.016
R_VDD2_6117 METAL5_438000_893000 METAL5_438000_901000 0.032
R_VDD2_6118 METAL5_438000_901000 METAL5_438000_905000 0.016
R_VDD2_6119 METAL5_438000_905000 METAL5_438000_913000 0.032
R_VDD2_6120 METAL5_438000_913000 METAL5_438000_917000 0.016
R_VDD2_6121 METAL5_438000_917000 METAL5_438000_929000 0.048
R_VDD2_6122 METAL5_438000_929000 METAL5_438000_941000 0.048
R_VDD2_6123 METAL5_438000_941000 METAL5_438000_953000 0.048
R_VDD2_6124 METAL5_438000_953000 METAL5_440000_953000 0.008
R_VDD2_6125 METAL5_440000_953000 METAL5_446000_953000 0.024
R_VDD2_6126 METAL5_446000_953000 METAL5_446000_965000 0.048
R_VDD2_6127 METAL5_446000_965000 METAL5_446000_977000 0.048
R_VDD2_6128 METAL5_446000_977000 METAL5_446000_989000 0.048
R_VDD2_6129 METAL5_446000_989000 METAL5_446000_1001000 0.048
R_VDD2_6130 METAL5_446000_1001000 METAL5_446000_1013000 0.048
R_VDD2_6131 METAL5_446000_1013000 METAL5_446000_1025000 0.048
R_VDD2_6132 METAL5_446000_1025000 METAL5_446000_1041000 0.064
R_VDD2_6133 METAL5_446000_1041000 METAL5_446000_1053000 0.048
R_VDD2_6134 METAL5_446000_1053000 METAL5_446000_1065000 0.048
R_VDD2_6135 METAL5_446000_1065000 METAL4_446000_1065000 0.1
R_VDD2_6136 METAL4_446000_1065000 METAL4_446000_1077000 0.096
R_VDD2_6137 METAL4_446000_1077000 METAL4_446000_1089000 0.096
R_VDD2_6138 METAL4_446000_1089000 METAL5_446000_1089000 0.1
R_VDD2_6139 METAL5_446000_1089000 METAL5_446000_1101000 0.048
R_VDD2_6140 METAL5_446000_1101000 METAL5_446000_1153000 0.208
R_VDD2_6141 METAL5_446000_1153000 METAL5_446000_1165000 0.048
R_VDD2_6142 METAL5_446000_1165000 METAL4_446000_1165000 0.1
R_VDD2_6143 METAL4_446000_1165000 METAL4_446000_1177000 0.096
R_VDD2_6144 METAL4_446000_1177000 METAL4_446000_1189000 0.096
R_VDD2_6145 METAL4_446000_1189000 METAL5_446000_1189000 0.1
R_VDD2_6146 METAL5_446000_1189000 METAL5_446000_1201000 0.048
R_VDD2_6147 METAL5_446000_1201000 METAL5_446000_1217000 0.064
R_VDD2_6148 METAL5_446000_1217000 METAL5_448000_1217000 0.008
R_VDD2_6149 METAL5_448000_1217000 METAL5_450000_1217000 0.008
R_VDD2_6150 METAL5_450000_1217000 METAL5_452000_1217000 0.008
R_VDD2_6151 METAL5_452000_1217000 METAL5_458000_1217000 0.024
R_VDD2_6152 METAL5_458000_1217000 METAL5_460000_1217000 0.008
R_VDD2_6153 METAL5_460000_1217000 METAL5_462000_1217000 0.008
R_VDD2_6154 METAL5_462000_1217000 METAL5_464000_1217000 0.008
R_VDD2_6155 METAL5_464000_1217000 METAL5_470000_1217000 0.024
R_VDD2_6156 METAL5_470000_1217000 METAL5_470000_1229000 0.048
R_VDD2_6157 METAL5_470000_1229000 METAL5_470000_1241000 0.048
R_VDD2_6158 METAL5_470000_1241000 METAL5_470000_1253000 0.048
R_VDD2_6159 METAL5_470000_1253000 METAL5_470000_1265000 0.048
R_VDD2_6160 METAL5_470000_1265000 METAL5_470000_1277000 0.048
R_VDD2_6161 METAL5_470000_1277000 METAL5_470000_1289000 0.048
R_VDD2_6162 METAL5_470000_1289000 METAL5_470000_1357000 0.272
R_VDD2_6163 METAL5_470000_1357000 METAL5_470000_1369000 0.048
R_VDD2_6164 METAL5_470000_1369000 METAL4_470000_1369000 0.1
R_VDD2_6165 METAL4_470000_1369000 METAL4_470000_1381000 0.096
R_VDD2_6166 METAL4_470000_1381000 METAL4_470000_1393000 0.096
R_VDD2_6167 METAL4_470000_1393000 METAL5_470000_1393000 0.1
R_VDD2_6168 METAL5_470000_1393000 METAL5_470000_1405000 0.048
R_VDD2_6169 METAL5_470000_1405000 METAL5_470000_1407000 0.008
R_VDD2_6170 METAL5_470000_1407000 METAL5_470000_1417000 0.04
R_VDD2_6171 METAL5_470000_1417000 METAL5_470000_1529000 0.448
R_VDD2_6172 METAL5_470000_1529000 METAL5_470000_1541000 0.048
R_VDD2_6173 METAL5_470000_1541000 METAL5_470000_1553000 0.048
R_VDD2_6174 METAL5_470000_1553000 METAL5_470000_1565000 0.048
R_VDD2_6175 METAL5_470000_1565000 METAL5_470000_1577000 0.048
R_VDD2_6176 METAL5_470000_1577000 METAL5_470000_1617000 0.16
R_VDD2_6177 METAL5_470000_1617000 METAL5_470000_1629000 0.048
R_VDD2_6178 METAL5_470000_1629000 METAL5_470000_1641000 0.048
R_VDD2_6179 METAL5_470000_1641000 METAL5_470000_1653000 0.048
R_VDD2_6180 METAL5_470000_1653000 METAL5_470000_1665000 0.048
R_VDD2_6181 METAL5_470000_1665000 METAL5_470000_1677000 0.048
R_VDD2_6182 METAL5_470000_1677000 METAL5_470000_1689000 0.048
R_VDD2_6183 METAL5_470000_1689000 METAL5_470000_1753000 0.256
R_VDD2_6184 METAL5_470000_1753000 METAL5_470000_1765000 0.048
R_VDD2_6185 METAL5_470000_1765000 METAL5_470000_1777000 0.048
R_VDD2_6186 METAL5_470000_1777000 METAL5_470000_1789000 0.048
R_VDD2_6187 METAL5_470000_1789000 METAL5_470000_1817000 0.112
R_VDD2_6188 METAL5_470000_1817000 METAL5_470000_1829000 0.048
R_VDD2_6189 METAL5_470000_1829000 METAL5_470000_1841000 0.048
R_VDD2_6190 METAL5_470000_1841000 METAL5_470000_1853000 0.048
R_VDD2_6191 METAL5_470000_1853000 METAL5_470000_1865000 0.048
R_VDD2_6192 METAL5_470000_1865000 METAL5_470000_1877000 0.048
R_VDD2_6193 METAL5_470000_1877000 METAL5_470000_1905000 0.112
R_VDD2_6194 METAL5_470000_1905000 METAL5_470000_1917000 0.048
R_VDD2_6195 METAL5_470000_1917000 METAL5_470000_1929000 0.048
R_VDD2_6196 METAL5_470000_1929000 METAL4_470000_1929000 0.1
R_VDD2_6197 METAL4_470000_1929000 METAL4_470000_1941000 0.096
R_VDD2_6198 METAL4_470000_1941000 METAL4_470000_1953000 0.096
R_VDD2_6199 METAL4_470000_1953000 METAL4_470000_1965000 0.096
R_VDD2_6200 METAL4_470000_1965000 METAL4_470000_1977000 0.096
R_VDD2_6201 METAL4_470000_1977000 METAL4_470000_1989000 0.096
R_VDD2_6202 METAL4_470000_1989000 METAL5_470000_1989000 0.1
R_VDD2_6203 METAL5_470000_1989000 METAL5_470000_2001000 0.048
R_VDD2_6204 METAL5_470000_2001000 METAL5_470000_2013000 0.048
R_VDD2_6205 METAL5_470000_2013000 METAL5_470000_2093000 0.32
R_VDD2_6206 METAL5_470000_2093000 METAL5_470000_2107000 0.056
R_VDD2_6207 METAL5_470000_2107000 METAL5_470000_2217000 0.44
R_VDD2_6208 METAL5_470000_2217000 METAL5_470000_2229000 0.048
R_VDD2_6209 METAL5_470000_2229000 METAL5_470000_2241000 0.048
R_VDD2_6210 METAL5_470000_2241000 METAL5_470000_2253000 0.048
R_VDD2_6211 METAL5_470000_2253000 METAL5_470000_2265000 0.048
R_VDD2_6212 METAL5_470000_2265000 METAL5_470000_2277000 0.048
R_VDD2_6213 METAL5_470000_2277000 METAL5_470000_2341000 0.256
R_VDD2_6214 METAL5_470000_2341000 METAL5_470000_2353000 0.048
R_VDD2_6215 METAL5_470000_2353000 METAL5_470000_2365000 0.048
R_VDD2_6216 METAL5_470000_2365000 METAL5_470000_2377000 0.048
R_VDD2_6217 METAL5_470000_2377000 METAL5_470000_2389000 0.048
R_VDD2_6218 METAL5_470000_2389000 METAL5_470000_2401000 0.048
R_VDD2_6219 METAL5_470000_2401000 METAL5_470000_2453000 0.208
R_VDD2_6220 METAL5_470000_2453000 METAL5_470000_2465000 0.048
R_VDD2_6221 METAL5_470000_2465000 METAL5_470000_2477000 0.048
R_VDD2_6222 METAL5_470000_2477000 METAL5_470000_2489000 0.048
R_VDD2_6223 METAL5_470000_2489000 METAL5_470000_2553000 0.256
R_VDD2_6224 METAL5_470000_2553000 METAL5_470000_2565000 0.048
R_VDD2_6225 METAL5_470000_2565000 METAL5_470000_2577000 0.048
R_VDD2_6226 METAL5_470000_2577000 METAL5_470000_2605000 0.112
R_VDD2_6227 METAL5_470000_2605000 METAL5_470000_2617000 0.048
R_VDD2_6228 METAL5_470000_2617000 METAL5_470000_2629000 0.048
R_VDD2_6229 METAL5_470000_2629000 METAL5_470000_2641000 0.048
R_VDD2_6230 METAL5_470000_2641000 METAL5_470000_2653000 0.048
R_VDD2_6231 METAL5_470000_2653000 METAL5_464000_2653000 0.024
R_VDD2_6232 METAL5_464000_2653000 METAL5_462000_2653000 0.008
R_VDD2_6233 METAL5_462000_2653000 METAL5_460000_2653000 0.008
R_VDD2_6234 METAL5_460000_2653000 METAL5_458000_2653000 0.008
R_VDD2_6235 METAL5_458000_2653000 METAL5_452000_2653000 0.024
R_VDD2_6236 METAL5_452000_2653000 METAL5_452000_2665000 0.048
R_VDD2_6237 METAL5_452000_2665000 METAL4_452000_2665000 0.1
R_VDD2_6238 METAL4_452000_2665000 METAL4_452000_2677000 0.096
R_VDD2_6239 METAL4_452000_2677000 METAL4_452000_2689000 0.096
R_VDD2_6240 METAL4_452000_2689000 METAL4_452000_2701000 0.096
R_VDD2_6241 METAL4_452000_2701000 METAL5_452000_2701000 0.1
R_VDD2_6242 METAL5_452000_2701000 METAL5_452000_2713000 0.048
R_VDD2_6243 METAL5_452000_2713000 METAL5_452000_2769000 0.224
R_VDD2_6244 METAL5_452000_2769000 METAL5_452000_2781000 0.048
R_VDD2_6245 METAL5_452000_2781000 METAL5_452000_2793000 0.048
R_VDD2_6246 METAL5_452000_2793000 METAL5_450000_2793000 0.008
R_VDD2_6247 METAL5_450000_2793000 METAL5_448000_2793000 0.008
R_VDD2_6248 METAL5_448000_2793000 METAL5_446000_2793000 0.008
R_VDD2_6249 METAL5_446000_2793000 METAL4_446000_2793000 0.1
R_VDD2_6250 METAL4_446000_2793000 METAL4_446000_2805000 0.096
R_VDD2_6251 METAL4_446000_2805000 METAL4_440000_2805000 0.048
R_VDD2_6252 METAL4_440000_2805000 METAL4_438000_2805000 0.016
R_VDD2_6253 METAL4_438000_2805000 METAL4_436000_2805000 0.016
R_VDD2_6254 METAL4_436000_2805000 METAL4_434000_2805000 0.016
R_VDD2_6255 METAL4_434000_2805000 METAL4_428000_2805000 0.048
R_VDD2_6256 METAL4_428000_2805000 METAL4_426000_2805000 0.016
R_VDD2_6257 METAL4_426000_2805000 METAL4_424000_2805000 0.016
R_VDD2_6258 METAL4_424000_2805000 METAL4_422000_2805000 0.016
R_VDD2_6259 METAL4_422000_2805000 METAL4_420000_2805000 0.016
R_VDD2_6260 METAL4_420000_2805000 METAL4_416000_2805000 0.032
R_VDD2_6261 METAL4_416000_2805000 METAL4_414000_2805000 0.016
R_VDD2_6262 METAL4_414000_2805000 METAL4_412000_2805000 0.016
R_VDD2_6263 METAL4_412000_2805000 METAL4_410000_2805000 0.016
R_VDD2_6264 METAL4_410000_2805000 METAL4_408000_2805000 0.016
R_VDD2_6265 METAL4_408000_2805000 METAL4_402000_2805000 0.048
R_VDD2_6266 METAL4_402000_2805000 METAL4_400000_2805000 0.016
R_VDD2_6267 METAL4_400000_2805000 METAL4_398000_2805000 0.016
R_VDD2_6268 METAL4_398000_2805000 METAL5_398000_2805000 0.1
R_VDD2_6269 METAL5_398000_2805000 METAL5_398000_2807000 0.008
R_VDD2_6270 METAL5_398000_2807000 METAL5_398000_2817000 0.04
R_VDD2_6271 METAL5_398000_2817000 METAL5_398000_2941000 0.496
R_VDD2_6272 METAL5_398000_2941000 METAL5_398000_2953000 0.048
R_VDD2_6273 METAL5_398000_2953000 METAL5_396000_2953000 0.008
R_VDD2_6274 METAL5_396000_2953000 METAL5_390000_2953000 0.024
R_VDD2_6275 METAL5_390000_2953000 METAL5_388000_2953000 0.008
R_VDD2_6276 METAL5_388000_2953000 METAL5_386000_2953000 0.008
R_VDD2_6277 METAL5_386000_2953000 METAL5_386000_2965000 0.048
R_VDD2_6278 METAL5_386000_2965000 METAL5_386000_2977000 0.048
R_VDD2_6279 METAL5_386000_2977000 METAL5_386000_2989000 0.048
R_VDD2_6280 METAL5_386000_2989000 METAL5_386000_3001000 0.048
R_VDD2_6281 METAL5_386000_3001000 METAL5_386000_3053000 0.208
R_VDD2_6282 METAL5_386000_3053000 METAL5_386000_3065000 0.048
R_VDD2_6283 METAL5_386000_3065000 METAL5_386000_3077000 0.048
R_VDD2_6284 METAL5_386000_3077000 METAL5_386000_3089000 0.048
R_VDD2_6285 METAL5_386000_3089000 METAL5_386000_3101000 0.048
R_VDD2_6286 METAL5_386000_3101000 METAL5_386000_3153000 0.208
R_VDD2_6287 METAL5_386000_3153000 METAL5_386000_3165000 0.048
R_VDD2_6288 METAL5_386000_3165000 METAL5_386000_3177000 0.048
R_VDD2_6289 METAL5_386000_3177000 METAL5_386000_3189000 0.048
R_VDD2_6290 METAL5_386000_3189000 METAL5_386000_3253000 0.256
R_VDD2_6291 METAL5_386000_3253000 METAL5_386000_3265000 0.048
R_VDD2_6292 METAL5_386000_3265000 METAL5_386000_3277000 0.048
R_VDD2_6293 METAL5_386000_3277000 METAL5_386000_3289000 0.048
R_VDD2_6294 METAL5_386000_3289000 METAL5_386000_3341000 0.208
R_VDD2_6295 METAL5_386000_3341000 METAL5_386000_3353000 0.048
R_VDD2_6296 METAL5_386000_3353000 METAL5_386000_3365000 0.048
R_VDD2_6297 METAL5_386000_3365000 METAL5_386000_3377000 0.048
R_VDD2_6298 METAL5_386000_3377000 METAL5_384000_3377000 0.008
R_VDD2_6299 METAL5_384000_3377000 METAL5_378000_3377000 0.024
R_VDD2_6300 METAL5_378000_3377000 METAL5_376000_3377000 0.008
R_VDD2_6301 METAL5_376000_3377000 METAL5_374000_3377000 0.008
R_VDD2_6302 METAL5_374000_3377000 METAL5_372000_3377000 0.008
R_VDD2_6303 METAL5_372000_3377000 METAL4_372000_3377000 0.1
R_VDD2_6304 METAL4_372000_3377000 METAL4_366000_3377000 0.048
R_VDD2_6305 METAL4_366000_3377000 METAL4_364000_3377000 0.016
R_VDD2_6306 METAL4_364000_3377000 METAL4_362000_3377000 0.016
R_VDD2_6307 METAL4_362000_3377000 METAL4_360000_3377000 0.016
R_VDD2_6308 METAL4_360000_3377000 METAL4_354000_3377000 0.048
R_VDD2_6309 METAL4_354000_3377000 METAL4_352000_3377000 0.016
R_VDD2_6310 METAL4_352000_3377000 METAL4_350000_3377000 0.016
R_VDD2_6311 METAL4_350000_3377000 METAL4_348000_3377000 0.016
R_VDD2_6312 METAL4_348000_3377000 METAL4_342000_3377000 0.048
R_VDD2_6313 METAL4_342000_3377000 METAL4_340000_3377000 0.016
R_VDD2_6314 METAL4_340000_3377000 METAL4_338000_3377000 0.016
R_VDD2_6315 METAL4_338000_3377000 METAL4_336000_3377000 0.016
R_VDD2_6316 METAL4_336000_3377000 METAL4_330000_3377000 0.048
R_VDD2_6317 METAL4_330000_3377000 METAL4_328000_3377000 0.016
R_VDD2_6318 METAL4_328000_3377000 METAL4_326000_3377000 0.016
R_VDD2_6319 METAL4_326000_3377000 METAL4_324000_3377000 0.016
R_VDD2_6320 METAL4_324000_3377000 METAL5_324000_3377000 0.1
R_VDD2_6321 METAL5_324000_3377000 METAL5_318000_3377000 0.024
R_VDD2_6322 METAL5_318000_3377000 METAL5_316000_3377000 0.008
R_VDD2_6323 METAL5_316000_3377000 METAL5_314000_3377000 0.008
R_VDD2_6324 METAL5_314000_3377000 METAL5_312000_3377000 0.008
R_VDD2_6325 METAL5_312000_3377000 METAL5_306000_3377000 0.024
R_VDD2_6326 METAL5_306000_3377000 METAL5_305000_3377000 0.004
R_VDD2_6327 METAL5_305000_3377000 METAL5_304000_3377000 0.004
R_VDD2_6328 METAL5_304000_3377000 METAL5_302000_3377000 0.008
R_VDD2_6329 METAL5_302000_3377000 METAL5_300000_3377000 0.008
R_VDD2_6330 METAL5_300000_3377000 METAL5_294000_3377000 0.024
R_VDD2_6331 METAL5_294000_3377000 METAL5_293000_3377000 0.004
R_VDD2_6332 METAL5_293000_3377000 METAL5_290000_3377000 0.012
R_VDD2_6333 METAL5_290000_3377000 METAL5_288000_3377000 0.008
R_VDD2_6334 METAL5_288000_3377000 METAL5_282000_3377000 0.024
R_VDD2_6335 METAL5_282000_3377000 METAL5_281000_3377000 0.004
R_VDD2_6336 METAL5_281000_3377000 METAL5_278000_3377000 0.012
R_VDD2_6337 METAL5_278000_3377000 METAL5_276000_3377000 0.008
R_VDD2_6338 METAL5_276000_3377000 METAL5_270000_3377000 0.024
R_VDD2_6339 METAL5_270000_3377000 METAL5_269000_3377000 0.004
R_VDD2_6340 METAL5_269000_3377000 METAL5_266000_3377000 0.012
R_VDD2_6341 METAL5_266000_3377000 METAL5_264000_3377000 0.008
R_VDD2_6342 METAL5_264000_3377000 METAL5_258000_3377000 0.024
R_VDD2_6343 METAL5_258000_3377000 METAL5_257000_3377000 0.004
R_VDD2_6344 METAL5_257000_3377000 METAL6_257000_3377000 0.1
R_VDD2_6345 METAL6_257000_3377000 METAL6_257000_3389000 0.024
R_VDD2_6346 METAL6_257000_3389000 METAL6_257000_3401000 0.024
R_VDD2_6347 METAL6_257000_3401000 METAL6_257000_3413000 0.024
R_VDD2_6348 METAL6_257000_3413000 METAL6_257000_3425000 0.024
R_VDD2_6349 METAL6_257000_3425000 METAL6_257000_3481000 0.112
R_VDD2_6350 METAL6_257000_3481000 METAL6_257000_3493000 0.024
R_VDD2_6351 METAL6_257000_3493000 METAL6_257000_3495000 0.004
R_VDD2_6352 METAL6_257000_3495000 METAL6_257000_3505000 0.02
R_VDD2_6353 METAL6_257000_3505000 METAL6_257000_3507000 0.004
R_VDD2_6354 METAL6_257000_3507000 METAL6_257000_3519000 0.024
R_VDD2_6355 METAL6_257000_3519000 METAL6_257000_3641000 0.244
R_VDD2_6356 METAL6_257000_3641000 METAL6_257000_3653000 0.024
R_VDD2_6357 METAL6_257000_3653000 METAL5_257000_3653000 0.1
R_VDD2_6358 METAL5_257000_3653000 METAL5_258000_3653000 0.004
R_VDD2_6359 METAL5_258000_3653000 METAL5_264000_3653000 0.024
R_VDD2_6360 METAL5_264000_3653000 METAL5_266000_3653000 0.008
R_VDD2_6361 METAL5_266000_3653000 METAL5_269000_3653000 0.012
R_VDD2_6362 METAL5_269000_3653000 METAL5_269000_3665000 0.048
R_VDD2_6363 METAL5_269000_3665000 METAL5_269000_3677000 0.048
R_VDD2_6364 METAL5_269000_3677000 METAL5_266000_3677000 0.012
R_VDD2_6365 METAL5_266000_3677000 METAL5_264000_3677000 0.008
R_VDD2_6366 METAL5_264000_3677000 METAL5_258000_3677000 0.024
R_VDD2_6367 METAL5_258000_3677000 METAL5_257000_3677000 0.004
R_VDD2_6368 METAL5_257000_3677000 METAL6_257000_3677000 0.1
R_VDD2_6369 METAL6_257000_3677000 METAL6_257000_3689000 0.024
R_VDD2_6370 METAL6_257000_3689000 METAL6_257000_3753000 0.128
R_VDD2_6371 METAL6_257000_3753000 METAL6_257000_3765000 0.024
R_VDD2_6372 METAL6_555000_3065000 METAL6_543000_3065000 0.024
R_VDD2_6373 METAL5_350000_8000 METAL4_350000_8000 0.1
R_VDD2_6374 METAL4_350000_8000 METAL4_348000_8000 0.016
R_VDD2_6375 METAL4_348000_8000 METAL4_342000_8000 0.048
R_VDD2_6376 METAL4_342000_8000 METAL4_340000_8000 0.016
R_VDD2_6377 METAL4_340000_8000 METAL4_338000_8000 0.016
R_VDD2_6378 METAL4_338000_8000 METAL4_336000_8000 0.016
R_VDD2_6379 METAL4_336000_8000 METAL4_330000_8000 0.048
R_VDD2_6380 METAL4_330000_8000 METAL4_328000_8000 0.016
R_VDD2_6381 METAL4_328000_8000 METAL4_326000_8000 0.016
R_VDD2_6382 METAL4_326000_8000 METAL5_326000_8000 0.1
R_VDD2_6383 METAL5_326000_8000 METAL5_326000_20000 0.048
R_VDD2_6384 METAL5_326000_20000 METAL5_324000_20000 0.008
R_VDD2_6385 METAL5_324000_20000 METAL5_318000_20000 0.024
R_VDD2_6386 METAL5_318000_20000 METAL5_316000_20000 0.008
R_VDD2_6387 METAL5_316000_20000 METAL5_314000_20000 0.008
R_VDD2_6388 METAL5_314000_20000 METAL5_312000_20000 0.008
R_VDD2_6389 METAL5_312000_20000 METAL5_306000_20000 0.024
R_VDD2_6390 METAL5_306000_20000 METAL5_305000_20000 0.004
R_VDD2_6391 METAL5_305000_20000 METAL5_304000_20000 0.004
R_VDD2_6392 METAL5_304000_20000 METAL5_302000_20000 0.008
R_VDD2_6393 METAL5_302000_20000 METAL5_300000_20000 0.008
R_VDD2_6394 METAL5_300000_20000 METAL5_294000_20000 0.024
R_VDD2_6395 METAL5_294000_20000 METAL5_294000_32000 0.048
R_VDD2_6396 METAL5_294000_32000 METAL5_294000_44000 0.048
R_VDD2_6397 METAL5_294000_44000 METAL5_294000_45000 0.004
R_VDD2_6398 METAL5_294000_45000 METAL5_294000_56000 0.044
R_VDD2_6399 METAL5_294000_56000 METAL5_294000_57000 0.004
R_VDD2_6400 METAL5_294000_57000 METAL5_294000_68000 0.044
R_VDD2_6401 METAL5_294000_68000 METAL5_294000_69000 0.004
R_VDD2_6402 METAL5_294000_69000 METAL5_294000_80000 0.044
R_VDD2_6403 METAL5_294000_80000 METAL5_300000_80000 0.024
R_VDD2_6404 METAL5_300000_80000 METAL5_302000_80000 0.008
R_VDD2_6405 METAL5_302000_80000 METAL5_304000_80000 0.008
R_VDD2_6406 METAL5_304000_80000 METAL5_304000_81000 0.004
R_VDD2_6407 METAL5_304000_81000 METAL5_304000_92000 0.044
R_VDD2_6408 METAL5_304000_92000 METAL5_304000_93000 0.004
R_VDD2_6409 METAL5_304000_93000 METAL5_304000_105000 0.048
R_VDD2_6410 METAL5_304000_105000 METAL5_304000_117000 0.048
R_VDD2_6411 METAL5_304000_117000 METAL5_304000_121000 0.016
R_VDD2_6412 METAL5_304000_121000 METAL5_304000_129000 0.032
R_VDD2_6413 METAL5_304000_129000 METAL5_304000_133000 0.016
R_VDD2_6414 METAL5_304000_133000 METAL5_304000_141000 0.032
R_VDD2_6415 METAL5_304000_141000 METAL5_304000_145000 0.016
R_VDD2_6416 METAL5_304000_145000 METAL5_304000_153000 0.032
R_VDD2_6417 METAL5_304000_153000 METAL5_304000_157000 0.016
R_VDD2_6418 METAL5_304000_157000 METAL5_304000_165000 0.032
R_VDD2_6419 METAL5_304000_165000 METAL5_304000_169000 0.016
R_VDD2_6420 METAL5_304000_169000 METAL5_304000_177000 0.032
R_VDD2_6421 METAL5_304000_177000 METAL5_304000_181000 0.016
R_VDD2_6422 METAL5_304000_181000 METAL5_304000_193000 0.048
R_VDD2_6423 METAL5_304000_193000 METAL5_304000_205000 0.048
R_VDD2_6424 METAL5_304000_205000 METAL5_304000_217000 0.048
R_VDD2_6425 METAL5_304000_217000 METAL5_304000_229000 0.048
R_VDD2_6426 METAL5_304000_229000 METAL5_304000_233000 0.016
R_VDD2_6427 METAL5_304000_233000 METAL5_304000_241000 0.032
R_VDD2_6428 METAL5_304000_241000 METAL5_304000_245000 0.016
R_VDD2_6429 METAL5_304000_245000 METAL5_305000_245000 0.004
R_VDD2_6430 METAL5_305000_245000 METAL5_306000_245000 0.004
R_VDD2_6431 METAL5_306000_245000 METAL4_306000_245000 0.1
R_VDD2_6432 METAL4_306000_245000 METAL4_306000_253000 0.064
R_VDD2_6433 METAL4_306000_253000 METAL4_312000_253000 0.048
R_VDD2_6434 METAL4_312000_253000 METAL4_312000_257000 0.032
R_VDD2_6435 METAL4_312000_257000 METAL4_312000_265000 0.064
R_VDD2_6436 METAL4_312000_265000 METAL4_312000_269000 0.032
R_VDD2_6437 METAL4_312000_269000 METAL4_312000_277000 0.064
R_VDD2_6438 METAL4_312000_277000 METAL4_312000_281000 0.032
R_VDD2_6439 METAL4_312000_281000 METAL4_312000_289000 0.064
R_VDD2_6440 METAL4_312000_289000 METAL4_312000_293000 0.032
R_VDD2_6441 METAL4_312000_293000 METAL4_312000_301000 0.064
R_VDD2_6442 METAL4_312000_301000 METAL4_312000_305000 0.032
R_VDD2_6443 METAL4_312000_305000 METAL4_312000_313000 0.064
R_VDD2_6444 METAL4_312000_313000 METAL4_312000_317000 0.032
R_VDD2_6445 METAL4_312000_317000 METAL4_312000_329000 0.096
R_VDD2_6446 METAL4_312000_329000 METAL4_312000_341000 0.096
R_VDD2_6447 METAL4_312000_341000 METAL4_312000_353000 0.096
R_VDD2_6448 METAL4_312000_353000 METAL4_312000_365000 0.096
R_VDD2_6449 METAL4_312000_365000 METAL4_312000_377000 0.096
R_VDD2_6450 METAL4_312000_377000 METAL4_312000_389000 0.096
R_VDD2_6451 METAL4_312000_389000 METAL4_312000_401000 0.096
R_VDD2_6452 METAL4_312000_401000 METAL4_312000_405000 0.032
R_VDD2_6453 METAL4_312000_405000 METAL4_312000_417000 0.096
R_VDD2_6454 METAL4_312000_417000 METAL4_312000_429000 0.096
R_VDD2_6455 METAL4_312000_429000 METAL4_312000_441000 0.096
R_VDD2_6456 METAL4_312000_441000 METAL4_314000_441000 0.016
R_VDD2_6457 METAL4_314000_441000 METAL4_316000_441000 0.016
R_VDD2_6458 METAL4_316000_441000 METAL4_318000_441000 0.016
R_VDD2_6459 METAL4_318000_441000 METAL4_324000_441000 0.048
R_VDD2_6460 METAL4_324000_441000 METAL4_324000_453000 0.096
R_VDD2_6461 METAL4_324000_453000 METAL4_324000_465000 0.096
R_VDD2_6462 METAL4_324000_465000 METAL4_324000_469000 0.032
R_VDD2_6463 METAL4_324000_469000 METAL4_324000_477000 0.064
R_VDD2_6464 METAL4_324000_477000 METAL5_324000_477000 0.1
R_VDD2_6465 METAL5_324000_477000 METAL5_324000_481000 0.016
R_VDD2_6466 METAL5_324000_481000 METAL5_324000_489000 0.032
R_VDD2_6467 METAL5_324000_489000 METAL5_324000_493000 0.016
R_VDD2_6468 METAL5_324000_493000 METAL5_324000_501000 0.032
R_VDD2_6469 METAL5_324000_501000 METAL5_324000_505000 0.016
R_VDD2_6470 METAL5_324000_505000 METAL5_324000_517000 0.048
R_VDD2_6471 METAL5_324000_517000 METAL5_324000_529000 0.048
R_VDD2_6472 METAL5_324000_529000 METAL4_324000_529000 0.1
R_VDD2_6473 METAL4_324000_529000 METAL4_324000_541000 0.096
R_VDD2_6474 METAL4_324000_541000 METAL4_324000_553000 0.096
R_VDD2_6475 METAL4_324000_553000 METAL4_324000_565000 0.096
R_VDD2_6476 METAL4_324000_565000 METAL4_324000_577000 0.096
R_VDD2_6477 METAL4_324000_577000 METAL4_324000_589000 0.096
R_VDD2_6478 METAL4_324000_589000 METAL4_324000_601000 0.096
R_VDD2_6479 METAL4_324000_601000 METAL5_324000_601000 0.1
R_VDD2_6480 METAL5_324000_601000 METAL5_324000_613000 0.048
R_VDD2_6481 METAL5_324000_613000 METAL5_324000_625000 0.048
R_VDD2_6482 METAL5_324000_625000 METAL5_324000_681000 0.224
R_VDD2_6483 METAL5_324000_681000 METAL5_324000_693000 0.048
R_VDD2_6484 METAL5_324000_693000 METAL5_324000_705000 0.048
R_VDD2_6485 METAL5_324000_705000 METAL5_324000_707000 0.008
R_VDD2_6486 METAL5_324000_707000 METAL5_324000_717000 0.04
R_VDD2_6487 METAL5_324000_717000 METAL5_324000_769000 0.208
R_VDD2_6488 METAL5_324000_769000 METAL5_324000_781000 0.048
R_VDD2_6489 METAL5_324000_781000 METAL5_324000_793000 0.048
R_VDD2_6490 METAL5_324000_793000 METAL5_324000_805000 0.048
R_VDD2_6491 METAL5_324000_805000 METAL5_326000_805000 0.008
R_VDD2_6492 METAL5_326000_805000 METAL4_326000_805000 0.1
R_VDD2_6493 METAL4_326000_805000 METAL4_326000_817000 0.096
R_VDD2_6494 METAL4_326000_817000 METAL4_326000_829000 0.096
R_VDD2_6495 METAL4_326000_829000 METAL4_326000_841000 0.096
R_VDD2_6496 METAL4_326000_841000 METAL4_326000_853000 0.096
R_VDD2_6497 METAL4_326000_853000 METAL4_326000_865000 0.096
R_VDD2_6498 METAL4_326000_865000 METAL4_326000_869000 0.032
R_VDD2_6499 METAL4_326000_869000 METAL4_328000_869000 0.016
R_VDD2_6500 METAL4_328000_869000 METAL4_330000_869000 0.016
R_VDD2_6501 METAL4_330000_869000 METAL4_336000_869000 0.048
R_VDD2_6502 METAL4_336000_869000 METAL4_338000_869000 0.016
R_VDD2_6503 METAL4_338000_869000 METAL4_338000_877000 0.064
R_VDD2_6504 METAL4_338000_877000 METAL4_338000_881000 0.032
R_VDD2_6505 METAL4_338000_881000 METAL4_338000_889000 0.064
R_VDD2_6506 METAL4_338000_889000 METAL4_338000_893000 0.032
R_VDD2_6507 METAL4_338000_893000 METAL4_340000_893000 0.016
R_VDD2_6508 METAL4_340000_893000 METAL4_342000_893000 0.016
R_VDD2_6509 METAL4_342000_893000 METAL4_348000_893000 0.048
R_VDD2_6510 METAL4_348000_893000 METAL4_350000_893000 0.016
R_VDD2_6511 METAL4_350000_893000 METAL4_352000_893000 0.016
R_VDD2_6512 METAL4_352000_893000 METAL4_354000_893000 0.016
R_VDD2_6513 METAL4_354000_893000 METAL4_360000_893000 0.048
R_VDD2_6514 METAL4_360000_893000 METAL4_362000_893000 0.016
R_VDD2_6515 METAL4_362000_893000 METAL4_362000_901000 0.064
R_VDD2_6516 METAL4_362000_901000 METAL4_362000_905000 0.032
R_VDD2_6517 METAL4_362000_905000 METAL4_362000_913000 0.064
R_VDD2_6518 METAL4_362000_913000 METAL4_362000_917000 0.032
R_VDD2_6519 METAL4_362000_917000 METAL4_362000_929000 0.096
R_VDD2_6520 METAL4_362000_929000 METAL4_362000_941000 0.096
R_VDD2_6521 METAL4_362000_941000 METAL4_362000_953000 0.096
R_VDD2_6522 METAL4_362000_953000 METAL4_362000_965000 0.096
R_VDD2_6523 METAL4_362000_965000 METAL4_362000_977000 0.096
R_VDD2_6524 METAL4_362000_977000 METAL4_362000_989000 0.096
R_VDD2_6525 METAL4_362000_989000 METAL4_362000_1001000 0.096
R_VDD2_6526 METAL4_362000_1001000 METAL4_362000_1013000 0.096
R_VDD2_6527 METAL4_362000_1013000 METAL5_362000_1013000 0.1
R_VDD2_6528 METAL5_362000_1013000 METAL5_362000_1025000 0.048
R_VDD2_6529 METAL5_362000_1025000 METAL5_362000_1041000 0.064
R_VDD2_6530 METAL5_362000_1041000 METAL5_362000_1053000 0.048
R_VDD2_6531 METAL5_362000_1053000 METAL5_362000_1065000 0.048
R_VDD2_6532 METAL5_362000_1065000 METAL4_362000_1065000 0.1
R_VDD2_6533 METAL4_362000_1065000 METAL4_362000_1077000 0.096
R_VDD2_6534 METAL4_362000_1077000 METAL4_362000_1089000 0.096
R_VDD2_6535 METAL4_362000_1089000 METAL5_362000_1089000 0.1
R_VDD2_6536 METAL5_362000_1089000 METAL5_362000_1101000 0.048
R_VDD2_6537 METAL5_362000_1101000 METAL5_362000_1153000 0.208
R_VDD2_6538 METAL5_362000_1153000 METAL5_362000_1165000 0.048
R_VDD2_6539 METAL5_362000_1165000 METAL5_362000_1177000 0.048
R_VDD2_6540 METAL5_362000_1177000 METAL5_362000_1189000 0.048
R_VDD2_6541 METAL5_362000_1189000 METAL5_362000_1201000 0.048
R_VDD2_6542 METAL5_362000_1201000 METAL5_362000_1205000 0.016
R_VDD2_6543 METAL5_362000_1205000 METAL5_362000_1217000 0.048
R_VDD2_6544 METAL5_362000_1217000 METAL5_362000_1229000 0.048
R_VDD2_6545 METAL5_362000_1229000 METAL5_362000_1241000 0.048
R_VDD2_6546 METAL5_362000_1241000 METAL5_362000_1253000 0.048
R_VDD2_6547 METAL5_362000_1253000 METAL5_364000_1253000 0.008
R_VDD2_6548 METAL5_364000_1253000 METAL5_366000_1253000 0.008
R_VDD2_6549 METAL5_366000_1253000 METAL5_372000_1253000 0.024
R_VDD2_6550 METAL5_372000_1253000 METAL5_374000_1253000 0.008
R_VDD2_6551 METAL5_374000_1253000 METAL4_374000_1253000 0.1
R_VDD2_6552 METAL4_374000_1253000 METAL4_374000_1265000 0.096
R_VDD2_6553 METAL4_374000_1265000 METAL4_374000_1277000 0.096
R_VDD2_6554 METAL4_374000_1277000 METAL4_374000_1289000 0.096
R_VDD2_6555 METAL4_374000_1289000 METAL5_374000_1289000 0.1
R_VDD2_6556 METAL5_374000_1289000 METAL5_374000_1357000 0.272
R_VDD2_6557 METAL5_374000_1357000 METAL5_374000_1369000 0.048
R_VDD2_6558 METAL5_374000_1369000 METAL5_374000_1381000 0.048
R_VDD2_6559 METAL5_374000_1381000 METAL5_374000_1393000 0.048
R_VDD2_6560 METAL5_374000_1393000 METAL4_374000_1393000 0.1
R_VDD2_6561 METAL4_374000_1393000 METAL4_374000_1405000 0.096
R_VDD2_6562 METAL4_374000_1405000 METAL4_374000_1407000 0.016
R_VDD2_6563 METAL4_374000_1407000 METAL4_374000_1417000 0.08
R_VDD2_6564 METAL4_374000_1417000 METAL5_374000_1417000 0.1
R_VDD2_6565 METAL5_374000_1417000 METAL5_374000_1529000 0.448
R_VDD2_6566 METAL5_374000_1529000 METAL5_374000_1541000 0.048
R_VDD2_6567 METAL5_374000_1541000 METAL4_374000_1541000 0.1
R_VDD2_6568 METAL4_374000_1541000 METAL4_374000_1553000 0.096
R_VDD2_6569 METAL4_374000_1553000 METAL4_374000_1565000 0.096
R_VDD2_6570 METAL4_374000_1565000 METAL5_374000_1565000 0.1
R_VDD2_6571 METAL5_374000_1565000 METAL5_374000_1577000 0.048
R_VDD2_6572 METAL5_374000_1577000 METAL5_374000_1617000 0.16
R_VDD2_6573 METAL5_374000_1617000 METAL5_374000_1629000 0.048
R_VDD2_6574 METAL5_374000_1629000 METAL5_374000_1641000 0.048
R_VDD2_6575 METAL5_374000_1641000 METAL5_374000_1653000 0.048
R_VDD2_6576 METAL5_374000_1653000 METAL4_374000_1653000 0.1
R_VDD2_6577 METAL4_374000_1653000 METAL4_374000_1665000 0.096
R_VDD2_6578 METAL4_374000_1665000 METAL4_374000_1677000 0.096
R_VDD2_6579 METAL4_374000_1677000 METAL5_374000_1677000 0.1
R_VDD2_6580 METAL5_374000_1677000 METAL5_374000_1689000 0.048
R_VDD2_6581 METAL5_374000_1689000 METAL5_374000_1753000 0.256
R_VDD2_6582 METAL5_374000_1753000 METAL5_374000_1765000 0.048
R_VDD2_6583 METAL5_374000_1765000 METAL5_374000_1777000 0.048
R_VDD2_6584 METAL5_374000_1777000 METAL5_374000_1789000 0.048
R_VDD2_6585 METAL5_374000_1789000 METAL5_374000_1817000 0.112
R_VDD2_6586 METAL5_374000_1817000 METAL5_374000_1829000 0.048
R_VDD2_6587 METAL5_374000_1829000 METAL5_374000_1841000 0.048
R_VDD2_6588 METAL5_374000_1841000 METAL5_374000_1853000 0.048
R_VDD2_6589 METAL5_374000_1853000 METAL5_374000_1865000 0.048
R_VDD2_6590 METAL5_374000_1865000 METAL5_374000_1877000 0.048
R_VDD2_6591 METAL5_374000_1877000 METAL5_374000_1905000 0.112
R_VDD2_6592 METAL5_374000_1905000 METAL5_374000_1917000 0.048
R_VDD2_6593 METAL5_374000_1917000 METAL5_374000_1929000 0.048
R_VDD2_6594 METAL5_374000_1929000 METAL5_374000_1941000 0.048
R_VDD2_6595 METAL5_374000_1941000 METAL5_374000_1953000 0.048
R_VDD2_6596 METAL5_374000_1953000 METAL4_374000_1953000 0.1
R_VDD2_6597 METAL4_374000_1953000 METAL4_374000_1965000 0.096
R_VDD2_6598 METAL4_374000_1965000 METAL4_374000_1977000 0.096
R_VDD2_6599 METAL4_374000_1977000 METAL5_374000_1977000 0.1
R_VDD2_6600 METAL5_374000_1977000 METAL5_374000_1989000 0.048
R_VDD2_6601 METAL5_374000_1989000 METAL5_374000_2001000 0.048
R_VDD2_6602 METAL5_374000_2001000 METAL5_374000_2013000 0.048
R_VDD2_6603 METAL5_374000_2013000 METAL5_374000_2093000 0.32
R_VDD2_6604 METAL5_374000_2093000 METAL5_374000_2107000 0.056
R_VDD2_6605 METAL5_374000_2107000 METAL5_374000_2217000 0.44
R_VDD2_6606 METAL5_374000_2217000 METAL5_374000_2229000 0.048
R_VDD2_6607 METAL5_374000_2229000 METAL5_374000_2241000 0.048
R_VDD2_6608 METAL5_374000_2241000 METAL5_374000_2253000 0.048
R_VDD2_6609 METAL5_374000_2253000 METAL5_374000_2265000 0.048
R_VDD2_6610 METAL5_374000_2265000 METAL5_374000_2277000 0.048
R_VDD2_6611 METAL5_374000_2277000 METAL5_374000_2341000 0.256
R_VDD2_6612 METAL5_374000_2341000 METAL5_374000_2353000 0.048
R_VDD2_6613 METAL5_374000_2353000 METAL5_374000_2365000 0.048
R_VDD2_6614 METAL5_374000_2365000 METAL5_374000_2377000 0.048
R_VDD2_6615 METAL5_374000_2377000 METAL5_374000_2389000 0.048
R_VDD2_6616 METAL5_374000_2389000 METAL5_374000_2401000 0.048
R_VDD2_6617 METAL5_374000_2401000 METAL5_374000_2453000 0.208
R_VDD2_6618 METAL5_374000_2453000 METAL5_374000_2465000 0.048
R_VDD2_6619 METAL5_374000_2465000 METAL5_374000_2477000 0.048
R_VDD2_6620 METAL5_374000_2477000 METAL5_374000_2489000 0.048
R_VDD2_6621 METAL5_374000_2489000 METAL5_374000_2553000 0.256
R_VDD2_6622 METAL5_374000_2553000 METAL5_374000_2565000 0.048
R_VDD2_6623 METAL5_374000_2565000 METAL5_374000_2577000 0.048
R_VDD2_6624 METAL5_374000_2577000 METAL5_374000_2605000 0.112
R_VDD2_6625 METAL5_374000_2605000 METAL5_374000_2617000 0.048
R_VDD2_6626 METAL5_374000_2617000 METAL5_374000_2629000 0.048
R_VDD2_6627 METAL5_374000_2629000 METAL5_374000_2641000 0.048
R_VDD2_6628 METAL5_374000_2641000 METAL5_374000_2653000 0.048
R_VDD2_6629 METAL5_374000_2653000 METAL4_374000_2653000 0.1
R_VDD2_6630 METAL4_374000_2653000 METAL4_376000_2653000 0.016
R_VDD2_6631 METAL4_376000_2653000 METAL4_378000_2653000 0.016
R_VDD2_6632 METAL4_378000_2653000 METAL4_384000_2653000 0.048
R_VDD2_6633 METAL4_384000_2653000 METAL4_386000_2653000 0.016
R_VDD2_6634 METAL4_386000_2653000 METAL4_388000_2653000 0.016
R_VDD2_6635 METAL4_388000_2653000 METAL4_390000_2653000 0.016
R_VDD2_6636 METAL4_390000_2653000 METAL4_396000_2653000 0.048
R_VDD2_6637 METAL4_396000_2653000 METAL4_398000_2653000 0.016
R_VDD2_6638 METAL4_398000_2653000 METAL4_400000_2653000 0.016
R_VDD2_6639 METAL4_400000_2653000 METAL4_402000_2653000 0.016
R_VDD2_6640 METAL4_402000_2653000 METAL4_408000_2653000 0.048
R_VDD2_6641 METAL4_408000_2653000 METAL4_410000_2653000 0.016
R_VDD2_6642 METAL4_410000_2653000 METAL4_412000_2653000 0.016
R_VDD2_6643 METAL4_412000_2653000 METAL4_414000_2653000 0.016
R_VDD2_6644 METAL4_414000_2653000 METAL4_416000_2653000 0.016
R_VDD2_6645 METAL4_416000_2653000 METAL4_420000_2653000 0.032
R_VDD2_6646 METAL4_420000_2653000 METAL4_422000_2653000 0.016
R_VDD2_6647 METAL4_422000_2653000 METAL4_424000_2653000 0.016
R_VDD2_6648 METAL4_424000_2653000 METAL4_426000_2653000 0.016
R_VDD2_6649 METAL4_426000_2653000 METAL4_428000_2653000 0.016
R_VDD2_6650 METAL4_428000_2653000 METAL4_434000_2653000 0.048
R_VDD2_6651 METAL4_434000_2653000 METAL4_436000_2653000 0.016
R_VDD2_6652 METAL4_436000_2653000 METAL4_438000_2653000 0.016
R_VDD2_6653 METAL4_438000_2653000 METAL4_440000_2653000 0.016
R_VDD2_6654 METAL4_440000_2653000 METAL4_446000_2653000 0.048
R_VDD2_6655 METAL4_446000_2653000 METAL4_448000_2653000 0.016
R_VDD2_6656 METAL4_448000_2653000 METAL4_450000_2653000 0.016
R_VDD2_6657 METAL4_450000_2653000 METAL4_452000_2653000 0.016
R_VDD2_6658 METAL4_452000_2653000 METAL4_458000_2653000 0.048
R_VDD2_6659 METAL4_458000_2653000 METAL4_460000_2653000 0.016
R_VDD2_6660 METAL4_460000_2653000 METAL4_462000_2653000 0.016
R_VDD2_6661 METAL4_462000_2653000 METAL4_464000_2653000 0.016
R_VDD2_6662 METAL4_464000_2653000 METAL4_464000_2665000 0.096
R_VDD2_6663 METAL4_464000_2665000 METAL4_464000_2677000 0.096
R_VDD2_6664 METAL4_464000_2677000 METAL4_464000_2689000 0.096
R_VDD2_6665 METAL4_464000_2689000 METAL4_464000_2701000 0.096
R_VDD2_6666 METAL4_464000_2701000 METAL5_464000_2701000 0.1
R_VDD2_6667 METAL5_464000_2701000 METAL5_464000_2713000 0.048
R_VDD2_6668 METAL5_464000_2713000 METAL5_464000_2769000 0.224
R_VDD2_6669 METAL5_464000_2769000 METAL5_464000_2781000 0.048
R_VDD2_6670 METAL5_464000_2781000 METAL5_464000_2793000 0.048
R_VDD2_6671 METAL5_464000_2793000 METAL5_464000_2805000 0.048
R_VDD2_6672 METAL5_464000_2805000 METAL5_470000_2805000 0.024
R_VDD2_6673 METAL5_470000_2805000 METAL5_470000_2807000 0.008
R_VDD2_6674 METAL5_470000_2807000 METAL5_470000_2817000 0.04
R_VDD2_6675 METAL5_470000_2817000 METAL5_470000_2941000 0.496
R_VDD2_6676 METAL5_470000_2941000 METAL5_470000_2953000 0.048
R_VDD2_6677 METAL5_470000_2953000 METAL5_470000_2965000 0.048
R_VDD2_6678 METAL5_470000_2965000 METAL5_470000_2977000 0.048
R_VDD2_6679 METAL5_470000_2977000 METAL5_472000_2977000 0.008
R_VDD2_6680 METAL5_472000_2977000 METAL5_474000_2977000 0.008
R_VDD2_6681 METAL5_474000_2977000 METAL5_476000_2977000 0.008
R_VDD2_6682 METAL5_476000_2977000 METAL5_482000_2977000 0.024
R_VDD2_6683 METAL5_482000_2977000 METAL5_484000_2977000 0.008
R_VDD2_6684 METAL5_484000_2977000 METAL5_486000_2977000 0.008
R_VDD2_6685 METAL5_486000_2977000 METAL5_488000_2977000 0.008
R_VDD2_6686 METAL5_488000_2977000 METAL5_495000_2977000 0.028
R_VDD2_6687 METAL5_495000_2977000 METAL4_495000_2977000 0.1
R_VDD2_6688 METAL4_495000_2977000 METAL4_496000_2977000 0.008
R_VDD2_6689 METAL4_496000_2977000 METAL4_500000_2977000 0.032
R_VDD2_6690 METAL4_500000_2977000 METAL4_507000_2977000 0.056
R_VDD2_6691 METAL4_507000_2977000 METAL4_508000_2977000 0.008
R_VDD2_6692 METAL4_508000_2977000 METAL4_512000_2977000 0.032
R_VDD2_6693 METAL4_512000_2977000 METAL4_519000_2977000 0.056
R_VDD2_6694 METAL4_519000_2977000 METAL4_524000_2977000 0.04
R_VDD2_6695 METAL4_524000_2977000 METAL4_531000_2977000 0.056
R_VDD2_6696 METAL4_531000_2977000 METAL4_543000_2977000 0.096
R_VDD2_6697 METAL4_543000_2977000 METAL5_543000_2977000 0.1
R_VDD2_6698 METAL5_543000_2977000 METAL6_543000_2977000 0.1
R_VDD2_6699 METAL6_543000_2977000 METAL6_543000_2989000 0.024
R_VDD2_6700 METAL6_543000_2989000 METAL6_543000_3001000 0.024
R_VDD2_6701 METAL6_543000_3001000 METAL6_543000_3053000 0.104
R_VDD2_6702 METAL6_543000_3053000 METAL6_543000_3065000 0.024
R_VDD2_6703 METAL6_245000_3065000 METAL6_257000_3065000 0.024
R_VDD2_6704 METAL6_350000_8000 METAL6_352000_8000 0.004
R_VDD2_6705 METAL6_352000_8000 METAL6_354000_8000 0.004
R_VDD2_6706 METAL6_354000_8000 METAL6_360000_8000 0.012
R_VDD2_6707 METAL6_360000_8000 METAL6_362000_8000 0.004
R_VDD2_6708 METAL6_362000_8000 METAL6_364000_8000 0.004
R_VDD2_6709 METAL6_364000_8000 METAL5_364000_8000 0.1
R_VDD2_6710 METAL5_364000_8000 METAL4_364000_8000 0.1
R_VDD2_6711 METAL4_364000_8000 METAL4_364000_20000 0.096
R_VDD2_6712 METAL4_364000_20000 METAL4_364000_32000 0.096
R_VDD2_6713 METAL4_364000_32000 METAL4_364000_44000 0.096
R_VDD2_6714 METAL4_364000_44000 METAL4_366000_44000 0.016
R_VDD2_6715 METAL4_366000_44000 METAL4_366000_45000 0.008
R_VDD2_6716 METAL4_366000_45000 METAL4_366000_56000 0.088
R_VDD2_6717 METAL4_366000_56000 METAL4_366000_57000 0.008
R_VDD2_6718 METAL4_366000_57000 METAL4_366000_68000 0.088
R_VDD2_6719 METAL4_366000_68000 METAL5_366000_68000 0.1
R_VDD2_6720 METAL5_366000_68000 METAL5_372000_68000 0.024
R_VDD2_6721 METAL5_372000_68000 METAL5_374000_68000 0.008
R_VDD2_6722 METAL5_374000_68000 METAL5_376000_68000 0.008
R_VDD2_6723 METAL5_376000_68000 METAL5_378000_68000 0.008
R_VDD2_6724 METAL5_378000_68000 METAL5_378000_69000 0.004
R_VDD2_6725 METAL5_378000_69000 METAL5_378000_80000 0.044
R_VDD2_6726 METAL5_378000_80000 METAL5_378000_81000 0.004
R_VDD2_6727 METAL5_378000_81000 METAL5_378000_92000 0.044
R_VDD2_6728 METAL5_378000_92000 METAL5_378000_93000 0.004
R_VDD2_6729 METAL5_378000_93000 METAL5_378000_105000 0.048
R_VDD2_6730 METAL5_378000_105000 METAL5_378000_117000 0.048
R_VDD2_6731 METAL5_378000_117000 METAL5_378000_121000 0.016
R_VDD2_6732 METAL5_378000_121000 METAL5_378000_129000 0.032
R_VDD2_6733 METAL5_378000_129000 METAL4_378000_129000 0.1
R_VDD2_6734 METAL4_378000_129000 METAL4_384000_129000 0.048
R_VDD2_6735 METAL4_384000_129000 METAL4_386000_129000 0.016
R_VDD2_6736 METAL4_386000_129000 METAL4_388000_129000 0.016
R_VDD2_6737 METAL4_388000_129000 METAL4_390000_129000 0.016
R_VDD2_6738 METAL4_390000_129000 METAL4_396000_129000 0.048
R_VDD2_6739 METAL4_396000_129000 METAL4_398000_129000 0.016
R_VDD2_6740 METAL4_398000_129000 METAL4_400000_129000 0.016
R_VDD2_6741 METAL4_400000_129000 METAL4_402000_129000 0.016
R_VDD2_6742 METAL4_402000_129000 METAL4_408000_129000 0.048
R_VDD2_6743 METAL4_408000_129000 METAL4_410000_129000 0.016
R_VDD2_6744 METAL4_410000_129000 METAL4_412000_129000 0.016
R_VDD2_6745 METAL4_412000_129000 METAL4_414000_129000 0.016
R_VDD2_6746 METAL4_414000_129000 METAL4_416000_129000 0.016
R_VDD2_6747 METAL4_416000_129000 METAL4_420000_129000 0.032
R_VDD2_6748 METAL4_420000_129000 METAL4_420000_133000 0.032
R_VDD2_6749 METAL4_420000_133000 METAL4_420000_141000 0.064
R_VDD2_6750 METAL4_420000_141000 METAL5_420000_141000 0.1
R_VDD2_6751 METAL5_420000_141000 METAL5_420000_145000 0.016
R_VDD2_6752 METAL5_420000_145000 METAL5_420000_153000 0.032
R_VDD2_6753 METAL5_420000_153000 METAL5_420000_157000 0.016
R_VDD2_6754 METAL5_420000_157000 METAL5_420000_165000 0.032
R_VDD2_6755 METAL5_420000_165000 METAL5_420000_169000 0.016
R_VDD2_6756 METAL5_420000_169000 METAL5_420000_177000 0.032
R_VDD2_6757 METAL5_420000_177000 METAL5_420000_181000 0.016
R_VDD2_6758 METAL5_420000_181000 METAL5_420000_193000 0.048
R_VDD2_6759 METAL5_420000_193000 METAL5_420000_205000 0.048
R_VDD2_6760 METAL5_420000_205000 METAL5_420000_217000 0.048
R_VDD2_6761 METAL5_420000_217000 METAL5_420000_229000 0.048
R_VDD2_6762 METAL5_420000_229000 METAL5_420000_233000 0.016
R_VDD2_6763 METAL5_420000_233000 METAL5_420000_241000 0.032
R_VDD2_6764 METAL5_420000_241000 METAL5_422000_241000 0.008
R_VDD2_6765 METAL5_422000_241000 METAL5_424000_241000 0.008
R_VDD2_6766 METAL5_424000_241000 METAL5_426000_241000 0.008
R_VDD2_6767 METAL5_426000_241000 METAL5_428000_241000 0.008
R_VDD2_6768 METAL5_428000_241000 METAL5_434000_241000 0.024
R_VDD2_6769 METAL5_434000_241000 METAL5_436000_241000 0.008
R_VDD2_6770 METAL5_436000_241000 METAL5_438000_241000 0.008
R_VDD2_6771 METAL5_438000_241000 METAL5_440000_241000 0.008
R_VDD2_6772 METAL5_440000_241000 METAL5_446000_241000 0.024
R_VDD2_6773 METAL5_446000_241000 METAL5_448000_241000 0.008
R_VDD2_6774 METAL5_448000_241000 METAL4_448000_241000 0.1
R_VDD2_6775 METAL4_448000_241000 METAL4_448000_245000 0.032
R_VDD2_6776 METAL4_448000_245000 METAL4_448000_253000 0.064
R_VDD2_6777 METAL4_448000_253000 METAL4_448000_257000 0.032
R_VDD2_6778 METAL4_448000_257000 METAL4_448000_265000 0.064
R_VDD2_6779 METAL4_448000_265000 METAL4_448000_269000 0.032
R_VDD2_6780 METAL4_448000_269000 METAL4_448000_277000 0.064
R_VDD2_6781 METAL4_448000_277000 METAL4_448000_281000 0.032
R_VDD2_6782 METAL4_448000_281000 METAL4_448000_289000 0.064
R_VDD2_6783 METAL4_448000_289000 METAL4_448000_293000 0.032
R_VDD2_6784 METAL4_448000_293000 METAL4_448000_301000 0.064
R_VDD2_6785 METAL4_448000_301000 METAL4_448000_305000 0.032
R_VDD2_6786 METAL4_448000_305000 METAL4_448000_313000 0.064
R_VDD2_6787 METAL4_448000_313000 METAL4_448000_317000 0.032
R_VDD2_6788 METAL4_448000_317000 METAL4_448000_329000 0.096
R_VDD2_6789 METAL4_448000_329000 METAL4_448000_341000 0.096
R_VDD2_6790 METAL4_448000_341000 METAL4_450000_341000 0.016
R_VDD2_6791 METAL4_450000_341000 METAL5_450000_341000 0.1
R_VDD2_6792 METAL5_450000_341000 METAL5_450000_353000 0.048
R_VDD2_6793 METAL5_450000_353000 METAL5_450000_365000 0.048
R_VDD2_6794 METAL5_450000_365000 METAL5_450000_377000 0.048
R_VDD2_6795 METAL5_450000_377000 METAL5_450000_389000 0.048
R_VDD2_6796 METAL5_450000_389000 METAL5_450000_401000 0.048
R_VDD2_6797 METAL5_450000_401000 METAL5_450000_405000 0.016
R_VDD2_6798 METAL5_450000_405000 METAL5_450000_417000 0.048
R_VDD2_6799 METAL5_450000_417000 METAL5_452000_417000 0.008
R_VDD2_6800 METAL5_452000_417000 METAL5_458000_417000 0.024
R_VDD2_6801 METAL5_458000_417000 METAL5_460000_417000 0.008
R_VDD2_6802 METAL5_460000_417000 METAL5_462000_417000 0.008
R_VDD2_6803 METAL5_462000_417000 METAL5_464000_417000 0.008
R_VDD2_6804 METAL5_464000_417000 METAL5_470000_417000 0.024
R_VDD2_6805 METAL5_470000_417000 METAL5_472000_417000 0.008
R_VDD2_6806 METAL5_472000_417000 METAL5_474000_417000 0.008
R_VDD2_6807 METAL5_474000_417000 METAL5_476000_417000 0.008
R_VDD2_6808 METAL5_476000_417000 METAL5_482000_417000 0.024
R_VDD2_6809 METAL5_482000_417000 METAL5_483000_417000 0.004
R_VDD2_6810 METAL5_483000_417000 METAL5_484000_417000 0.004
R_VDD2_6811 METAL5_484000_417000 METAL5_486000_417000 0.008
R_VDD2_6812 METAL5_486000_417000 METAL5_486000_429000 0.048
R_VDD2_6813 METAL5_486000_429000 METAL5_486000_441000 0.048
R_VDD2_6814 METAL5_486000_441000 METAL5_486000_453000 0.048
R_VDD2_6815 METAL5_486000_453000 METAL5_486000_465000 0.048
R_VDD2_6816 METAL5_486000_465000 METAL5_486000_469000 0.016
R_VDD2_6817 METAL5_486000_469000 METAL5_486000_477000 0.032
R_VDD2_6818 METAL5_486000_477000 METAL5_486000_481000 0.016
R_VDD2_6819 METAL5_486000_481000 METAL5_486000_489000 0.032
R_VDD2_6820 METAL5_486000_489000 METAL5_486000_493000 0.016
R_VDD2_6821 METAL5_486000_493000 METAL5_486000_501000 0.032
R_VDD2_6822 METAL5_486000_501000 METAL5_486000_505000 0.016
R_VDD2_6823 METAL5_486000_505000 METAL5_486000_517000 0.048
R_VDD2_6824 METAL5_486000_517000 METAL5_486000_529000 0.048
R_VDD2_6825 METAL5_486000_529000 METAL4_486000_529000 0.1
R_VDD2_6826 METAL4_486000_529000 METAL4_486000_541000 0.096
R_VDD2_6827 METAL4_486000_541000 METAL4_486000_553000 0.096
R_VDD2_6828 METAL4_486000_553000 METAL4_486000_565000 0.096
R_VDD2_6829 METAL4_486000_565000 METAL4_486000_577000 0.096
R_VDD2_6830 METAL4_486000_577000 METAL4_486000_589000 0.096
R_VDD2_6831 METAL4_486000_589000 METAL4_486000_601000 0.096
R_VDD2_6832 METAL4_486000_601000 METAL4_486000_613000 0.096
R_VDD2_6833 METAL4_486000_613000 METAL5_486000_613000 0.1
R_VDD2_6834 METAL5_486000_613000 METAL5_486000_625000 0.048
R_VDD2_6835 METAL5_486000_625000 METAL5_486000_681000 0.224
R_VDD2_6836 METAL5_486000_681000 METAL5_486000_693000 0.048
R_VDD2_6837 METAL5_486000_693000 METAL5_486000_705000 0.048
R_VDD2_6838 METAL5_486000_705000 METAL5_486000_707000 0.008
R_VDD2_6839 METAL5_486000_707000 METAL5_486000_717000 0.04
R_VDD2_6840 METAL5_486000_717000 METAL5_486000_769000 0.208
R_VDD2_6841 METAL5_486000_769000 METAL4_486000_769000 0.1
R_VDD2_6842 METAL4_486000_769000 METAL4_486000_781000 0.096
R_VDD2_6843 METAL4_486000_781000 METAL4_486000_793000 0.096
R_VDD2_6844 METAL4_486000_793000 METAL4_486000_805000 0.096
R_VDD2_6845 METAL4_486000_805000 METAL4_486000_817000 0.096
R_VDD2_6846 METAL4_486000_817000 METAL4_486000_829000 0.096
R_VDD2_6847 METAL4_486000_829000 METAL4_486000_841000 0.096
R_VDD2_6848 METAL4_486000_841000 METAL4_486000_853000 0.096
R_VDD2_6849 METAL4_486000_853000 METAL4_484000_853000 0.016
R_VDD2_6850 METAL4_484000_853000 METAL4_483000_853000 0.008
R_VDD2_6851 METAL4_483000_853000 METAL4_482000_853000 0.008
R_VDD2_6852 METAL4_482000_853000 METAL4_476000_853000 0.048
R_VDD2_6853 METAL4_476000_853000 METAL4_474000_853000 0.016
R_VDD2_6854 METAL4_474000_853000 METAL4_472000_853000 0.016
R_VDD2_6855 METAL4_472000_853000 METAL4_472000_857000 0.032
R_VDD2_6856 METAL4_472000_857000 METAL4_472000_865000 0.064
R_VDD2_6857 METAL4_472000_865000 METAL4_472000_869000 0.032
R_VDD2_6858 METAL4_472000_869000 METAL4_472000_877000 0.064
R_VDD2_6859 METAL4_472000_877000 METAL4_472000_881000 0.032
R_VDD2_6860 METAL4_472000_881000 METAL4_472000_889000 0.064
R_VDD2_6861 METAL4_472000_889000 METAL5_472000_889000 0.1
R_VDD2_6862 METAL5_472000_889000 METAL5_472000_893000 0.016
R_VDD2_6863 METAL5_472000_893000 METAL5_472000_901000 0.032
R_VDD2_6864 METAL5_472000_901000 METAL5_472000_905000 0.016
R_VDD2_6865 METAL5_472000_905000 METAL5_472000_913000 0.032
R_VDD2_6866 METAL5_472000_913000 METAL5_472000_917000 0.016
R_VDD2_6867 METAL5_472000_917000 METAL5_472000_929000 0.048
R_VDD2_6868 METAL5_472000_929000 METAL5_472000_941000 0.048
R_VDD2_6869 METAL5_472000_941000 METAL5_472000_953000 0.048
R_VDD2_6870 METAL5_472000_953000 METAL5_472000_965000 0.048
R_VDD2_6871 METAL5_472000_965000 METAL5_472000_977000 0.048
R_VDD2_6872 METAL5_472000_977000 METAL5_472000_989000 0.048
R_VDD2_6873 METAL5_472000_989000 METAL5_472000_1001000 0.048
R_VDD2_6874 METAL5_472000_1001000 METAL5_472000_1013000 0.048
R_VDD2_6875 METAL5_472000_1013000 METAL5_472000_1025000 0.048
R_VDD2_6876 METAL5_472000_1025000 METAL5_472000_1041000 0.064
R_VDD2_6877 METAL5_472000_1041000 METAL5_472000_1053000 0.048
R_VDD2_6878 METAL5_472000_1053000 METAL5_472000_1065000 0.048
R_VDD2_6879 METAL5_472000_1065000 METAL5_470000_1065000 0.008
R_VDD2_6880 METAL5_470000_1065000 METAL5_464000_1065000 0.024
R_VDD2_6881 METAL5_464000_1065000 METAL5_462000_1065000 0.008
R_VDD2_6882 METAL5_462000_1065000 METAL5_460000_1065000 0.008
R_VDD2_6883 METAL5_460000_1065000 METAL5_458000_1065000 0.008
R_VDD2_6884 METAL5_458000_1065000 METAL4_458000_1065000 0.1
R_VDD2_6885 METAL4_458000_1065000 METAL4_458000_1077000 0.096
R_VDD2_6886 METAL4_458000_1077000 METAL4_458000_1089000 0.096
R_VDD2_6887 METAL4_458000_1089000 METAL4_458000_1101000 0.096
R_VDD2_6888 METAL4_458000_1101000 METAL4_452000_1101000 0.048
R_VDD2_6889 METAL4_452000_1101000 METAL4_450000_1101000 0.016
R_VDD2_6890 METAL4_450000_1101000 METAL4_448000_1101000 0.016
R_VDD2_6891 METAL4_448000_1101000 METAL4_446000_1101000 0.016
R_VDD2_6892 METAL4_446000_1101000 METAL4_440000_1101000 0.048
R_VDD2_6893 METAL4_440000_1101000 METAL4_438000_1101000 0.016
R_VDD2_6894 METAL4_438000_1101000 METAL4_436000_1101000 0.016
R_VDD2_6895 METAL4_436000_1101000 METAL4_434000_1101000 0.016
R_VDD2_6896 METAL4_434000_1101000 METAL4_428000_1101000 0.048
R_VDD2_6897 METAL4_428000_1101000 METAL4_426000_1101000 0.016
R_VDD2_6898 METAL4_426000_1101000 METAL4_424000_1101000 0.016
R_VDD2_6899 METAL4_424000_1101000 METAL4_422000_1101000 0.016
R_VDD2_6900 METAL4_422000_1101000 METAL4_420000_1101000 0.016
R_VDD2_6901 METAL4_420000_1101000 METAL4_416000_1101000 0.032
R_VDD2_6902 METAL4_416000_1101000 METAL4_414000_1101000 0.016
R_VDD2_6903 METAL4_414000_1101000 METAL4_412000_1101000 0.016
R_VDD2_6904 METAL4_412000_1101000 METAL4_410000_1101000 0.016
R_VDD2_6905 METAL4_410000_1101000 METAL4_408000_1101000 0.016
R_VDD2_6906 METAL4_408000_1101000 METAL4_402000_1101000 0.048
R_VDD2_6907 METAL4_402000_1101000 METAL4_400000_1101000 0.016
R_VDD2_6908 METAL4_400000_1101000 METAL4_398000_1101000 0.016
R_VDD2_6909 METAL4_398000_1101000 METAL5_398000_1101000 0.1
R_VDD2_6910 METAL5_398000_1101000 METAL5_398000_1153000 0.208
R_VDD2_6911 METAL5_398000_1153000 METAL5_398000_1165000 0.048
R_VDD2_6912 METAL5_398000_1165000 METAL5_398000_1177000 0.048
R_VDD2_6913 METAL5_398000_1177000 METAL5_396000_1177000 0.008
R_VDD2_6914 METAL5_396000_1177000 METAL5_390000_1177000 0.024
R_VDD2_6915 METAL5_390000_1177000 METAL5_388000_1177000 0.008
R_VDD2_6916 METAL5_388000_1177000 METAL5_386000_1177000 0.008
R_VDD2_6917 METAL5_386000_1177000 METAL5_386000_1189000 0.048
R_VDD2_6918 METAL5_386000_1189000 METAL5_386000_1201000 0.048
R_VDD2_6919 METAL5_386000_1201000 METAL5_386000_1205000 0.016
R_VDD2_6920 METAL5_386000_1205000 METAL5_386000_1217000 0.048
R_VDD2_6921 METAL5_386000_1217000 METAL5_386000_1229000 0.048
R_VDD2_6922 METAL5_386000_1229000 METAL5_386000_1241000 0.048
R_VDD2_6923 METAL5_386000_1241000 METAL5_386000_1253000 0.048
R_VDD2_6924 METAL5_386000_1253000 METAL4_386000_1253000 0.1
R_VDD2_6925 METAL4_386000_1253000 METAL4_386000_1265000 0.096
R_VDD2_6926 METAL4_386000_1265000 METAL4_386000_1277000 0.096
R_VDD2_6927 METAL4_386000_1277000 METAL4_386000_1289000 0.096
R_VDD2_6928 METAL4_386000_1289000 METAL5_386000_1289000 0.1
R_VDD2_6929 METAL5_386000_1289000 METAL5_386000_1301000 0.048
R_VDD2_6930 METAL5_386000_1301000 METAL5_386000_1357000 0.224
R_VDD2_6931 METAL5_386000_1357000 METAL5_386000_1369000 0.048
R_VDD2_6932 METAL5_386000_1369000 METAL5_386000_1381000 0.048
R_VDD2_6933 METAL5_386000_1381000 METAL4_386000_1381000 0.1
R_VDD2_6934 METAL4_386000_1381000 METAL4_384000_1381000 0.016
R_VDD2_6935 METAL4_384000_1381000 METAL4_378000_1381000 0.048
R_VDD2_6936 METAL4_378000_1381000 METAL4_376000_1381000 0.016
R_VDD2_6937 METAL4_376000_1381000 METAL4_374000_1381000 0.016
R_VDD2_6938 METAL4_374000_1381000 METAL4_372000_1381000 0.016
R_VDD2_6939 METAL4_372000_1381000 METAL4_366000_1381000 0.048
R_VDD2_6940 METAL4_366000_1381000 METAL4_364000_1381000 0.016
R_VDD2_6941 METAL4_364000_1381000 METAL4_362000_1381000 0.016
R_VDD2_6942 METAL4_362000_1381000 METAL4_362000_1393000 0.096
R_VDD2_6943 METAL4_362000_1393000 METAL4_362000_1405000 0.096
R_VDD2_6944 METAL4_362000_1405000 METAL4_362000_1407000 0.016
R_VDD2_6945 METAL4_362000_1407000 METAL4_362000_1417000 0.08
R_VDD2_6946 METAL4_362000_1417000 METAL5_362000_1417000 0.1
R_VDD2_6947 METAL5_362000_1417000 METAL5_362000_1429000 0.048
R_VDD2_6948 METAL5_362000_1429000 METAL5_362000_1529000 0.4
R_VDD2_6949 METAL5_362000_1529000 METAL5_362000_1541000 0.048
R_VDD2_6950 METAL5_362000_1541000 METAL4_362000_1541000 0.1
R_VDD2_6951 METAL4_362000_1541000 METAL4_362000_1553000 0.096
R_VDD2_6952 METAL4_362000_1553000 METAL4_362000_1565000 0.096
R_VDD2_6953 METAL4_362000_1565000 METAL5_362000_1565000 0.1
R_VDD2_6954 METAL5_362000_1565000 METAL5_362000_1577000 0.048
R_VDD2_6955 METAL5_362000_1577000 METAL5_362000_1617000 0.16
R_VDD2_6956 METAL5_362000_1617000 METAL5_362000_1629000 0.048
R_VDD2_6957 METAL5_362000_1629000 METAL5_362000_1641000 0.048
R_VDD2_6958 METAL5_362000_1641000 METAL5_362000_1653000 0.048
R_VDD2_6959 METAL5_362000_1653000 METAL4_362000_1653000 0.1
R_VDD2_6960 METAL4_362000_1653000 METAL4_362000_1665000 0.096
R_VDD2_6961 METAL4_362000_1665000 METAL4_362000_1677000 0.096
R_VDD2_6962 METAL4_362000_1677000 METAL5_362000_1677000 0.1
R_VDD2_6963 METAL5_362000_1677000 METAL5_362000_1689000 0.048
R_VDD2_6964 METAL5_362000_1689000 METAL5_362000_1753000 0.256
R_VDD2_6965 METAL5_362000_1753000 METAL5_362000_1765000 0.048
R_VDD2_6966 METAL5_362000_1765000 METAL5_362000_1777000 0.048
R_VDD2_6967 METAL5_362000_1777000 METAL5_362000_1789000 0.048
R_VDD2_6968 METAL5_362000_1789000 METAL5_362000_1817000 0.112
R_VDD2_6969 METAL5_362000_1817000 METAL5_362000_1829000 0.048
R_VDD2_6970 METAL5_362000_1829000 METAL5_362000_1841000 0.048
R_VDD2_6971 METAL5_362000_1841000 METAL5_362000_1853000 0.048
R_VDD2_6972 METAL5_362000_1853000 METAL5_362000_1865000 0.048
R_VDD2_6973 METAL5_362000_1865000 METAL5_362000_1877000 0.048
R_VDD2_6974 METAL5_362000_1877000 METAL5_362000_1905000 0.112
R_VDD2_6975 METAL5_362000_1905000 METAL5_362000_1917000 0.048
R_VDD2_6976 METAL5_362000_1917000 METAL5_362000_1929000 0.048
R_VDD2_6977 METAL5_362000_1929000 METAL5_362000_1941000 0.048
R_VDD2_6978 METAL5_362000_1941000 METAL4_362000_1941000 0.1
R_VDD2_6979 METAL4_362000_1941000 METAL4_362000_1953000 0.096
R_VDD2_6980 METAL4_362000_1953000 METAL4_362000_1965000 0.096
R_VDD2_6981 METAL4_362000_1965000 METAL4_362000_1977000 0.096
R_VDD2_6982 METAL4_362000_1977000 METAL4_362000_1989000 0.096
R_VDD2_6983 METAL4_362000_1989000 METAL5_362000_1989000 0.1
R_VDD2_6984 METAL5_362000_1989000 METAL5_362000_2001000 0.048
R_VDD2_6985 METAL5_362000_2001000 METAL5_362000_2013000 0.048
R_VDD2_6986 METAL5_362000_2013000 METAL5_362000_2093000 0.32
R_VDD2_6987 METAL5_362000_2093000 METAL5_362000_2107000 0.056
R_VDD2_6988 METAL5_362000_2107000 METAL5_362000_2217000 0.44
R_VDD2_6989 METAL5_362000_2217000 METAL5_362000_2229000 0.048
R_VDD2_6990 METAL5_362000_2229000 METAL5_362000_2241000 0.048
R_VDD2_6991 METAL5_362000_2241000 METAL5_362000_2253000 0.048
R_VDD2_6992 METAL5_362000_2253000 METAL5_362000_2265000 0.048
R_VDD2_6993 METAL5_362000_2265000 METAL5_362000_2277000 0.048
R_VDD2_6994 METAL5_362000_2277000 METAL5_362000_2341000 0.256
R_VDD2_6995 METAL5_362000_2341000 METAL5_362000_2353000 0.048
R_VDD2_6996 METAL5_362000_2353000 METAL5_362000_2365000 0.048
R_VDD2_6997 METAL5_362000_2365000 METAL5_362000_2377000 0.048
R_VDD2_6998 METAL5_362000_2377000 METAL5_362000_2389000 0.048
R_VDD2_6999 METAL5_362000_2389000 METAL5_362000_2401000 0.048
R_VDD2_7000 METAL5_362000_2401000 METAL5_362000_2453000 0.208
R_VDD2_7001 METAL5_362000_2453000 METAL5_362000_2465000 0.048
R_VDD2_7002 METAL5_362000_2465000 METAL5_362000_2477000 0.048
R_VDD2_7003 METAL5_362000_2477000 METAL5_362000_2489000 0.048
R_VDD2_7004 METAL5_362000_2489000 METAL5_362000_2553000 0.256
R_VDD2_7005 METAL5_362000_2553000 METAL5_362000_2565000 0.048
R_VDD2_7006 METAL5_362000_2565000 METAL5_362000_2577000 0.048
R_VDD2_7007 METAL5_362000_2577000 METAL5_362000_2605000 0.112
R_VDD2_7008 METAL5_362000_2605000 METAL5_362000_2617000 0.048
R_VDD2_7009 METAL5_362000_2617000 METAL5_360000_2617000 0.008
R_VDD2_7010 METAL5_360000_2617000 METAL5_354000_2617000 0.024
R_VDD2_7011 METAL5_354000_2617000 METAL5_352000_2617000 0.008
R_VDD2_7012 METAL5_352000_2617000 METAL5_350000_2617000 0.008
R_VDD2_7013 METAL5_350000_2617000 METAL5_348000_2617000 0.008
R_VDD2_7014 METAL5_348000_2617000 METAL5_342000_2617000 0.024
R_VDD2_7015 METAL5_342000_2617000 METAL5_340000_2617000 0.008
R_VDD2_7016 METAL5_340000_2617000 METAL5_338000_2617000 0.008
R_VDD2_7017 METAL5_338000_2617000 METAL5_336000_2617000 0.008
R_VDD2_7018 METAL5_336000_2617000 METAL4_336000_2617000 0.1
R_VDD2_7019 METAL4_336000_2617000 METAL4_336000_2629000 0.096
R_VDD2_7020 METAL4_336000_2629000 METAL4_336000_2641000 0.096
R_VDD2_7021 METAL4_336000_2641000 METAL4_336000_2653000 0.096
R_VDD2_7022 METAL4_336000_2653000 METAL4_336000_2665000 0.096
R_VDD2_7023 METAL4_336000_2665000 METAL4_330000_2665000 0.048
R_VDD2_7024 METAL4_330000_2665000 METAL4_328000_2665000 0.016
R_VDD2_7025 METAL4_328000_2665000 METAL4_326000_2665000 0.016
R_VDD2_7026 METAL4_326000_2665000 METAL4_324000_2665000 0.016
R_VDD2_7027 METAL4_324000_2665000 METAL4_318000_2665000 0.048
R_VDD2_7028 METAL4_318000_2665000 METAL4_316000_2665000 0.016
R_VDD2_7029 METAL4_316000_2665000 METAL4_314000_2665000 0.016
R_VDD2_7030 METAL4_314000_2665000 METAL4_312000_2665000 0.016
R_VDD2_7031 METAL4_312000_2665000 METAL4_306000_2665000 0.048
R_VDD2_7032 METAL4_306000_2665000 METAL4_305000_2665000 0.008
R_VDD2_7033 METAL4_305000_2665000 METAL4_304000_2665000 0.008
R_VDD2_7034 METAL4_304000_2665000 METAL4_302000_2665000 0.016
R_VDD2_7035 METAL4_302000_2665000 METAL5_302000_2665000 0.1
R_VDD2_7036 METAL5_302000_2665000 METAL5_302000_2677000 0.048
R_VDD2_7037 METAL5_302000_2677000 METAL5_302000_2689000 0.048
R_VDD2_7038 METAL5_302000_2689000 METAL5_302000_2701000 0.048
R_VDD2_7039 METAL5_302000_2701000 METAL5_302000_2713000 0.048
R_VDD2_7040 METAL5_302000_2713000 METAL5_302000_2769000 0.224
R_VDD2_7041 METAL5_302000_2769000 METAL5_302000_2781000 0.048
R_VDD2_7042 METAL5_302000_2781000 METAL4_302000_2781000 0.1
R_VDD2_7043 METAL4_302000_2781000 METAL4_302000_2793000 0.096
R_VDD2_7044 METAL4_302000_2793000 METAL4_302000_2805000 0.096
R_VDD2_7045 METAL4_302000_2805000 METAL5_302000_2805000 0.1
R_VDD2_7046 METAL5_302000_2805000 METAL5_302000_2807000 0.008
R_VDD2_7047 METAL5_302000_2807000 METAL5_302000_2817000 0.04
R_VDD2_7048 METAL5_302000_2817000 METAL5_302000_2941000 0.496
R_VDD2_7049 METAL5_302000_2941000 METAL5_302000_2953000 0.048
R_VDD2_7050 METAL5_302000_2953000 METAL5_302000_2965000 0.048
R_VDD2_7051 METAL5_302000_2965000 METAL5_302000_2977000 0.048
R_VDD2_7052 METAL5_302000_2977000 METAL5_300000_2977000 0.008
R_VDD2_7053 METAL5_300000_2977000 METAL5_294000_2977000 0.024
R_VDD2_7054 METAL5_294000_2977000 METAL5_293000_2977000 0.004
R_VDD2_7055 METAL5_293000_2977000 METAL4_293000_2977000 0.1
R_VDD2_7056 METAL4_293000_2977000 METAL4_292000_2977000 0.008
R_VDD2_7057 METAL4_292000_2977000 METAL4_290000_2977000 0.016
R_VDD2_7058 METAL4_290000_2977000 METAL4_288000_2977000 0.016
R_VDD2_7059 METAL4_288000_2977000 METAL4_282000_2977000 0.048
R_VDD2_7060 METAL4_282000_2977000 METAL4_281000_2977000 0.008
R_VDD2_7061 METAL4_281000_2977000 METAL4_278000_2977000 0.024
R_VDD2_7062 METAL4_278000_2977000 METAL4_276000_2977000 0.016
R_VDD2_7063 METAL4_276000_2977000 METAL4_270000_2977000 0.048
R_VDD2_7064 METAL4_270000_2977000 METAL4_269000_2977000 0.008
R_VDD2_7065 METAL4_269000_2977000 METAL4_266000_2977000 0.024
R_VDD2_7066 METAL4_266000_2977000 METAL4_264000_2977000 0.016
R_VDD2_7067 METAL4_264000_2977000 METAL4_258000_2977000 0.048
R_VDD2_7068 METAL4_258000_2977000 METAL4_257000_2977000 0.008
R_VDD2_7069 METAL4_257000_2977000 METAL5_257000_2977000 0.1
R_VDD2_7070 METAL5_257000_2977000 METAL6_257000_2977000 0.1
R_VDD2_7071 METAL6_257000_2977000 METAL6_257000_2989000 0.024
R_VDD2_7072 METAL6_257000_2989000 METAL6_257000_3001000 0.024
R_VDD2_7073 METAL6_257000_3001000 METAL6_257000_3053000 0.104
R_VDD2_7074 METAL6_257000_3053000 METAL6_257000_3065000 0.024
R_VDD2_7075 METAL6_555000_2365000 METAL6_543000_2365000 0.024
R_VDD2_7076 METAL4_386000_129000 METAL4_386000_121000 0.064
R_VDD2_7077 METAL4_386000_121000 METAL4_386000_117000 0.032
R_VDD2_7078 METAL4_386000_117000 METAL4_388000_117000 0.016
R_VDD2_7079 METAL4_388000_117000 METAL4_390000_117000 0.016
R_VDD2_7080 METAL4_390000_117000 METAL4_396000_117000 0.048
R_VDD2_7081 METAL4_396000_117000 METAL4_398000_117000 0.016
R_VDD2_7082 METAL4_398000_117000 METAL4_400000_117000 0.016
R_VDD2_7083 METAL4_400000_117000 METAL4_402000_117000 0.016
R_VDD2_7084 METAL4_402000_117000 METAL4_408000_117000 0.048
R_VDD2_7085 METAL4_408000_117000 METAL4_410000_117000 0.016
R_VDD2_7086 METAL4_410000_117000 METAL4_412000_117000 0.016
R_VDD2_7087 METAL4_412000_117000 METAL4_414000_117000 0.016
R_VDD2_7088 METAL4_414000_117000 METAL4_416000_117000 0.016
R_VDD2_7089 METAL4_416000_117000 METAL4_420000_117000 0.032
R_VDD2_7090 METAL4_420000_117000 METAL4_422000_117000 0.016
R_VDD2_7091 METAL4_422000_117000 METAL4_424000_117000 0.016
R_VDD2_7092 METAL4_424000_117000 METAL4_426000_117000 0.016
R_VDD2_7093 METAL4_426000_117000 METAL4_428000_117000 0.016
R_VDD2_7094 METAL4_428000_117000 METAL4_432000_117000 0.032
R_VDD2_7095 METAL4_432000_117000 METAL4_432000_121000 0.032
R_VDD2_7096 METAL4_432000_121000 METAL4_432000_129000 0.064
R_VDD2_7097 METAL4_432000_129000 METAL4_432000_133000 0.032
R_VDD2_7098 METAL4_432000_133000 METAL4_432000_141000 0.064
R_VDD2_7099 METAL4_432000_141000 METAL5_432000_141000 0.1
R_VDD2_7100 METAL5_432000_141000 METAL5_432000_145000 0.016
R_VDD2_7101 METAL5_432000_145000 METAL5_432000_153000 0.032
R_VDD2_7102 METAL5_432000_153000 METAL5_432000_157000 0.016
R_VDD2_7103 METAL5_432000_157000 METAL5_432000_165000 0.032
R_VDD2_7104 METAL5_432000_165000 METAL5_432000_169000 0.016
R_VDD2_7105 METAL5_432000_169000 METAL5_432000_177000 0.032
R_VDD2_7106 METAL5_432000_177000 METAL5_432000_181000 0.016
R_VDD2_7107 METAL5_432000_181000 METAL5_432000_193000 0.048
R_VDD2_7108 METAL5_432000_193000 METAL5_432000_205000 0.048
R_VDD2_7109 METAL5_432000_205000 METAL5_432000_217000 0.048
R_VDD2_7110 METAL5_432000_217000 METAL5_432000_229000 0.048
R_VDD2_7111 METAL5_432000_229000 METAL5_434000_229000 0.008
R_VDD2_7112 METAL5_434000_229000 METAL5_436000_229000 0.008
R_VDD2_7113 METAL5_436000_229000 METAL5_438000_229000 0.008
R_VDD2_7114 METAL5_438000_229000 METAL5_440000_229000 0.008
R_VDD2_7115 METAL5_440000_229000 METAL5_446000_229000 0.024
R_VDD2_7116 METAL5_446000_229000 METAL5_448000_229000 0.008
R_VDD2_7117 METAL5_448000_229000 METAL4_448000_229000 0.1
R_VDD2_7118 METAL4_448000_229000 METAL4_450000_229000 0.016
R_VDD2_7119 METAL4_450000_229000 METAL4_452000_229000 0.016
R_VDD2_7120 METAL4_452000_229000 METAL4_458000_229000 0.048
R_VDD2_7121 METAL4_458000_229000 METAL4_460000_229000 0.016
R_VDD2_7122 METAL4_460000_229000 METAL4_460000_233000 0.032
R_VDD2_7123 METAL4_460000_233000 METAL4_460000_241000 0.064
R_VDD2_7124 METAL4_460000_241000 METAL4_460000_245000 0.032
R_VDD2_7125 METAL4_460000_245000 METAL4_460000_253000 0.064
R_VDD2_7126 METAL4_460000_253000 METAL4_460000_257000 0.032
R_VDD2_7127 METAL4_460000_257000 METAL4_460000_265000 0.064
R_VDD2_7128 METAL4_460000_265000 METAL4_460000_269000 0.032
R_VDD2_7129 METAL4_460000_269000 METAL4_460000_277000 0.064
R_VDD2_7130 METAL4_460000_277000 METAL4_460000_281000 0.032
R_VDD2_7131 METAL4_460000_281000 METAL4_460000_289000 0.064
R_VDD2_7132 METAL4_460000_289000 METAL4_460000_293000 0.032
R_VDD2_7133 METAL4_460000_293000 METAL4_460000_301000 0.064
R_VDD2_7134 METAL4_460000_301000 METAL4_460000_305000 0.032
R_VDD2_7135 METAL4_460000_305000 METAL4_460000_313000 0.064
R_VDD2_7136 METAL4_460000_313000 METAL4_460000_317000 0.032
R_VDD2_7137 METAL4_460000_317000 METAL4_460000_329000 0.096
R_VDD2_7138 METAL4_460000_329000 METAL4_462000_329000 0.016
R_VDD2_7139 METAL4_462000_329000 METAL4_462000_341000 0.096
R_VDD2_7140 METAL4_462000_341000 METAL5_462000_341000 0.1
R_VDD2_7141 METAL5_462000_341000 METAL5_462000_353000 0.048
R_VDD2_7142 METAL5_462000_353000 METAL5_462000_365000 0.048
R_VDD2_7143 METAL5_462000_365000 METAL5_462000_377000 0.048
R_VDD2_7144 METAL5_462000_377000 METAL5_462000_389000 0.048
R_VDD2_7145 METAL5_462000_389000 METAL5_462000_401000 0.048
R_VDD2_7146 METAL5_462000_401000 METAL5_462000_405000 0.016
R_VDD2_7147 METAL5_462000_405000 METAL5_464000_405000 0.008
R_VDD2_7148 METAL5_464000_405000 METAL5_470000_405000 0.024
R_VDD2_7149 METAL5_470000_405000 METAL5_472000_405000 0.008
R_VDD2_7150 METAL5_472000_405000 METAL5_474000_405000 0.008
R_VDD2_7151 METAL5_474000_405000 METAL5_476000_405000 0.008
R_VDD2_7152 METAL5_476000_405000 METAL5_482000_405000 0.024
R_VDD2_7153 METAL5_482000_405000 METAL5_483000_405000 0.004
R_VDD2_7154 METAL5_483000_405000 METAL5_484000_405000 0.004
R_VDD2_7155 METAL5_484000_405000 METAL5_486000_405000 0.008
R_VDD2_7156 METAL5_486000_405000 METAL5_488000_405000 0.008
R_VDD2_7157 METAL5_488000_405000 METAL5_495000_405000 0.028
R_VDD2_7158 METAL5_495000_405000 METAL5_496000_405000 0.004
R_VDD2_7159 METAL5_496000_405000 METAL5_498000_405000 0.008
R_VDD2_7160 METAL5_498000_405000 METAL5_498000_417000 0.048
R_VDD2_7161 METAL5_498000_417000 METAL5_498000_429000 0.048
R_VDD2_7162 METAL5_498000_429000 METAL5_498000_441000 0.048
R_VDD2_7163 METAL5_498000_441000 METAL5_498000_453000 0.048
R_VDD2_7164 METAL5_498000_453000 METAL5_498000_465000 0.048
R_VDD2_7165 METAL5_498000_465000 METAL5_498000_469000 0.016
R_VDD2_7166 METAL5_498000_469000 METAL5_498000_477000 0.032
R_VDD2_7167 METAL5_498000_477000 METAL5_498000_481000 0.016
R_VDD2_7168 METAL5_498000_481000 METAL5_498000_489000 0.032
R_VDD2_7169 METAL5_498000_489000 METAL5_498000_493000 0.016
R_VDD2_7170 METAL5_498000_493000 METAL5_498000_501000 0.032
R_VDD2_7171 METAL5_498000_501000 METAL5_498000_505000 0.016
R_VDD2_7172 METAL5_498000_505000 METAL5_498000_517000 0.048
R_VDD2_7173 METAL5_498000_517000 METAL5_498000_529000 0.048
R_VDD2_7174 METAL5_498000_529000 METAL5_500000_529000 0.008
R_VDD2_7175 METAL5_500000_529000 METAL5_507000_529000 0.028
R_VDD2_7176 METAL5_507000_529000 METAL5_508000_529000 0.004
R_VDD2_7177 METAL5_508000_529000 METAL5_512000_529000 0.016
R_VDD2_7178 METAL5_512000_529000 METAL5_519000_529000 0.028
R_VDD2_7179 METAL5_519000_529000 METAL4_519000_529000 0.1
R_VDD2_7180 METAL4_519000_529000 METAL4_519000_541000 0.096
R_VDD2_7181 METAL4_519000_541000 METAL4_524000_541000 0.04
R_VDD2_7182 METAL4_524000_541000 METAL4_524000_553000 0.096
R_VDD2_7183 METAL4_524000_553000 METAL4_524000_565000 0.096
R_VDD2_7184 METAL4_524000_565000 METAL4_524000_577000 0.096
R_VDD2_7185 METAL4_524000_577000 METAL4_524000_589000 0.096
R_VDD2_7186 METAL4_524000_589000 METAL4_524000_601000 0.096
R_VDD2_7187 METAL4_524000_601000 METAL4_524000_613000 0.096
R_VDD2_7188 METAL4_524000_613000 METAL5_524000_613000 0.1
R_VDD2_7189 METAL5_524000_613000 METAL5_524000_625000 0.048
R_VDD2_7190 METAL5_524000_625000 METAL5_524000_681000 0.224
R_VDD2_7191 METAL5_524000_681000 METAL5_524000_693000 0.048
R_VDD2_7192 METAL5_524000_693000 METAL5_531000_693000 0.028
R_VDD2_7193 METAL5_531000_693000 METAL5_531000_705000 0.048
R_VDD2_7194 METAL5_531000_705000 METAL5_531000_707000 0.008
R_VDD2_7195 METAL5_531000_707000 METAL5_531000_717000 0.04
R_VDD2_7196 METAL5_531000_717000 METAL5_531000_757000 0.16
R_VDD2_7197 METAL5_531000_757000 METAL5_531000_769000 0.048
R_VDD2_7198 METAL5_531000_769000 METAL5_531000_781000 0.048
R_VDD2_7199 METAL5_531000_781000 METAL5_531000_793000 0.048
R_VDD2_7200 METAL5_531000_793000 METAL5_531000_805000 0.048
R_VDD2_7201 METAL5_531000_805000 METAL5_531000_817000 0.048
R_VDD2_7202 METAL5_531000_817000 METAL5_531000_829000 0.048
R_VDD2_7203 METAL5_531000_829000 METAL5_531000_841000 0.048
R_VDD2_7204 METAL5_531000_841000 METAL4_531000_841000 0.1
R_VDD2_7205 METAL4_531000_841000 METAL4_531000_853000 0.096
R_VDD2_7206 METAL4_531000_853000 METAL4_531000_857000 0.032
R_VDD2_7207 METAL4_531000_857000 METAL4_531000_865000 0.064
R_VDD2_7208 METAL4_531000_865000 METAL4_531000_869000 0.032
R_VDD2_7209 METAL4_531000_869000 METAL4_531000_877000 0.064
R_VDD2_7210 METAL4_531000_877000 METAL4_531000_881000 0.032
R_VDD2_7211 METAL4_531000_881000 METAL4_531000_889000 0.064
R_VDD2_7212 METAL4_531000_889000 METAL4_531000_893000 0.032
R_VDD2_7213 METAL4_531000_893000 METAL4_531000_901000 0.064
R_VDD2_7214 METAL4_531000_901000 METAL4_531000_905000 0.032
R_VDD2_7215 METAL4_531000_905000 METAL4_531000_913000 0.064
R_VDD2_7216 METAL4_531000_913000 METAL4_531000_917000 0.032
R_VDD2_7217 METAL4_531000_917000 METAL4_531000_929000 0.096
R_VDD2_7218 METAL4_531000_929000 METAL4_531000_941000 0.096
R_VDD2_7219 METAL4_531000_941000 METAL4_531000_953000 0.096
R_VDD2_7220 METAL4_531000_953000 METAL4_531000_965000 0.096
R_VDD2_7221 METAL4_531000_965000 METAL4_531000_977000 0.096
R_VDD2_7222 METAL4_531000_977000 METAL4_531000_989000 0.096
R_VDD2_7223 METAL4_531000_989000 METAL5_531000_989000 0.1
R_VDD2_7224 METAL5_531000_989000 METAL5_531000_1001000 0.048
R_VDD2_7225 METAL5_531000_1001000 METAL5_531000_1013000 0.048
R_VDD2_7226 METAL5_531000_1013000 METAL5_531000_1025000 0.048
R_VDD2_7227 METAL5_531000_1025000 METAL5_531000_1041000 0.064
R_VDD2_7228 METAL5_531000_1041000 METAL5_531000_1053000 0.048
R_VDD2_7229 METAL5_531000_1053000 METAL5_531000_1065000 0.048
R_VDD2_7230 METAL5_531000_1065000 METAL4_531000_1065000 0.1
R_VDD2_7231 METAL4_531000_1065000 METAL4_531000_1077000 0.096
R_VDD2_7232 METAL4_531000_1077000 METAL4_531000_1089000 0.096
R_VDD2_7233 METAL4_531000_1089000 METAL5_531000_1089000 0.1
R_VDD2_7234 METAL5_531000_1089000 METAL5_531000_1101000 0.048
R_VDD2_7235 METAL5_531000_1101000 METAL5_531000_1113000 0.048
R_VDD2_7236 METAL5_531000_1113000 METAL5_531000_1153000 0.16
R_VDD2_7237 METAL5_531000_1153000 METAL5_531000_1165000 0.048
R_VDD2_7238 METAL5_531000_1165000 METAL4_531000_1165000 0.1
R_VDD2_7239 METAL4_531000_1165000 METAL4_531000_1177000 0.096
R_VDD2_7240 METAL4_531000_1177000 METAL4_531000_1189000 0.096
R_VDD2_7241 METAL4_531000_1189000 METAL5_531000_1189000 0.1
R_VDD2_7242 METAL5_531000_1189000 METAL5_531000_1201000 0.048
R_VDD2_7243 METAL5_531000_1201000 METAL5_531000_1205000 0.016
R_VDD2_7244 METAL5_531000_1205000 METAL5_531000_1217000 0.048
R_VDD2_7245 METAL5_531000_1217000 METAL5_531000_1229000 0.048
R_VDD2_7246 METAL5_531000_1229000 METAL5_531000_1241000 0.048
R_VDD2_7247 METAL5_531000_1241000 METAL5_531000_1253000 0.048
R_VDD2_7248 METAL5_531000_1253000 METAL5_531000_1265000 0.048
R_VDD2_7249 METAL5_531000_1265000 METAL5_531000_1277000 0.048
R_VDD2_7250 METAL5_531000_1277000 METAL5_531000_1289000 0.048
R_VDD2_7251 METAL5_531000_1289000 METAL5_531000_1301000 0.048
R_VDD2_7252 METAL5_531000_1301000 METAL5_531000_1357000 0.224
R_VDD2_7253 METAL5_531000_1357000 METAL5_531000_1369000 0.048
R_VDD2_7254 METAL5_531000_1369000 METAL4_531000_1369000 0.1
R_VDD2_7255 METAL4_531000_1369000 METAL4_531000_1381000 0.096
R_VDD2_7256 METAL4_531000_1381000 METAL4_531000_1393000 0.096
R_VDD2_7257 METAL4_531000_1393000 METAL5_531000_1393000 0.1
R_VDD2_7258 METAL5_531000_1393000 METAL5_531000_1405000 0.048
R_VDD2_7259 METAL5_531000_1405000 METAL5_531000_1407000 0.008
R_VDD2_7260 METAL5_531000_1407000 METAL5_531000_1417000 0.04
R_VDD2_7261 METAL5_531000_1417000 METAL5_531000_1429000 0.048
R_VDD2_7262 METAL5_531000_1429000 METAL5_531000_1529000 0.4
R_VDD2_7263 METAL5_531000_1529000 METAL5_531000_1541000 0.048
R_VDD2_7264 METAL5_531000_1541000 METAL4_531000_1541000 0.1
R_VDD2_7265 METAL4_531000_1541000 METAL4_531000_1553000 0.096
R_VDD2_7266 METAL4_531000_1553000 METAL4_531000_1565000 0.096
R_VDD2_7267 METAL4_531000_1565000 METAL4_531000_1577000 0.096
R_VDD2_7268 METAL4_531000_1577000 METAL4_531000_1617000 0.32
R_VDD2_7269 METAL4_531000_1617000 METAL4_531000_1629000 0.096
R_VDD2_7270 METAL4_531000_1629000 METAL4_531000_1641000 0.096
R_VDD2_7271 METAL4_531000_1641000 METAL4_531000_1653000 0.096
R_VDD2_7272 METAL4_531000_1653000 METAL4_531000_1665000 0.096
R_VDD2_7273 METAL4_531000_1665000 METAL4_524000_1665000 0.056
R_VDD2_7274 METAL4_524000_1665000 METAL4_519000_1665000 0.04
R_VDD2_7275 METAL4_519000_1665000 METAL4_512000_1665000 0.056
R_VDD2_7276 METAL4_512000_1665000 METAL4_508000_1665000 0.032
R_VDD2_7277 METAL4_508000_1665000 METAL4_507000_1665000 0.008
R_VDD2_7278 METAL4_507000_1665000 METAL4_507000_1677000 0.096
R_VDD2_7279 METAL4_507000_1677000 METAL4_507000_1689000 0.096
R_VDD2_7280 METAL4_507000_1689000 METAL4_508000_1689000 0.008
R_VDD2_7281 METAL4_508000_1689000 METAL4_512000_1689000 0.032
R_VDD2_7282 METAL4_512000_1689000 METAL4_519000_1689000 0.056
R_VDD2_7283 METAL4_519000_1689000 METAL5_519000_1689000 0.1
R_VDD2_7284 METAL5_519000_1689000 METAL5_519000_1753000 0.256
R_VDD2_7285 METAL5_519000_1753000 METAL5_519000_1765000 0.048
R_VDD2_7286 METAL5_519000_1765000 METAL5_519000_1777000 0.048
R_VDD2_7287 METAL5_519000_1777000 METAL5_519000_1789000 0.048
R_VDD2_7288 METAL5_519000_1789000 METAL5_519000_1817000 0.112
R_VDD2_7289 METAL5_519000_1817000 METAL5_519000_1829000 0.048
R_VDD2_7290 METAL5_519000_1829000 METAL5_519000_1841000 0.048
R_VDD2_7291 METAL5_519000_1841000 METAL5_519000_1853000 0.048
R_VDD2_7292 METAL5_519000_1853000 METAL5_519000_1865000 0.048
R_VDD2_7293 METAL5_519000_1865000 METAL5_519000_1877000 0.048
R_VDD2_7294 METAL5_519000_1877000 METAL5_519000_1905000 0.112
R_VDD2_7295 METAL5_519000_1905000 METAL5_519000_1917000 0.048
R_VDD2_7296 METAL5_519000_1917000 METAL5_519000_1929000 0.048
R_VDD2_7297 METAL5_519000_1929000 METAL4_519000_1929000 0.1
R_VDD2_7298 METAL4_519000_1929000 METAL4_519000_1941000 0.096
R_VDD2_7299 METAL4_519000_1941000 METAL4_519000_1953000 0.096
R_VDD2_7300 METAL4_519000_1953000 METAL4_519000_1965000 0.096
R_VDD2_7301 METAL4_519000_1965000 METAL4_519000_1977000 0.096
R_VDD2_7302 METAL4_519000_1977000 METAL4_519000_1989000 0.096
R_VDD2_7303 METAL4_519000_1989000 METAL5_519000_1989000 0.1
R_VDD2_7304 METAL5_519000_1989000 METAL5_519000_2001000 0.048
R_VDD2_7305 METAL5_519000_2001000 METAL5_519000_2013000 0.048
R_VDD2_7306 METAL5_519000_2013000 METAL5_519000_2093000 0.32
R_VDD2_7307 METAL5_519000_2093000 METAL5_519000_2107000 0.056
R_VDD2_7308 METAL5_519000_2107000 METAL5_519000_2217000 0.44
R_VDD2_7309 METAL5_519000_2217000 METAL5_519000_2229000 0.048
R_VDD2_7310 METAL5_519000_2229000 METAL5_519000_2241000 0.048
R_VDD2_7311 METAL5_519000_2241000 METAL5_519000_2253000 0.048
R_VDD2_7312 METAL5_519000_2253000 METAL5_519000_2265000 0.048
R_VDD2_7313 METAL5_519000_2265000 METAL5_519000_2277000 0.048
R_VDD2_7314 METAL5_519000_2277000 METAL4_519000_2277000 0.1
R_VDD2_7315 METAL4_519000_2277000 METAL4_524000_2277000 0.04
R_VDD2_7316 METAL4_524000_2277000 METAL4_531000_2277000 0.056
R_VDD2_7317 METAL4_531000_2277000 METAL4_543000_2277000 0.096
R_VDD2_7318 METAL4_543000_2277000 METAL5_543000_2277000 0.1
R_VDD2_7319 METAL5_543000_2277000 METAL6_543000_2277000 0.1
R_VDD2_7320 METAL6_543000_2277000 METAL6_543000_2341000 0.128
R_VDD2_7321 METAL6_543000_2341000 METAL6_543000_2353000 0.024
R_VDD2_7322 METAL6_543000_2353000 METAL6_543000_2365000 0.024
R_VDD2_7323 METAL6_245000_2365000 METAL6_257000_2365000 0.024
R_VDD2_7324 METAL5_304000_121000 METAL5_302000_121000 0.008
R_VDD2_7325 METAL5_302000_121000 METAL5_300000_121000 0.008
R_VDD2_7326 METAL5_300000_121000 METAL5_294000_121000 0.024
R_VDD2_7327 METAL5_294000_121000 METAL5_293000_121000 0.004
R_VDD2_7328 METAL5_293000_121000 METAL5_292000_121000 0.004
R_VDD2_7329 METAL5_292000_121000 METAL5_292000_129000 0.032
R_VDD2_7330 METAL5_292000_129000 METAL5_292000_133000 0.016
R_VDD2_7331 METAL5_292000_133000 METAL5_292000_141000 0.032
R_VDD2_7332 METAL5_292000_141000 METAL5_292000_145000 0.016
R_VDD2_7333 METAL5_292000_145000 METAL5_292000_153000 0.032
R_VDD2_7334 METAL5_292000_153000 METAL5_292000_157000 0.016
R_VDD2_7335 METAL5_292000_157000 METAL5_292000_165000 0.032
R_VDD2_7336 METAL5_292000_165000 METAL5_292000_169000 0.016
R_VDD2_7337 METAL5_292000_169000 METAL5_292000_177000 0.032
R_VDD2_7338 METAL5_292000_177000 METAL5_292000_181000 0.016
R_VDD2_7339 METAL5_292000_181000 METAL5_292000_193000 0.048
R_VDD2_7340 METAL5_292000_193000 METAL5_292000_205000 0.048
R_VDD2_7341 METAL5_292000_205000 METAL5_292000_217000 0.048
R_VDD2_7342 METAL5_292000_217000 METAL5_292000_229000 0.048
R_VDD2_7343 METAL5_292000_229000 METAL5_292000_233000 0.016
R_VDD2_7344 METAL5_292000_233000 METAL5_292000_241000 0.032
R_VDD2_7345 METAL5_292000_241000 METAL5_292000_245000 0.016
R_VDD2_7346 METAL5_292000_245000 METAL4_292000_245000 0.1
R_VDD2_7347 METAL4_292000_245000 METAL4_292000_253000 0.064
R_VDD2_7348 METAL4_292000_253000 METAL4_292000_257000 0.032
R_VDD2_7349 METAL4_292000_257000 METAL4_292000_265000 0.064
R_VDD2_7350 METAL4_292000_265000 METAL4_292000_269000 0.032
R_VDD2_7351 METAL4_292000_269000 METAL4_292000_277000 0.064
R_VDD2_7352 METAL4_292000_277000 METAL4_292000_281000 0.032
R_VDD2_7353 METAL4_292000_281000 METAL4_292000_289000 0.064
R_VDD2_7354 METAL4_292000_289000 METAL4_292000_293000 0.032
R_VDD2_7355 METAL4_292000_293000 METAL4_292000_301000 0.064
R_VDD2_7356 METAL4_292000_301000 METAL4_292000_305000 0.032
R_VDD2_7357 METAL4_292000_305000 METAL4_292000_313000 0.064
R_VDD2_7358 METAL4_292000_313000 METAL4_292000_317000 0.032
R_VDD2_7359 METAL4_292000_317000 METAL4_292000_329000 0.096
R_VDD2_7360 METAL4_292000_329000 METAL4_292000_341000 0.096
R_VDD2_7361 METAL4_292000_341000 METAL4_292000_353000 0.096
R_VDD2_7362 METAL4_292000_353000 METAL4_292000_365000 0.096
R_VDD2_7363 METAL4_292000_365000 METAL4_292000_377000 0.096
R_VDD2_7364 METAL4_292000_377000 METAL4_292000_389000 0.096
R_VDD2_7365 METAL4_292000_389000 METAL4_292000_393000 0.032
R_VDD2_7366 METAL4_292000_393000 METAL4_292000_401000 0.064
R_VDD2_7367 METAL4_292000_401000 METAL4_292000_405000 0.032
R_VDD2_7368 METAL4_292000_405000 METAL4_292000_417000 0.096
R_VDD2_7369 METAL4_292000_417000 METAL4_292000_429000 0.096
R_VDD2_7370 METAL4_292000_429000 METAL4_292000_441000 0.096
R_VDD2_7371 METAL4_292000_441000 METAL4_293000_441000 0.008
R_VDD2_7372 METAL4_293000_441000 METAL4_294000_441000 0.008
R_VDD2_7373 METAL4_294000_441000 METAL4_300000_441000 0.048
R_VDD2_7374 METAL4_300000_441000 METAL4_300000_453000 0.096
R_VDD2_7375 METAL4_300000_453000 METAL4_300000_465000 0.096
R_VDD2_7376 METAL4_300000_465000 METAL4_300000_469000 0.032
R_VDD2_7377 METAL4_300000_469000 METAL4_300000_477000 0.064
R_VDD2_7378 METAL4_300000_477000 METAL4_300000_481000 0.032
R_VDD2_7379 METAL4_300000_481000 METAL4_300000_489000 0.064
R_VDD2_7380 METAL4_300000_489000 METAL4_300000_493000 0.032
R_VDD2_7381 METAL4_300000_493000 METAL4_300000_501000 0.064
R_VDD2_7382 METAL4_300000_501000 METAL4_300000_505000 0.032
R_VDD2_7383 METAL4_300000_505000 METAL4_300000_517000 0.096
R_VDD2_7384 METAL4_300000_517000 METAL4_302000_517000 0.016
R_VDD2_7385 METAL4_302000_517000 METAL4_304000_517000 0.016
R_VDD2_7386 METAL4_304000_517000 METAL4_305000_517000 0.008
R_VDD2_7387 METAL4_305000_517000 METAL4_306000_517000 0.008
R_VDD2_7388 METAL4_306000_517000 METAL4_312000_517000 0.048
R_VDD2_7389 METAL4_312000_517000 METAL4_314000_517000 0.016
R_VDD2_7390 METAL4_314000_517000 METAL4_316000_517000 0.016
R_VDD2_7391 METAL4_316000_517000 METAL4_318000_517000 0.016
R_VDD2_7392 METAL4_318000_517000 METAL4_324000_517000 0.048
R_VDD2_7393 METAL4_324000_517000 METAL4_326000_517000 0.016
R_VDD2_7394 METAL4_326000_517000 METAL4_328000_517000 0.016
R_VDD2_7395 METAL4_328000_517000 METAL4_330000_517000 0.016
R_VDD2_7396 METAL4_330000_517000 METAL4_336000_517000 0.048
R_VDD2_7397 METAL4_336000_517000 METAL4_336000_529000 0.096
R_VDD2_7398 METAL4_336000_529000 METAL4_336000_541000 0.096
R_VDD2_7399 METAL4_336000_541000 METAL4_336000_553000 0.096
R_VDD2_7400 METAL4_336000_553000 METAL4_336000_565000 0.096
R_VDD2_7401 METAL4_336000_565000 METAL4_338000_565000 0.016
R_VDD2_7402 METAL4_338000_565000 METAL4_340000_565000 0.016
R_VDD2_7403 METAL4_340000_565000 METAL4_342000_565000 0.016
R_VDD2_7404 METAL4_342000_565000 METAL4_348000_565000 0.048
R_VDD2_7405 METAL4_348000_565000 METAL4_350000_565000 0.016
R_VDD2_7406 METAL4_350000_565000 METAL4_352000_565000 0.016
R_VDD2_7407 METAL4_352000_565000 METAL4_354000_565000 0.016
R_VDD2_7408 METAL4_354000_565000 METAL4_360000_565000 0.048
R_VDD2_7409 METAL4_360000_565000 METAL4_362000_565000 0.016
R_VDD2_7410 METAL4_362000_565000 METAL4_364000_565000 0.016
R_VDD2_7411 METAL4_364000_565000 METAL4_366000_565000 0.016
R_VDD2_7412 METAL4_366000_565000 METAL4_372000_565000 0.048
R_VDD2_7413 METAL4_372000_565000 METAL4_374000_565000 0.016
R_VDD2_7414 METAL4_374000_565000 METAL4_376000_565000 0.016
R_VDD2_7415 METAL4_376000_565000 METAL4_378000_565000 0.016
R_VDD2_7416 METAL4_378000_565000 METAL4_384000_565000 0.048
R_VDD2_7417 METAL4_384000_565000 METAL4_386000_565000 0.016
R_VDD2_7418 METAL4_386000_565000 METAL4_388000_565000 0.016
R_VDD2_7419 METAL4_388000_565000 METAL4_390000_565000 0.016
R_VDD2_7420 METAL4_390000_565000 METAL4_396000_565000 0.048
R_VDD2_7421 METAL4_396000_565000 METAL4_398000_565000 0.016
R_VDD2_7422 METAL4_398000_565000 METAL4_400000_565000 0.016
R_VDD2_7423 METAL4_400000_565000 METAL4_402000_565000 0.016
R_VDD2_7424 METAL4_402000_565000 METAL4_408000_565000 0.048
R_VDD2_7425 METAL4_408000_565000 METAL4_408000_577000 0.096
R_VDD2_7426 METAL4_408000_577000 METAL4_408000_589000 0.096
R_VDD2_7427 METAL4_408000_589000 METAL4_408000_601000 0.096
R_VDD2_7428 METAL4_408000_601000 METAL5_408000_601000 0.1
R_VDD2_7429 METAL5_408000_601000 METAL5_408000_613000 0.048
R_VDD2_7430 METAL5_408000_613000 METAL5_408000_625000 0.048
R_VDD2_7431 METAL5_408000_625000 METAL5_408000_681000 0.224
R_VDD2_7432 METAL5_408000_681000 METAL5_408000_693000 0.048
R_VDD2_7433 METAL5_408000_693000 METAL5_408000_705000 0.048
R_VDD2_7434 METAL5_408000_705000 METAL5_408000_707000 0.008
R_VDD2_7435 METAL5_408000_707000 METAL5_408000_717000 0.04
R_VDD2_7436 METAL5_408000_717000 METAL5_408000_757000 0.16
R_VDD2_7437 METAL5_408000_757000 METAL5_408000_769000 0.048
R_VDD2_7438 METAL5_408000_769000 METAL5_410000_769000 0.008
R_VDD2_7439 METAL5_410000_769000 METAL5_410000_781000 0.048
R_VDD2_7440 METAL5_410000_781000 METAL5_410000_793000 0.048
R_VDD2_7441 METAL5_410000_793000 METAL5_410000_805000 0.048
R_VDD2_7442 METAL5_410000_805000 METAL4_410000_805000 0.1
R_VDD2_7443 METAL4_410000_805000 METAL4_410000_817000 0.096
R_VDD2_7444 METAL4_410000_817000 METAL4_410000_829000 0.096
R_VDD2_7445 METAL4_410000_829000 METAL4_410000_841000 0.096
R_VDD2_7446 METAL4_410000_841000 METAL4_410000_853000 0.096
R_VDD2_7447 METAL4_410000_853000 METAL4_410000_857000 0.032
R_VDD2_7448 METAL4_410000_857000 METAL4_410000_865000 0.064
R_VDD2_7449 METAL4_410000_865000 METAL4_410000_869000 0.032
R_VDD2_7450 METAL4_410000_869000 METAL4_410000_877000 0.064
R_VDD2_7451 METAL4_410000_877000 METAL4_410000_881000 0.032
R_VDD2_7452 METAL4_410000_881000 METAL4_410000_889000 0.064
R_VDD2_7453 METAL4_410000_889000 METAL4_410000_893000 0.032
R_VDD2_7454 METAL4_410000_893000 METAL4_410000_901000 0.064
R_VDD2_7455 METAL4_410000_901000 METAL4_410000_905000 0.032
R_VDD2_7456 METAL4_410000_905000 METAL4_410000_913000 0.064
R_VDD2_7457 METAL4_410000_913000 METAL4_410000_917000 0.032
R_VDD2_7458 METAL4_410000_917000 METAL4_410000_929000 0.096
R_VDD2_7459 METAL4_410000_929000 METAL4_410000_941000 0.096
R_VDD2_7460 METAL4_410000_941000 METAL4_410000_953000 0.096
R_VDD2_7461 METAL4_410000_953000 METAL4_410000_965000 0.096
R_VDD2_7462 METAL4_410000_965000 METAL4_410000_977000 0.096
R_VDD2_7463 METAL4_410000_977000 METAL4_410000_989000 0.096
R_VDD2_7464 METAL4_410000_989000 METAL4_410000_1001000 0.096
R_VDD2_7465 METAL4_410000_1001000 METAL4_410000_1013000 0.096
R_VDD2_7466 METAL4_410000_1013000 METAL4_408000_1013000 0.016
R_VDD2_7467 METAL4_408000_1013000 METAL4_402000_1013000 0.048
R_VDD2_7468 METAL4_402000_1013000 METAL4_400000_1013000 0.016
R_VDD2_7469 METAL4_400000_1013000 METAL4_398000_1013000 0.016
R_VDD2_7470 METAL4_398000_1013000 METAL5_398000_1013000 0.1
R_VDD2_7471 METAL5_398000_1013000 METAL5_398000_1025000 0.048
R_VDD2_7472 METAL5_398000_1025000 METAL5_398000_1041000 0.064
R_VDD2_7473 METAL5_398000_1041000 METAL5_398000_1053000 0.048
R_VDD2_7474 METAL5_398000_1053000 METAL5_398000_1065000 0.048
R_VDD2_7475 METAL5_398000_1065000 METAL4_398000_1065000 0.1
R_VDD2_7476 METAL4_398000_1065000 METAL4_398000_1077000 0.096
R_VDD2_7477 METAL4_398000_1077000 METAL4_398000_1089000 0.096
R_VDD2_7478 METAL4_398000_1089000 METAL5_398000_1089000 0.1
R_VDD2_7479 METAL5_398000_1089000 METAL5_396000_1089000 0.008
R_VDD2_7480 METAL5_396000_1089000 METAL5_390000_1089000 0.024
R_VDD2_7481 METAL5_390000_1089000 METAL5_388000_1089000 0.008
R_VDD2_7482 METAL5_388000_1089000 METAL5_386000_1089000 0.008
R_VDD2_7483 METAL5_386000_1089000 METAL5_386000_1101000 0.048
R_VDD2_7484 METAL5_386000_1101000 METAL5_386000_1113000 0.048
R_VDD2_7485 METAL5_386000_1113000 METAL5_386000_1153000 0.16
R_VDD2_7486 METAL5_386000_1153000 METAL5_386000_1165000 0.048
R_VDD2_7487 METAL5_386000_1165000 METAL5_384000_1165000 0.008
R_VDD2_7488 METAL5_384000_1165000 METAL5_378000_1165000 0.024
R_VDD2_7489 METAL5_378000_1165000 METAL5_376000_1165000 0.008
R_VDD2_7490 METAL5_376000_1165000 METAL5_374000_1165000 0.008
R_VDD2_7491 METAL5_374000_1165000 METAL5_374000_1177000 0.048
R_VDD2_7492 METAL5_374000_1177000 METAL5_374000_1189000 0.048
R_VDD2_7493 METAL5_374000_1189000 METAL5_374000_1201000 0.048
R_VDD2_7494 METAL5_374000_1201000 METAL5_374000_1205000 0.016
R_VDD2_7495 METAL5_374000_1205000 METAL5_374000_1217000 0.048
R_VDD2_7496 METAL5_374000_1217000 METAL5_374000_1229000 0.048
R_VDD2_7497 METAL5_374000_1229000 METAL5_374000_1241000 0.048
R_VDD2_7498 METAL5_374000_1241000 METAL4_374000_1241000 0.1
R_VDD2_7499 METAL4_374000_1241000 METAL4_372000_1241000 0.016
R_VDD2_7500 METAL4_372000_1241000 METAL4_366000_1241000 0.048
R_VDD2_7501 METAL4_366000_1241000 METAL4_364000_1241000 0.016
R_VDD2_7502 METAL4_364000_1241000 METAL4_362000_1241000 0.016
R_VDD2_7503 METAL4_362000_1241000 METAL4_362000_1253000 0.096
R_VDD2_7504 METAL4_362000_1253000 METAL4_362000_1265000 0.096
R_VDD2_7505 METAL4_362000_1265000 METAL4_362000_1277000 0.096
R_VDD2_7506 METAL4_362000_1277000 METAL4_362000_1289000 0.096
R_VDD2_7507 METAL4_362000_1289000 METAL4_360000_1289000 0.016
R_VDD2_7508 METAL4_360000_1289000 METAL4_354000_1289000 0.048
R_VDD2_7509 METAL4_354000_1289000 METAL4_352000_1289000 0.016
R_VDD2_7510 METAL4_352000_1289000 METAL4_350000_1289000 0.016
R_VDD2_7511 METAL4_350000_1289000 METAL4_348000_1289000 0.016
R_VDD2_7512 METAL4_348000_1289000 METAL4_342000_1289000 0.048
R_VDD2_7513 METAL4_342000_1289000 METAL4_340000_1289000 0.016
R_VDD2_7514 METAL4_340000_1289000 METAL4_338000_1289000 0.016
R_VDD2_7515 METAL4_338000_1289000 METAL4_336000_1289000 0.016
R_VDD2_7516 METAL4_336000_1289000 METAL4_330000_1289000 0.048
R_VDD2_7517 METAL4_330000_1289000 METAL4_328000_1289000 0.016
R_VDD2_7518 METAL4_328000_1289000 METAL4_326000_1289000 0.016
R_VDD2_7519 METAL4_326000_1289000 METAL4_324000_1289000 0.016
R_VDD2_7520 METAL4_324000_1289000 METAL5_324000_1289000 0.1
R_VDD2_7521 METAL5_324000_1289000 METAL5_324000_1301000 0.048
R_VDD2_7522 METAL5_324000_1301000 METAL5_324000_1357000 0.224
R_VDD2_7523 METAL5_324000_1357000 METAL5_318000_1357000 0.024
R_VDD2_7524 METAL5_318000_1357000 METAL5_316000_1357000 0.008
R_VDD2_7525 METAL5_316000_1357000 METAL5_314000_1357000 0.008
R_VDD2_7526 METAL5_314000_1357000 METAL5_312000_1357000 0.008
R_VDD2_7527 METAL5_312000_1357000 METAL5_306000_1357000 0.024
R_VDD2_7528 METAL5_306000_1357000 METAL5_305000_1357000 0.004
R_VDD2_7529 METAL5_305000_1357000 METAL5_304000_1357000 0.004
R_VDD2_7530 METAL5_304000_1357000 METAL5_302000_1357000 0.008
R_VDD2_7531 METAL5_302000_1357000 METAL5_302000_1369000 0.048
R_VDD2_7532 METAL5_302000_1369000 METAL5_300000_1369000 0.008
R_VDD2_7533 METAL5_300000_1369000 METAL5_294000_1369000 0.024
R_VDD2_7534 METAL5_294000_1369000 METAL5_293000_1369000 0.004
R_VDD2_7535 METAL5_293000_1369000 METAL5_292000_1369000 0.004
R_VDD2_7536 METAL5_292000_1369000 METAL5_290000_1369000 0.008
R_VDD2_7537 METAL5_290000_1369000 METAL5_288000_1369000 0.008
R_VDD2_7538 METAL5_288000_1369000 METAL5_282000_1369000 0.024
R_VDD2_7539 METAL5_282000_1369000 METAL5_281000_1369000 0.004
R_VDD2_7540 METAL5_281000_1369000 METAL5_278000_1369000 0.012
R_VDD2_7541 METAL5_278000_1369000 METAL5_276000_1369000 0.008
R_VDD2_7542 METAL5_276000_1369000 METAL5_270000_1369000 0.024
R_VDD2_7543 METAL5_270000_1369000 METAL5_269000_1369000 0.004
R_VDD2_7544 METAL5_269000_1369000 METAL5_266000_1369000 0.012
R_VDD2_7545 METAL5_266000_1369000 METAL5_264000_1369000 0.008
R_VDD2_7546 METAL5_264000_1369000 METAL5_264000_1381000 0.048
R_VDD2_7547 METAL5_264000_1381000 METAL5_264000_1393000 0.048
R_VDD2_7548 METAL5_264000_1393000 METAL5_264000_1405000 0.048
R_VDD2_7549 METAL5_264000_1405000 METAL5_264000_1407000 0.008
R_VDD2_7550 METAL5_264000_1407000 METAL5_264000_1417000 0.04
R_VDD2_7551 METAL5_264000_1417000 METAL5_264000_1429000 0.048
R_VDD2_7552 METAL5_264000_1429000 METAL5_264000_1529000 0.4
R_VDD2_7553 METAL5_264000_1529000 METAL5_266000_1529000 0.008
R_VDD2_7554 METAL5_266000_1529000 METAL5_269000_1529000 0.012
R_VDD2_7555 METAL5_269000_1529000 METAL5_270000_1529000 0.004
R_VDD2_7556 METAL5_270000_1529000 METAL5_276000_1529000 0.024
R_VDD2_7557 METAL5_276000_1529000 METAL5_278000_1529000 0.008
R_VDD2_7558 METAL5_278000_1529000 METAL5_281000_1529000 0.012
R_VDD2_7559 METAL5_281000_1529000 METAL5_282000_1529000 0.004
R_VDD2_7560 METAL5_282000_1529000 METAL5_288000_1529000 0.024
R_VDD2_7561 METAL5_288000_1529000 METAL5_290000_1529000 0.008
R_VDD2_7562 METAL5_290000_1529000 METAL5_292000_1529000 0.008
R_VDD2_7563 METAL5_292000_1529000 METAL5_293000_1529000 0.004
R_VDD2_7564 METAL5_293000_1529000 METAL5_293000_1541000 0.048
R_VDD2_7565 METAL5_293000_1541000 METAL4_293000_1541000 0.1
R_VDD2_7566 METAL4_293000_1541000 METAL4_293000_1553000 0.096
R_VDD2_7567 METAL4_293000_1553000 METAL4_293000_1565000 0.096
R_VDD2_7568 METAL4_293000_1565000 METAL5_293000_1565000 0.1
R_VDD2_7569 METAL5_293000_1565000 METAL5_293000_1577000 0.048
R_VDD2_7570 METAL5_293000_1577000 METAL5_293000_1617000 0.16
R_VDD2_7571 METAL5_293000_1617000 METAL5_293000_1629000 0.048
R_VDD2_7572 METAL5_293000_1629000 METAL5_294000_1629000 0.004
R_VDD2_7573 METAL5_294000_1629000 METAL5_300000_1629000 0.024
R_VDD2_7574 METAL5_300000_1629000 METAL5_302000_1629000 0.008
R_VDD2_7575 METAL5_302000_1629000 METAL5_304000_1629000 0.008
R_VDD2_7576 METAL5_304000_1629000 METAL5_305000_1629000 0.004
R_VDD2_7577 METAL5_305000_1629000 METAL5_305000_1641000 0.048
R_VDD2_7578 METAL5_305000_1641000 METAL5_305000_1653000 0.048
R_VDD2_7579 METAL5_305000_1653000 METAL4_305000_1653000 0.1
R_VDD2_7580 METAL4_305000_1653000 METAL4_305000_1665000 0.096
R_VDD2_7581 METAL4_305000_1665000 METAL4_305000_1677000 0.096
R_VDD2_7582 METAL4_305000_1677000 METAL5_305000_1677000 0.1
R_VDD2_7583 METAL5_305000_1677000 METAL5_305000_1689000 0.048
R_VDD2_7584 METAL5_305000_1689000 METAL5_305000_1701000 0.048
R_VDD2_7585 METAL5_305000_1701000 METAL5_305000_1753000 0.208
R_VDD2_7586 METAL5_305000_1753000 METAL5_305000_1765000 0.048
R_VDD2_7587 METAL5_305000_1765000 METAL5_305000_1777000 0.048
R_VDD2_7588 METAL5_305000_1777000 METAL5_305000_1789000 0.048
R_VDD2_7589 METAL5_305000_1789000 METAL5_305000_1817000 0.112
R_VDD2_7590 METAL5_305000_1817000 METAL4_305000_1817000 0.1
R_VDD2_7591 METAL4_305000_1817000 METAL4_304000_1817000 0.008
R_VDD2_7592 METAL4_304000_1817000 METAL4_302000_1817000 0.016
R_VDD2_7593 METAL4_302000_1817000 METAL4_300000_1817000 0.016
R_VDD2_7594 METAL4_300000_1817000 METAL4_294000_1817000 0.048
R_VDD2_7595 METAL4_294000_1817000 METAL4_293000_1817000 0.008
R_VDD2_7596 METAL4_293000_1817000 METAL4_292000_1817000 0.008
R_VDD2_7597 METAL4_292000_1817000 METAL4_290000_1817000 0.016
R_VDD2_7598 METAL4_290000_1817000 METAL4_288000_1817000 0.016
R_VDD2_7599 METAL4_288000_1817000 METAL4_282000_1817000 0.048
R_VDD2_7600 METAL4_282000_1817000 METAL4_281000_1817000 0.008
R_VDD2_7601 METAL4_281000_1817000 METAL5_281000_1817000 0.1
R_VDD2_7602 METAL5_281000_1817000 METAL5_281000_1829000 0.048
R_VDD2_7603 METAL5_281000_1829000 METAL5_278000_1829000 0.012
R_VDD2_7604 METAL5_278000_1829000 METAL5_276000_1829000 0.008
R_VDD2_7605 METAL5_276000_1829000 METAL5_276000_1841000 0.048
R_VDD2_7606 METAL5_276000_1841000 METAL5_276000_1853000 0.048
R_VDD2_7607 METAL5_276000_1853000 METAL5_276000_1865000 0.048
R_VDD2_7608 METAL5_276000_1865000 METAL5_276000_1877000 0.048
R_VDD2_7609 METAL5_276000_1877000 METAL5_276000_1905000 0.112
R_VDD2_7610 METAL5_276000_1905000 METAL5_276000_1917000 0.048
R_VDD2_7611 METAL5_276000_1917000 METAL5_276000_1929000 0.048
R_VDD2_7612 METAL5_276000_1929000 METAL5_276000_1941000 0.048
R_VDD2_7613 METAL5_276000_1941000 METAL4_276000_1941000 0.1
R_VDD2_7614 METAL4_276000_1941000 METAL4_276000_1953000 0.096
R_VDD2_7615 METAL4_276000_1953000 METAL4_276000_1965000 0.096
R_VDD2_7616 METAL4_276000_1965000 METAL4_276000_1977000 0.096
R_VDD2_7617 METAL4_276000_1977000 METAL4_276000_1989000 0.096
R_VDD2_7618 METAL4_276000_1989000 METAL5_276000_1989000 0.1
R_VDD2_7619 METAL5_276000_1989000 METAL5_276000_2001000 0.048
R_VDD2_7620 METAL5_276000_2001000 METAL5_276000_2013000 0.048
R_VDD2_7621 METAL5_276000_2013000 METAL5_276000_2093000 0.32
R_VDD2_7622 METAL5_276000_2093000 METAL5_276000_2107000 0.056
R_VDD2_7623 METAL5_276000_2107000 METAL5_276000_2217000 0.44
R_VDD2_7624 METAL5_276000_2217000 METAL5_276000_2229000 0.048
R_VDD2_7625 METAL5_276000_2229000 METAL5_276000_2241000 0.048
R_VDD2_7626 METAL5_276000_2241000 METAL5_270000_2241000 0.024
R_VDD2_7627 METAL5_270000_2241000 METAL5_269000_2241000 0.004
R_VDD2_7628 METAL5_269000_2241000 METAL4_269000_2241000 0.1
R_VDD2_7629 METAL4_269000_2241000 METAL4_269000_2253000 0.096
R_VDD2_7630 METAL4_269000_2253000 METAL4_269000_2265000 0.096
R_VDD2_7631 METAL4_269000_2265000 METAL4_269000_2277000 0.096
R_VDD2_7632 METAL4_269000_2277000 METAL4_266000_2277000 0.024
R_VDD2_7633 METAL4_266000_2277000 METAL4_264000_2277000 0.016
R_VDD2_7634 METAL4_264000_2277000 METAL4_258000_2277000 0.048
R_VDD2_7635 METAL4_258000_2277000 METAL4_257000_2277000 0.008
R_VDD2_7636 METAL4_257000_2277000 METAL5_257000_2277000 0.1
R_VDD2_7637 METAL5_257000_2277000 METAL6_257000_2277000 0.1
R_VDD2_7638 METAL6_257000_2277000 METAL6_257000_2289000 0.024
R_VDD2_7639 METAL6_257000_2289000 METAL6_257000_2341000 0.104
R_VDD2_7640 METAL6_257000_2341000 METAL6_257000_2353000 0.024
R_VDD2_7641 METAL6_257000_2353000 METAL6_257000_2365000 0.024
R_VDD2_7642 METAL6_555000_1665000 METAL6_543000_1665000 0.024
R_VDD2_7643 METAL4_350000_8000 METAL3_350000_8000 0.1
R_VDD2_7644 METAL3_350000_8000 METAL3_350000_20000 0.096
R_VDD2_7645 METAL3_350000_20000 METAL3_350000_32000 0.096
R_VDD2_7646 METAL3_350000_32000 METAL3_352000_32000 0.016
R_VDD2_7647 METAL3_352000_32000 METAL3_354000_32000 0.016
R_VDD2_7648 METAL3_354000_32000 METAL3_360000_32000 0.048
R_VDD2_7649 METAL3_360000_32000 METAL3_362000_32000 0.016
R_VDD2_7650 METAL3_362000_32000 METAL3_364000_32000 0.016
R_VDD2_7651 METAL3_364000_32000 METAL3_366000_32000 0.016
R_VDD2_7652 METAL3_366000_32000 METAL3_372000_32000 0.048
R_VDD2_7653 METAL3_372000_32000 METAL3_374000_32000 0.016
R_VDD2_7654 METAL3_374000_32000 METAL3_376000_32000 0.016
R_VDD2_7655 METAL3_376000_32000 METAL3_378000_32000 0.016
R_VDD2_7656 METAL3_378000_32000 METAL3_384000_32000 0.048
R_VDD2_7657 METAL3_384000_32000 METAL3_386000_32000 0.016
R_VDD2_7658 METAL3_386000_32000 METAL3_388000_32000 0.016
R_VDD2_7659 METAL3_388000_32000 METAL3_390000_32000 0.016
R_VDD2_7660 METAL3_390000_32000 METAL3_396000_32000 0.048
R_VDD2_7661 METAL3_396000_32000 METAL3_398000_32000 0.016
R_VDD2_7662 METAL3_398000_32000 METAL3_400000_32000 0.016
R_VDD2_7663 METAL3_400000_32000 METAL3_402000_32000 0.016
R_VDD2_7664 METAL3_402000_32000 METAL3_408000_32000 0.048
R_VDD2_7665 METAL3_408000_32000 METAL3_410000_32000 0.016
R_VDD2_7666 METAL3_410000_32000 METAL3_412000_32000 0.016
R_VDD2_7667 METAL3_412000_32000 METAL3_414000_32000 0.016
R_VDD2_7668 METAL3_414000_32000 METAL3_416000_32000 0.016
R_VDD2_7669 METAL3_416000_32000 METAL3_420000_32000 0.032
R_VDD2_7670 METAL3_420000_32000 METAL3_422000_32000 0.016
R_VDD2_7671 METAL3_422000_32000 METAL3_424000_32000 0.016
R_VDD2_7672 METAL3_424000_32000 METAL4_424000_32000 0.1
R_VDD2_7673 METAL4_424000_32000 METAL5_424000_32000 0.1
R_VDD2_7674 METAL5_424000_32000 METAL5_424000_44000 0.048
R_VDD2_7675 METAL5_424000_44000 METAL5_426000_44000 0.008
R_VDD2_7676 METAL5_426000_44000 METAL5_428000_44000 0.008
R_VDD2_7677 METAL5_428000_44000 METAL5_432000_44000 0.016
R_VDD2_7678 METAL5_432000_44000 METAL5_434000_44000 0.008
R_VDD2_7679 METAL5_434000_44000 METAL5_436000_44000 0.008
R_VDD2_7680 METAL5_436000_44000 METAL5_438000_44000 0.008
R_VDD2_7681 METAL5_438000_44000 METAL5_440000_44000 0.008
R_VDD2_7682 METAL5_440000_44000 METAL5_444000_44000 0.016
R_VDD2_7683 METAL5_444000_44000 METAL5_446000_44000 0.008
R_VDD2_7684 METAL5_446000_44000 METAL5_448000_44000 0.008
R_VDD2_7685 METAL5_448000_44000 METAL5_450000_44000 0.008
R_VDD2_7686 METAL5_450000_44000 METAL5_452000_44000 0.008
R_VDD2_7687 METAL5_452000_44000 METAL5_458000_44000 0.024
R_VDD2_7688 METAL5_458000_44000 METAL5_460000_44000 0.008
R_VDD2_7689 METAL5_460000_44000 METAL5_462000_44000 0.008
R_VDD2_7690 METAL5_462000_44000 METAL5_464000_44000 0.008
R_VDD2_7691 METAL5_464000_44000 METAL5_470000_44000 0.024
R_VDD2_7692 METAL5_470000_44000 METAL5_472000_44000 0.008
R_VDD2_7693 METAL5_472000_44000 METAL5_474000_44000 0.008
R_VDD2_7694 METAL5_474000_44000 METAL5_476000_44000 0.008
R_VDD2_7695 METAL5_476000_44000 METAL5_482000_44000 0.024
R_VDD2_7696 METAL5_482000_44000 METAL5_482000_45000 0.004
R_VDD2_7697 METAL5_482000_45000 METAL5_482000_56000 0.044
R_VDD2_7698 METAL5_482000_56000 METAL5_482000_57000 0.004
R_VDD2_7699 METAL5_482000_57000 METAL5_482000_68000 0.044
R_VDD2_7700 METAL5_482000_68000 METAL5_482000_69000 0.004
R_VDD2_7701 METAL5_482000_69000 METAL5_482000_80000 0.044
R_VDD2_7702 METAL5_482000_80000 METAL5_482000_81000 0.004
R_VDD2_7703 METAL5_482000_81000 METAL5_482000_92000 0.044
R_VDD2_7704 METAL5_482000_92000 METAL5_482000_93000 0.004
R_VDD2_7705 METAL5_482000_93000 METAL5_482000_105000 0.048
R_VDD2_7706 METAL5_482000_105000 METAL5_482000_109000 0.016
R_VDD2_7707 METAL5_482000_109000 METAL5_482000_117000 0.032
R_VDD2_7708 METAL5_482000_117000 METAL5_482000_121000 0.016
R_VDD2_7709 METAL5_482000_121000 METAL5_482000_129000 0.032
R_VDD2_7710 METAL5_482000_129000 METAL5_483000_129000 0.004
R_VDD2_7711 METAL5_483000_129000 METAL5_484000_129000 0.004
R_VDD2_7712 METAL5_484000_129000 METAL5_486000_129000 0.008
R_VDD2_7713 METAL5_486000_129000 METAL5_488000_129000 0.008
R_VDD2_7714 METAL5_488000_129000 METAL4_488000_129000 0.1
R_VDD2_7715 METAL4_488000_129000 METAL4_495000_129000 0.056
R_VDD2_7716 METAL4_495000_129000 METAL4_496000_129000 0.008
R_VDD2_7717 METAL4_496000_129000 METAL4_498000_129000 0.016
R_VDD2_7718 METAL4_498000_129000 METAL4_500000_129000 0.016
R_VDD2_7719 METAL4_500000_129000 METAL4_507000_129000 0.056
R_VDD2_7720 METAL4_507000_129000 METAL4_508000_129000 0.008
R_VDD2_7721 METAL4_508000_129000 METAL4_510000_129000 0.016
R_VDD2_7722 METAL4_510000_129000 METAL4_512000_129000 0.016
R_VDD2_7723 METAL4_512000_129000 METAL5_512000_129000 0.1
R_VDD2_7724 METAL5_512000_129000 METAL5_512000_133000 0.016
R_VDD2_7725 METAL5_512000_133000 METAL5_512000_141000 0.032
R_VDD2_7726 METAL5_512000_141000 METAL5_512000_145000 0.016
R_VDD2_7727 METAL5_512000_145000 METAL5_512000_153000 0.032
R_VDD2_7728 METAL5_512000_153000 METAL5_512000_157000 0.016
R_VDD2_7729 METAL5_512000_157000 METAL5_512000_165000 0.032
R_VDD2_7730 METAL5_512000_165000 METAL5_512000_169000 0.016
R_VDD2_7731 METAL5_512000_169000 METAL5_512000_177000 0.032
R_VDD2_7732 METAL5_512000_177000 METAL5_512000_181000 0.016
R_VDD2_7733 METAL5_512000_181000 METAL5_512000_193000 0.048
R_VDD2_7734 METAL5_512000_193000 METAL5_512000_205000 0.048
R_VDD2_7735 METAL5_512000_205000 METAL5_512000_217000 0.048
R_VDD2_7736 METAL5_512000_217000 METAL5_512000_229000 0.048
R_VDD2_7737 METAL5_512000_229000 METAL5_510000_229000 0.008
R_VDD2_7738 METAL5_510000_229000 METAL5_508000_229000 0.008
R_VDD2_7739 METAL5_508000_229000 METAL5_507000_229000 0.004
R_VDD2_7740 METAL5_507000_229000 METAL4_507000_229000 0.1
R_VDD2_7741 METAL4_507000_229000 METAL4_507000_233000 0.032
R_VDD2_7742 METAL4_507000_233000 METAL4_507000_241000 0.064
R_VDD2_7743 METAL4_507000_241000 METAL4_507000_245000 0.032
R_VDD2_7744 METAL4_507000_245000 METAL4_507000_253000 0.064
R_VDD2_7745 METAL4_507000_253000 METAL4_507000_257000 0.032
R_VDD2_7746 METAL4_507000_257000 METAL4_507000_265000 0.064
R_VDD2_7747 METAL4_507000_265000 METAL4_507000_269000 0.032
R_VDD2_7748 METAL4_507000_269000 METAL4_507000_277000 0.064
R_VDD2_7749 METAL4_507000_277000 METAL4_507000_281000 0.032
R_VDD2_7750 METAL4_507000_281000 METAL4_507000_289000 0.064
R_VDD2_7751 METAL4_507000_289000 METAL4_507000_293000 0.032
R_VDD2_7752 METAL4_507000_293000 METAL4_507000_301000 0.064
R_VDD2_7753 METAL4_507000_301000 METAL4_507000_305000 0.032
R_VDD2_7754 METAL4_507000_305000 METAL4_507000_313000 0.064
R_VDD2_7755 METAL4_507000_313000 METAL4_507000_317000 0.032
R_VDD2_7756 METAL4_507000_317000 METAL4_507000_329000 0.096
R_VDD2_7757 METAL4_507000_329000 METAL4_507000_341000 0.096
R_VDD2_7758 METAL4_507000_341000 METAL5_507000_341000 0.1
R_VDD2_7759 METAL5_507000_341000 METAL5_507000_353000 0.048
R_VDD2_7760 METAL5_507000_353000 METAL5_507000_365000 0.048
R_VDD2_7761 METAL5_507000_365000 METAL5_507000_377000 0.048
R_VDD2_7762 METAL5_507000_377000 METAL5_507000_389000 0.048
R_VDD2_7763 METAL5_507000_389000 METAL5_507000_393000 0.016
R_VDD2_7764 METAL5_507000_393000 METAL5_508000_393000 0.004
R_VDD2_7765 METAL5_508000_393000 METAL5_510000_393000 0.008
R_VDD2_7766 METAL5_510000_393000 METAL5_510000_401000 0.032
R_VDD2_7767 METAL5_510000_401000 METAL5_510000_405000 0.016
R_VDD2_7768 METAL5_510000_405000 METAL5_510000_417000 0.048
R_VDD2_7769 METAL5_510000_417000 METAL5_510000_429000 0.048
R_VDD2_7770 METAL5_510000_429000 METAL5_510000_441000 0.048
R_VDD2_7771 METAL5_510000_441000 METAL5_510000_453000 0.048
R_VDD2_7772 METAL5_510000_453000 METAL5_510000_465000 0.048
R_VDD2_7773 METAL5_510000_465000 METAL5_510000_469000 0.016
R_VDD2_7774 METAL5_510000_469000 METAL5_510000_477000 0.032
R_VDD2_7775 METAL5_510000_477000 METAL5_510000_481000 0.016
R_VDD2_7776 METAL5_510000_481000 METAL5_510000_489000 0.032
R_VDD2_7777 METAL5_510000_489000 METAL5_510000_493000 0.016
R_VDD2_7778 METAL5_510000_493000 METAL5_510000_501000 0.032
R_VDD2_7779 METAL5_510000_501000 METAL5_510000_505000 0.016
R_VDD2_7780 METAL5_510000_505000 METAL5_510000_517000 0.048
R_VDD2_7781 METAL5_510000_517000 METAL4_510000_517000 0.1
R_VDD2_7782 METAL4_510000_517000 METAL4_508000_517000 0.016
R_VDD2_7783 METAL4_508000_517000 METAL4_507000_517000 0.008
R_VDD2_7784 METAL4_507000_517000 METAL4_500000_517000 0.056
R_VDD2_7785 METAL4_500000_517000 METAL4_498000_517000 0.016
R_VDD2_7786 METAL4_498000_517000 METAL4_496000_517000 0.016
R_VDD2_7787 METAL4_496000_517000 METAL4_495000_517000 0.008
R_VDD2_7788 METAL4_495000_517000 METAL4_488000_517000 0.056
R_VDD2_7789 METAL4_488000_517000 METAL4_486000_517000 0.016
R_VDD2_7790 METAL4_486000_517000 METAL4_484000_517000 0.016
R_VDD2_7791 METAL4_484000_517000 METAL4_483000_517000 0.008
R_VDD2_7792 METAL4_483000_517000 METAL4_482000_517000 0.008
R_VDD2_7793 METAL4_482000_517000 METAL4_476000_517000 0.048
R_VDD2_7794 METAL4_476000_517000 METAL4_474000_517000 0.016
R_VDD2_7795 METAL4_474000_517000 METAL4_472000_517000 0.016
R_VDD2_7796 METAL4_472000_517000 METAL4_470000_517000 0.016
R_VDD2_7797 METAL4_470000_517000 METAL4_464000_517000 0.048
R_VDD2_7798 METAL4_464000_517000 METAL4_462000_517000 0.016
R_VDD2_7799 METAL4_462000_517000 METAL4_462000_529000 0.096
R_VDD2_7800 METAL4_462000_529000 METAL4_462000_541000 0.096
R_VDD2_7801 METAL4_462000_541000 METAL4_462000_553000 0.096
R_VDD2_7802 METAL4_462000_553000 METAL4_462000_565000 0.096
R_VDD2_7803 METAL4_462000_565000 METAL4_462000_577000 0.096
R_VDD2_7804 METAL4_462000_577000 METAL4_462000_589000 0.096
R_VDD2_7805 METAL4_462000_589000 METAL4_462000_601000 0.096
R_VDD2_7806 METAL4_462000_601000 METAL4_462000_613000 0.096
R_VDD2_7807 METAL4_462000_613000 METAL5_462000_613000 0.1
R_VDD2_7808 METAL5_462000_613000 METAL5_462000_625000 0.048
R_VDD2_7809 METAL5_462000_625000 METAL5_462000_681000 0.224
R_VDD2_7810 METAL5_462000_681000 METAL5_462000_693000 0.048
R_VDD2_7811 METAL5_462000_693000 METAL5_462000_705000 0.048
R_VDD2_7812 METAL5_462000_705000 METAL5_462000_707000 0.008
R_VDD2_7813 METAL5_462000_707000 METAL5_462000_717000 0.04
R_VDD2_7814 METAL5_462000_717000 METAL5_462000_757000 0.16
R_VDD2_7815 METAL5_462000_757000 METAL5_462000_769000 0.048
R_VDD2_7816 METAL5_462000_769000 METAL5_462000_781000 0.048
R_VDD2_7817 METAL5_462000_781000 METAL4_462000_781000 0.1
R_VDD2_7818 METAL4_462000_781000 METAL4_462000_793000 0.096
R_VDD2_7819 METAL4_462000_793000 METAL4_462000_805000 0.096
R_VDD2_7820 METAL4_462000_805000 METAL4_462000_817000 0.096
R_VDD2_7821 METAL4_462000_817000 METAL4_462000_829000 0.096
R_VDD2_7822 METAL4_462000_829000 METAL4_462000_841000 0.096
R_VDD2_7823 METAL4_462000_841000 METAL4_460000_841000 0.016
R_VDD2_7824 METAL4_460000_841000 METAL4_460000_853000 0.096
R_VDD2_7825 METAL4_460000_853000 METAL4_460000_857000 0.032
R_VDD2_7826 METAL4_460000_857000 METAL4_460000_865000 0.064
R_VDD2_7827 METAL4_460000_865000 METAL4_460000_869000 0.032
R_VDD2_7828 METAL4_460000_869000 METAL4_460000_877000 0.064
R_VDD2_7829 METAL4_460000_877000 METAL4_460000_881000 0.032
R_VDD2_7830 METAL4_460000_881000 METAL4_460000_889000 0.064
R_VDD2_7831 METAL4_460000_889000 METAL5_460000_889000 0.1
R_VDD2_7832 METAL5_460000_889000 METAL5_460000_893000 0.016
R_VDD2_7833 METAL5_460000_893000 METAL5_460000_901000 0.032
R_VDD2_7834 METAL5_460000_901000 METAL5_460000_905000 0.016
R_VDD2_7835 METAL5_460000_905000 METAL5_460000_913000 0.032
R_VDD2_7836 METAL5_460000_913000 METAL5_460000_917000 0.016
R_VDD2_7837 METAL5_460000_917000 METAL5_460000_929000 0.048
R_VDD2_7838 METAL5_460000_929000 METAL5_460000_941000 0.048
R_VDD2_7839 METAL5_460000_941000 METAL5_460000_953000 0.048
R_VDD2_7840 METAL5_460000_953000 METAL5_460000_965000 0.048
R_VDD2_7841 METAL5_460000_965000 METAL5_460000_977000 0.048
R_VDD2_7842 METAL5_460000_977000 METAL5_460000_989000 0.048
R_VDD2_7843 METAL5_460000_989000 METAL5_460000_1001000 0.048
R_VDD2_7844 METAL5_460000_1001000 METAL5_460000_1013000 0.048
R_VDD2_7845 METAL5_460000_1013000 METAL5_460000_1025000 0.048
R_VDD2_7846 METAL5_460000_1025000 METAL5_460000_1041000 0.064
R_VDD2_7847 METAL5_460000_1041000 METAL5_460000_1053000 0.048
R_VDD2_7848 METAL5_460000_1053000 METAL4_460000_1053000 0.1
R_VDD2_7849 METAL4_460000_1053000 METAL4_462000_1053000 0.016
R_VDD2_7850 METAL4_462000_1053000 METAL4_464000_1053000 0.016
R_VDD2_7851 METAL4_464000_1053000 METAL4_470000_1053000 0.048
R_VDD2_7852 METAL4_470000_1053000 METAL4_470000_1065000 0.096
R_VDD2_7853 METAL4_470000_1065000 METAL4_470000_1077000 0.096
R_VDD2_7854 METAL4_470000_1077000 METAL4_470000_1089000 0.096
R_VDD2_7855 METAL4_470000_1089000 METAL5_470000_1089000 0.1
R_VDD2_7856 METAL5_470000_1089000 METAL5_470000_1101000 0.048
R_VDD2_7857 METAL5_470000_1101000 METAL5_470000_1113000 0.048
R_VDD2_7858 METAL5_470000_1113000 METAL5_470000_1153000 0.16
R_VDD2_7859 METAL5_470000_1153000 METAL5_470000_1165000 0.048
R_VDD2_7860 METAL5_470000_1165000 METAL5_472000_1165000 0.008
R_VDD2_7861 METAL5_472000_1165000 METAL4_472000_1165000 0.1
R_VDD2_7862 METAL4_472000_1165000 METAL4_472000_1177000 0.096
R_VDD2_7863 METAL4_472000_1177000 METAL4_472000_1189000 0.096
R_VDD2_7864 METAL4_472000_1189000 METAL4_472000_1201000 0.096
R_VDD2_7865 METAL4_472000_1201000 METAL4_472000_1205000 0.032
R_VDD2_7866 METAL4_472000_1205000 METAL4_472000_1217000 0.096
R_VDD2_7867 METAL4_472000_1217000 METAL4_472000_1229000 0.096
R_VDD2_7868 METAL4_472000_1229000 METAL4_472000_1241000 0.096
R_VDD2_7869 METAL4_472000_1241000 METAL4_472000_1253000 0.096
R_VDD2_7870 METAL4_472000_1253000 METAL4_472000_1265000 0.096
R_VDD2_7871 METAL4_472000_1265000 METAL4_472000_1277000 0.096
R_VDD2_7872 METAL4_472000_1277000 METAL4_474000_1277000 0.016
R_VDD2_7873 METAL4_474000_1277000 METAL4_476000_1277000 0.016
R_VDD2_7874 METAL4_476000_1277000 METAL4_482000_1277000 0.048
R_VDD2_7875 METAL4_482000_1277000 METAL4_483000_1277000 0.008
R_VDD2_7876 METAL4_483000_1277000 METAL4_484000_1277000 0.008
R_VDD2_7877 METAL4_484000_1277000 METAL4_486000_1277000 0.016
R_VDD2_7878 METAL4_486000_1277000 METAL4_488000_1277000 0.016
R_VDD2_7879 METAL4_488000_1277000 METAL4_495000_1277000 0.056
R_VDD2_7880 METAL4_495000_1277000 METAL4_496000_1277000 0.008
R_VDD2_7881 METAL4_496000_1277000 METAL4_498000_1277000 0.016
R_VDD2_7882 METAL4_498000_1277000 METAL4_500000_1277000 0.016
R_VDD2_7883 METAL4_500000_1277000 METAL4_507000_1277000 0.056
R_VDD2_7884 METAL4_507000_1277000 METAL4_508000_1277000 0.008
R_VDD2_7885 METAL4_508000_1277000 METAL4_510000_1277000 0.016
R_VDD2_7886 METAL4_510000_1277000 METAL4_512000_1277000 0.016
R_VDD2_7887 METAL4_512000_1277000 METAL4_519000_1277000 0.056
R_VDD2_7888 METAL4_519000_1277000 METAL4_524000_1277000 0.04
R_VDD2_7889 METAL4_524000_1277000 METAL4_531000_1277000 0.056
R_VDD2_7890 METAL4_531000_1277000 METAL4_536000_1277000 0.04
R_VDD2_7891 METAL4_536000_1277000 METAL4_543000_1277000 0.056
R_VDD2_7892 METAL4_543000_1277000 METAL5_543000_1277000 0.1
R_VDD2_7893 METAL5_543000_1277000 METAL5_543000_1289000 0.048
R_VDD2_7894 METAL5_543000_1289000 METAL5_543000_1301000 0.048
R_VDD2_7895 METAL5_543000_1301000 METAL5_543000_1345000 0.176
R_VDD2_7896 METAL5_543000_1345000 METAL5_543000_1357000 0.048
R_VDD2_7897 METAL5_543000_1357000 METAL5_543000_1369000 0.048
R_VDD2_7898 METAL5_543000_1369000 METAL4_543000_1369000 0.1
R_VDD2_7899 METAL4_543000_1369000 METAL4_543000_1381000 0.096
R_VDD2_7900 METAL4_543000_1381000 METAL4_543000_1393000 0.096
R_VDD2_7901 METAL4_543000_1393000 METAL5_543000_1393000 0.1
R_VDD2_7902 METAL5_543000_1393000 METAL5_543000_1405000 0.048
R_VDD2_7903 METAL5_543000_1405000 METAL5_543000_1407000 0.008
R_VDD2_7904 METAL5_543000_1407000 METAL5_543000_1417000 0.04
R_VDD2_7905 METAL5_543000_1417000 METAL5_543000_1429000 0.048
R_VDD2_7906 METAL5_543000_1429000 METAL5_543000_1517000 0.352
R_VDD2_7907 METAL5_543000_1517000 METAL5_543000_1529000 0.048
R_VDD2_7908 METAL5_543000_1529000 METAL5_543000_1541000 0.048
R_VDD2_7909 METAL5_543000_1541000 METAL4_543000_1541000 0.1
R_VDD2_7910 METAL4_543000_1541000 METAL3_543000_1541000 0.1
R_VDD2_7911 METAL3_543000_1541000 METAL3_543000_1553000 0.096
R_VDD2_7912 METAL3_543000_1553000 METAL3_536000_1553000 0.056
R_VDD2_7913 METAL3_536000_1553000 METAL3_531000_1553000 0.04
R_VDD2_7914 METAL3_531000_1553000 METAL3_531000_1565000 0.096
R_VDD2_7915 METAL3_531000_1565000 METAL3_531000_1577000 0.096
R_VDD2_7916 METAL3_531000_1577000 METAL3_536000_1577000 0.04
R_VDD2_7917 METAL3_536000_1577000 METAL3_543000_1577000 0.056
R_VDD2_7918 METAL3_543000_1577000 METAL4_543000_1577000 0.1
R_VDD2_7919 METAL4_543000_1577000 METAL5_543000_1577000 0.1
R_VDD2_7920 METAL5_543000_1577000 METAL6_543000_1577000 0.1
R_VDD2_7921 METAL6_543000_1577000 METAL6_543000_1617000 0.08
R_VDD2_7922 METAL6_543000_1617000 METAL6_543000_1629000 0.024
R_VDD2_7923 METAL6_543000_1629000 METAL6_543000_1641000 0.024
R_VDD2_7924 METAL6_543000_1641000 METAL6_543000_1653000 0.024
R_VDD2_7925 METAL6_543000_1653000 METAL6_543000_1665000 0.024
R_VDD2_7926 METAL6_245000_1665000 METAL6_257000_1665000 0.024
R_VDD2_7927 METAL5_354000_205000 METAL4_354000_205000 0.1
R_VDD2_7928 METAL4_354000_205000 METAL4_354000_217000 0.096
R_VDD2_7929 METAL4_354000_217000 METAL4_360000_217000 0.048
R_VDD2_7930 METAL4_360000_217000 METAL4_362000_217000 0.016
R_VDD2_7931 METAL4_362000_217000 METAL4_364000_217000 0.016
R_VDD2_7932 METAL4_364000_217000 METAL4_366000_217000 0.016
R_VDD2_7933 METAL4_366000_217000 METAL4_372000_217000 0.048
R_VDD2_7934 METAL4_372000_217000 METAL4_374000_217000 0.016
R_VDD2_7935 METAL4_374000_217000 METAL4_376000_217000 0.016
R_VDD2_7936 METAL4_376000_217000 METAL4_378000_217000 0.016
R_VDD2_7937 METAL4_378000_217000 METAL4_384000_217000 0.048
R_VDD2_7938 METAL4_384000_217000 METAL4_386000_217000 0.016
R_VDD2_7939 METAL4_386000_217000 METAL4_388000_217000 0.016
R_VDD2_7940 METAL4_388000_217000 METAL4_390000_217000 0.016
R_VDD2_7941 METAL4_390000_217000 METAL4_396000_217000 0.048
R_VDD2_7942 METAL4_396000_217000 METAL4_398000_217000 0.016
R_VDD2_7943 METAL4_398000_217000 METAL4_400000_217000 0.016
R_VDD2_7944 METAL4_400000_217000 METAL4_402000_217000 0.016
R_VDD2_7945 METAL4_402000_217000 METAL4_408000_217000 0.048
R_VDD2_7946 METAL4_408000_217000 METAL4_410000_217000 0.016
R_VDD2_7947 METAL4_410000_217000 METAL4_412000_217000 0.016
R_VDD2_7948 METAL4_412000_217000 METAL4_414000_217000 0.016
R_VDD2_7949 METAL4_414000_217000 METAL4_416000_217000 0.016
R_VDD2_7950 METAL4_416000_217000 METAL4_420000_217000 0.032
R_VDD2_7951 METAL4_420000_217000 METAL4_422000_217000 0.016
R_VDD2_7952 METAL4_422000_217000 METAL4_424000_217000 0.016
R_VDD2_7953 METAL4_424000_217000 METAL4_426000_217000 0.016
R_VDD2_7954 METAL4_426000_217000 METAL4_428000_217000 0.016
R_VDD2_7955 METAL4_428000_217000 METAL4_432000_217000 0.032
R_VDD2_7956 METAL4_432000_217000 METAL4_434000_217000 0.016
R_VDD2_7957 METAL4_434000_217000 METAL4_436000_217000 0.016
R_VDD2_7958 METAL4_436000_217000 METAL4_438000_217000 0.016
R_VDD2_7959 METAL4_438000_217000 METAL4_440000_217000 0.016
R_VDD2_7960 METAL4_440000_217000 METAL4_444000_217000 0.032
R_VDD2_7961 METAL4_444000_217000 METAL4_446000_217000 0.016
R_VDD2_7962 METAL4_446000_217000 METAL4_448000_217000 0.016
R_VDD2_7963 METAL4_448000_217000 METAL4_450000_217000 0.016
R_VDD2_7964 METAL4_450000_217000 METAL4_452000_217000 0.016
R_VDD2_7965 METAL4_452000_217000 METAL4_458000_217000 0.048
R_VDD2_7966 METAL4_458000_217000 METAL4_460000_217000 0.016
R_VDD2_7967 METAL4_460000_217000 METAL4_462000_217000 0.016
R_VDD2_7968 METAL4_462000_217000 METAL4_464000_217000 0.016
R_VDD2_7969 METAL4_464000_217000 METAL4_470000_217000 0.048
R_VDD2_7970 METAL4_470000_217000 METAL4_472000_217000 0.016
R_VDD2_7971 METAL4_472000_217000 METAL4_472000_229000 0.096
R_VDD2_7972 METAL4_472000_229000 METAL4_472000_233000 0.032
R_VDD2_7973 METAL4_472000_233000 METAL4_472000_241000 0.064
R_VDD2_7974 METAL4_472000_241000 METAL4_472000_245000 0.032
R_VDD2_7975 METAL4_472000_245000 METAL4_472000_253000 0.064
R_VDD2_7976 METAL4_472000_253000 METAL4_472000_257000 0.032
R_VDD2_7977 METAL4_472000_257000 METAL4_472000_265000 0.064
R_VDD2_7978 METAL4_472000_265000 METAL4_472000_269000 0.032
R_VDD2_7979 METAL4_472000_269000 METAL4_472000_277000 0.064
R_VDD2_7980 METAL4_472000_277000 METAL4_472000_281000 0.032
R_VDD2_7981 METAL4_472000_281000 METAL4_472000_289000 0.064
R_VDD2_7982 METAL4_472000_289000 METAL4_472000_293000 0.032
R_VDD2_7983 METAL4_472000_293000 METAL4_472000_301000 0.064
R_VDD2_7984 METAL4_472000_301000 METAL4_472000_305000 0.032
R_VDD2_7985 METAL4_472000_305000 METAL4_472000_313000 0.064
R_VDD2_7986 METAL4_472000_313000 METAL4_472000_317000 0.032
R_VDD2_7987 METAL4_472000_317000 METAL4_474000_317000 0.016
R_VDD2_7988 METAL4_474000_317000 METAL4_474000_329000 0.096
R_VDD2_7989 METAL4_474000_329000 METAL4_474000_341000 0.096
R_VDD2_7990 METAL4_474000_341000 METAL5_474000_341000 0.1
R_VDD2_7991 METAL5_474000_341000 METAL5_474000_353000 0.048
R_VDD2_7992 METAL5_474000_353000 METAL5_474000_365000 0.048
R_VDD2_7993 METAL5_474000_365000 METAL5_474000_377000 0.048
R_VDD2_7994 METAL5_474000_377000 METAL5_474000_381000 0.016
R_VDD2_7995 METAL5_474000_381000 METAL5_474000_389000 0.032
R_VDD2_7996 METAL5_474000_389000 METAL5_474000_393000 0.016
R_VDD2_7997 METAL5_474000_393000 METAL4_474000_393000 0.1
R_VDD2_7998 METAL4_474000_393000 METAL4_474000_401000 0.064
R_VDD2_7999 METAL4_474000_401000 METAL4_474000_405000 0.032
R_VDD2_8000 METAL4_474000_405000 METAL4_474000_417000 0.096
R_VDD2_8001 METAL4_474000_417000 METAL4_474000_429000 0.096
R_VDD2_8002 METAL4_474000_429000 METAL4_474000_441000 0.096
R_VDD2_8003 METAL4_474000_441000 METAL4_474000_453000 0.096
R_VDD2_8004 METAL4_474000_453000 METAL4_474000_465000 0.096
R_VDD2_8005 METAL4_474000_465000 METAL4_474000_469000 0.032
R_VDD2_8006 METAL4_474000_469000 METAL4_474000_477000 0.064
R_VDD2_8007 METAL4_474000_477000 METAL4_472000_477000 0.016
R_VDD2_8008 METAL4_472000_477000 METAL4_470000_477000 0.016
R_VDD2_8009 METAL4_470000_477000 METAL4_464000_477000 0.048
R_VDD2_8010 METAL4_464000_477000 METAL4_462000_477000 0.016
R_VDD2_8011 METAL4_462000_477000 METAL4_460000_477000 0.016
R_VDD2_8012 METAL4_460000_477000 METAL4_458000_477000 0.016
R_VDD2_8013 METAL4_458000_477000 METAL4_452000_477000 0.048
R_VDD2_8014 METAL4_452000_477000 METAL4_450000_477000 0.016
R_VDD2_8015 METAL4_450000_477000 METAL4_448000_477000 0.016
R_VDD2_8016 METAL4_448000_477000 METAL4_446000_477000 0.016
R_VDD2_8017 METAL4_446000_477000 METAL4_444000_477000 0.016
R_VDD2_8018 METAL4_444000_477000 METAL4_440000_477000 0.032
R_VDD2_8019 METAL4_440000_477000 METAL4_438000_477000 0.016
R_VDD2_8020 METAL4_438000_477000 METAL5_438000_477000 0.1
R_VDD2_8021 METAL5_438000_477000 METAL5_438000_481000 0.016
R_VDD2_8022 METAL5_438000_481000 METAL5_438000_489000 0.032
R_VDD2_8023 METAL5_438000_489000 METAL5_438000_493000 0.016
R_VDD2_8024 METAL5_438000_493000 METAL5_438000_501000 0.032
R_VDD2_8025 METAL5_438000_501000 METAL5_438000_505000 0.016
R_VDD2_8026 METAL5_438000_505000 METAL5_438000_517000 0.048
R_VDD2_8027 METAL5_438000_517000 METAL5_438000_529000 0.048
R_VDD2_8028 METAL5_438000_529000 METAL5_438000_541000 0.048
R_VDD2_8029 METAL5_438000_541000 METAL5_438000_553000 0.048
R_VDD2_8030 METAL5_438000_553000 METAL5_438000_565000 0.048
R_VDD2_8031 METAL5_438000_565000 METAL5_438000_577000 0.048
R_VDD2_8032 METAL5_438000_577000 METAL4_438000_577000 0.1
R_VDD2_8033 METAL4_438000_577000 METAL4_438000_589000 0.096
R_VDD2_8034 METAL4_438000_589000 METAL4_438000_601000 0.096
R_VDD2_8035 METAL4_438000_601000 METAL4_438000_613000 0.096
R_VDD2_8036 METAL4_438000_613000 METAL5_438000_613000 0.1
R_VDD2_8037 METAL5_438000_613000 METAL5_438000_625000 0.048
R_VDD2_8038 METAL5_438000_625000 METAL5_438000_681000 0.224
R_VDD2_8039 METAL5_438000_681000 METAL5_438000_693000 0.048
R_VDD2_8040 METAL5_438000_693000 METAL4_438000_693000 0.1
R_VDD2_8041 METAL4_438000_693000 METAL4_438000_705000 0.096
R_VDD2_8042 METAL4_438000_705000 METAL4_438000_707000 0.016
R_VDD2_8043 METAL4_438000_707000 METAL4_438000_717000 0.08
R_VDD2_8044 METAL4_438000_717000 METAL5_438000_717000 0.1
R_VDD2_8045 METAL5_438000_717000 METAL5_438000_757000 0.16
R_VDD2_8046 METAL5_438000_757000 METAL5_438000_769000 0.048
R_VDD2_8047 METAL5_438000_769000 METAL5_438000_781000 0.048
R_VDD2_8048 METAL5_438000_781000 METAL5_438000_793000 0.048
R_VDD2_8049 METAL5_438000_793000 METAL5_436000_793000 0.008
R_VDD2_8050 METAL5_436000_793000 METAL5_434000_793000 0.008
R_VDD2_8051 METAL5_434000_793000 METAL5_432000_793000 0.008
R_VDD2_8052 METAL5_432000_793000 METAL5_428000_793000 0.016
R_VDD2_8053 METAL5_428000_793000 METAL5_426000_793000 0.008
R_VDD2_8054 METAL5_426000_793000 METAL5_426000_805000 0.048
R_VDD2_8055 METAL5_426000_805000 METAL4_426000_805000 0.1
R_VDD2_8056 METAL4_426000_805000 METAL4_426000_817000 0.096
R_VDD2_8057 METAL4_426000_817000 METAL4_426000_829000 0.096
R_VDD2_8058 METAL4_426000_829000 METAL4_426000_841000 0.096
R_VDD2_8059 METAL4_426000_841000 METAL4_426000_853000 0.096
R_VDD2_8060 METAL4_426000_853000 METAL4_426000_857000 0.032
R_VDD2_8061 METAL4_426000_857000 METAL4_426000_865000 0.064
R_VDD2_8062 METAL4_426000_865000 METAL4_426000_869000 0.032
R_VDD2_8063 METAL4_426000_869000 METAL4_426000_877000 0.064
R_VDD2_8064 METAL4_426000_877000 METAL4_426000_881000 0.032
R_VDD2_8065 METAL4_426000_881000 METAL4_426000_889000 0.064
R_VDD2_8066 METAL4_426000_889000 METAL5_426000_889000 0.1
R_VDD2_8067 METAL5_426000_889000 METAL5_426000_893000 0.016
R_VDD2_8068 METAL5_426000_893000 METAL5_426000_901000 0.032
R_VDD2_8069 METAL5_426000_901000 METAL5_426000_905000 0.016
R_VDD2_8070 METAL5_426000_905000 METAL5_426000_913000 0.032
R_VDD2_8071 METAL5_426000_913000 METAL5_426000_917000 0.016
R_VDD2_8072 METAL5_426000_917000 METAL5_426000_929000 0.048
R_VDD2_8073 METAL5_426000_929000 METAL5_426000_941000 0.048
R_VDD2_8074 METAL5_426000_941000 METAL5_424000_941000 0.008
R_VDD2_8075 METAL5_424000_941000 METAL4_424000_941000 0.1
R_VDD2_8076 METAL4_424000_941000 METAL4_424000_953000 0.096
R_VDD2_8077 METAL4_424000_953000 METAL4_424000_965000 0.096
R_VDD2_8078 METAL4_424000_965000 METAL4_424000_977000 0.096
R_VDD2_8079 METAL4_424000_977000 METAL4_424000_989000 0.096
R_VDD2_8080 METAL4_424000_989000 METAL4_424000_1001000 0.096
R_VDD2_8081 METAL4_424000_1001000 METAL4_424000_1013000 0.096
R_VDD2_8082 METAL4_424000_1013000 METAL4_424000_1025000 0.096
R_VDD2_8083 METAL4_424000_1025000 METAL4_424000_1041000 0.128
R_VDD2_8084 METAL4_424000_1041000 METAL4_424000_1053000 0.096
R_VDD2_8085 METAL4_424000_1053000 METAL4_422000_1053000 0.016
R_VDD2_8086 METAL4_422000_1053000 METAL4_420000_1053000 0.016
R_VDD2_8087 METAL4_420000_1053000 METAL4_416000_1053000 0.032
R_VDD2_8088 METAL4_416000_1053000 METAL4_414000_1053000 0.016
R_VDD2_8089 METAL4_414000_1053000 METAL4_412000_1053000 0.016
R_VDD2_8090 METAL4_412000_1053000 METAL4_410000_1053000 0.016
R_VDD2_8091 METAL4_410000_1053000 METAL4_408000_1053000 0.016
R_VDD2_8092 METAL4_408000_1053000 METAL4_402000_1053000 0.048
R_VDD2_8093 METAL4_402000_1053000 METAL4_400000_1053000 0.016
R_VDD2_8094 METAL4_400000_1053000 METAL4_398000_1053000 0.016
R_VDD2_8095 METAL4_398000_1053000 METAL4_396000_1053000 0.016
R_VDD2_8096 METAL4_396000_1053000 METAL4_390000_1053000 0.048
R_VDD2_8097 METAL4_390000_1053000 METAL4_388000_1053000 0.016
R_VDD2_8098 METAL4_388000_1053000 METAL4_386000_1053000 0.016
R_VDD2_8099 METAL4_386000_1053000 METAL4_384000_1053000 0.016
R_VDD2_8100 METAL4_384000_1053000 METAL4_378000_1053000 0.048
R_VDD2_8101 METAL4_378000_1053000 METAL4_376000_1053000 0.016
R_VDD2_8102 METAL4_376000_1053000 METAL4_374000_1053000 0.016
R_VDD2_8103 METAL4_374000_1053000 METAL4_372000_1053000 0.016
R_VDD2_8104 METAL4_372000_1053000 METAL4_366000_1053000 0.048
R_VDD2_8105 METAL4_366000_1053000 METAL4_364000_1053000 0.016
R_VDD2_8106 METAL4_364000_1053000 METAL4_362000_1053000 0.016
R_VDD2_8107 METAL4_362000_1053000 METAL4_360000_1053000 0.016
R_VDD2_8108 METAL4_360000_1053000 METAL4_354000_1053000 0.048
R_VDD2_8109 METAL4_354000_1053000 METAL4_352000_1053000 0.016
R_VDD2_8110 METAL4_352000_1053000 METAL4_350000_1053000 0.016
R_VDD2_8111 METAL4_350000_1053000 METAL4_348000_1053000 0.016
R_VDD2_8112 METAL4_348000_1053000 METAL4_342000_1053000 0.048
R_VDD2_8113 METAL4_342000_1053000 METAL4_340000_1053000 0.016
R_VDD2_8114 METAL4_340000_1053000 METAL4_338000_1053000 0.016
R_VDD2_8115 METAL4_338000_1053000 METAL4_336000_1053000 0.016
R_VDD2_8116 METAL4_336000_1053000 METAL4_330000_1053000 0.048
R_VDD2_8117 METAL4_330000_1053000 METAL4_328000_1053000 0.016
R_VDD2_8118 METAL4_328000_1053000 METAL4_326000_1053000 0.016
R_VDD2_8119 METAL4_326000_1053000 METAL4_324000_1053000 0.016
R_VDD2_8120 METAL4_324000_1053000 METAL4_318000_1053000 0.048
R_VDD2_8121 METAL4_318000_1053000 METAL4_317000_1053000 0.008
R_VDD2_8122 METAL4_317000_1053000 METAL4_316000_1053000 0.008
R_VDD2_8123 METAL4_316000_1053000 METAL4_314000_1053000 0.016
R_VDD2_8124 METAL4_314000_1053000 METAL4_314000_1065000 0.096
R_VDD2_8125 METAL4_314000_1065000 METAL4_314000_1077000 0.096
R_VDD2_8126 METAL4_314000_1077000 METAL4_314000_1089000 0.096
R_VDD2_8127 METAL4_314000_1089000 METAL5_314000_1089000 0.1
R_VDD2_8128 METAL5_314000_1089000 METAL5_314000_1101000 0.048
R_VDD2_8129 METAL5_314000_1101000 METAL5_314000_1113000 0.048
R_VDD2_8130 METAL5_314000_1113000 METAL5_314000_1153000 0.16
R_VDD2_8131 METAL5_314000_1153000 METAL5_314000_1165000 0.048
R_VDD2_8132 METAL5_314000_1165000 METAL5_314000_1177000 0.048
R_VDD2_8133 METAL5_314000_1177000 METAL5_314000_1189000 0.048
R_VDD2_8134 METAL5_314000_1189000 METAL5_314000_1201000 0.048
R_VDD2_8135 METAL5_314000_1201000 METAL5_314000_1205000 0.016
R_VDD2_8136 METAL5_314000_1205000 METAL5_314000_1217000 0.048
R_VDD2_8137 METAL5_314000_1217000 METAL5_314000_1229000 0.048
R_VDD2_8138 METAL5_314000_1229000 METAL5_312000_1229000 0.008
R_VDD2_8139 METAL5_312000_1229000 METAL4_312000_1229000 0.1
R_VDD2_8140 METAL4_312000_1229000 METAL4_312000_1241000 0.096
R_VDD2_8141 METAL4_312000_1241000 METAL4_312000_1253000 0.096
R_VDD2_8142 METAL4_312000_1253000 METAL4_312000_1265000 0.096
R_VDD2_8143 METAL4_312000_1265000 METAL4_312000_1277000 0.096
R_VDD2_8144 METAL4_312000_1277000 METAL4_312000_1289000 0.096
R_VDD2_8145 METAL4_312000_1289000 METAL5_312000_1289000 0.1
R_VDD2_8146 METAL5_312000_1289000 METAL5_312000_1301000 0.048
R_VDD2_8147 METAL5_312000_1301000 METAL5_312000_1345000 0.176
R_VDD2_8148 METAL5_312000_1345000 METAL5_306000_1345000 0.024
R_VDD2_8149 METAL5_306000_1345000 METAL5_305000_1345000 0.004
R_VDD2_8150 METAL5_305000_1345000 METAL5_304000_1345000 0.004
R_VDD2_8151 METAL5_304000_1345000 METAL5_302000_1345000 0.008
R_VDD2_8152 METAL5_302000_1345000 METAL5_300000_1345000 0.008
R_VDD2_8153 METAL5_300000_1345000 METAL5_294000_1345000 0.024
R_VDD2_8154 METAL5_294000_1345000 METAL5_293000_1345000 0.004
R_VDD2_8155 METAL5_293000_1345000 METAL5_292000_1345000 0.004
R_VDD2_8156 METAL5_292000_1345000 METAL5_290000_1345000 0.008
R_VDD2_8157 METAL5_290000_1345000 METAL5_290000_1357000 0.048
R_VDD2_8158 METAL5_290000_1357000 METAL4_290000_1357000 0.1
R_VDD2_8159 METAL4_290000_1357000 METAL4_290000_1369000 0.096
R_VDD2_8160 METAL4_290000_1369000 METAL4_290000_1381000 0.096
R_VDD2_8161 METAL4_290000_1381000 METAL4_290000_1393000 0.096
R_VDD2_8162 METAL4_290000_1393000 METAL4_290000_1405000 0.096
R_VDD2_8163 METAL4_290000_1405000 METAL4_292000_1405000 0.016
R_VDD2_8164 METAL4_292000_1405000 METAL4_293000_1405000 0.008
R_VDD2_8165 METAL4_293000_1405000 METAL5_293000_1405000 0.1
R_VDD2_8166 METAL5_293000_1405000 METAL5_293000_1407000 0.008
R_VDD2_8167 METAL5_293000_1407000 METAL5_293000_1417000 0.04
R_VDD2_8168 METAL5_293000_1417000 METAL5_293000_1429000 0.048
R_VDD2_8169 METAL5_293000_1429000 METAL5_293000_1517000 0.352
R_VDD2_8170 METAL5_293000_1517000 METAL5_292000_1517000 0.004
R_VDD2_8171 METAL5_292000_1517000 METAL5_290000_1517000 0.008
R_VDD2_8172 METAL5_290000_1517000 METAL5_288000_1517000 0.008
R_VDD2_8173 METAL5_288000_1517000 METAL5_282000_1517000 0.024
R_VDD2_8174 METAL5_282000_1517000 METAL5_281000_1517000 0.004
R_VDD2_8175 METAL5_281000_1517000 METAL5_280000_1517000 0.004
R_VDD2_8176 METAL5_280000_1517000 METAL5_278000_1517000 0.008
R_VDD2_8177 METAL5_278000_1517000 METAL5_276000_1517000 0.008
R_VDD2_8178 METAL5_276000_1517000 METAL4_276000_1517000 0.1
R_VDD2_8179 METAL4_276000_1517000 METAL4_276000_1529000 0.096
R_VDD2_8180 METAL4_276000_1529000 METAL4_270000_1529000 0.048
R_VDD2_8181 METAL4_270000_1529000 METAL4_269000_1529000 0.008
R_VDD2_8182 METAL4_269000_1529000 METAL4_269000_1541000 0.096
R_VDD2_8183 METAL4_269000_1541000 METAL4_269000_1553000 0.096
R_VDD2_8184 METAL4_269000_1553000 METAL4_269000_1565000 0.096
R_VDD2_8185 METAL4_269000_1565000 METAL4_269000_1577000 0.096
R_VDD2_8186 METAL4_269000_1577000 METAL4_266000_1577000 0.024
R_VDD2_8187 METAL4_266000_1577000 METAL4_264000_1577000 0.016
R_VDD2_8188 METAL4_264000_1577000 METAL4_258000_1577000 0.048
R_VDD2_8189 METAL4_258000_1577000 METAL4_257000_1577000 0.008
R_VDD2_8190 METAL4_257000_1577000 METAL5_257000_1577000 0.1
R_VDD2_8191 METAL5_257000_1577000 METAL6_257000_1577000 0.1
R_VDD2_8192 METAL6_257000_1577000 METAL6_257000_1589000 0.024
R_VDD2_8193 METAL6_257000_1589000 METAL6_257000_1617000 0.056
R_VDD2_8194 METAL6_257000_1617000 METAL6_257000_1629000 0.024
R_VDD2_8195 METAL6_257000_1629000 METAL6_257000_1641000 0.024
R_VDD2_8196 METAL6_257000_1641000 METAL6_257000_1653000 0.024
R_VDD2_8197 METAL6_257000_1653000 METAL6_257000_1665000 0.024
R_VDD2_8198 METAL6_555000_965000 METAL6_543000_965000 0.024
R_VDD2_8199 METAL4_531000_941000 METAL4_536000_941000 0.04
R_VDD2_8200 METAL4_536000_941000 METAL4_543000_941000 0.056
R_VDD2_8201 METAL4_543000_941000 METAL5_543000_941000 0.1
R_VDD2_8202 METAL5_543000_941000 METAL6_543000_941000 0.1
R_VDD2_8203 METAL6_543000_941000 METAL6_543000_953000 0.024
R_VDD2_8204 METAL6_543000_953000 METAL6_543000_965000 0.024
R_VDD2_8205 METAL6_245000_965000 METAL6_257000_965000 0.024
R_VDD2_8206 METAL3_350000_8000 METAL3_348000_8000 0.016
R_VDD2_8207 METAL3_348000_8000 METAL3_342000_8000 0.048
R_VDD2_8208 METAL3_342000_8000 METAL3_340000_8000 0.016
R_VDD2_8209 METAL3_340000_8000 METAL3_338000_8000 0.016
R_VDD2_8210 METAL3_338000_8000 METAL3_338000_20000 0.096
R_VDD2_8211 METAL3_338000_20000 METAL4_338000_20000 0.1
R_VDD2_8212 METAL4_338000_20000 METAL4_336000_20000 0.016
R_VDD2_8213 METAL4_336000_20000 METAL4_330000_20000 0.048
R_VDD2_8214 METAL4_330000_20000 METAL4_328000_20000 0.016
R_VDD2_8215 METAL4_328000_20000 METAL4_326000_20000 0.016
R_VDD2_8216 METAL4_326000_20000 METAL4_324000_20000 0.016
R_VDD2_8217 METAL4_324000_20000 METAL4_318000_20000 0.048
R_VDD2_8218 METAL4_318000_20000 METAL4_317000_20000 0.008
R_VDD2_8219 METAL4_317000_20000 METAL4_316000_20000 0.008
R_VDD2_8220 METAL4_316000_20000 METAL4_314000_20000 0.016
R_VDD2_8221 METAL4_314000_20000 METAL4_312000_20000 0.016
R_VDD2_8222 METAL4_312000_20000 METAL4_306000_20000 0.048
R_VDD2_8223 METAL4_306000_20000 METAL4_305000_20000 0.008
R_VDD2_8224 METAL4_305000_20000 METAL4_304000_20000 0.008
R_VDD2_8225 METAL4_304000_20000 METAL4_302000_20000 0.016
R_VDD2_8226 METAL4_302000_20000 METAL4_300000_20000 0.016
R_VDD2_8227 METAL4_300000_20000 METAL4_294000_20000 0.048
R_VDD2_8228 METAL4_294000_20000 METAL4_293000_20000 0.008
R_VDD2_8229 METAL4_293000_20000 METAL4_292000_20000 0.008
R_VDD2_8230 METAL4_292000_20000 METAL4_290000_20000 0.016
R_VDD2_8231 METAL4_290000_20000 METAL4_288000_20000 0.016
R_VDD2_8232 METAL4_288000_20000 METAL4_282000_20000 0.048
R_VDD2_8233 METAL4_282000_20000 METAL5_282000_20000 0.1
R_VDD2_8234 METAL5_282000_20000 METAL6_282000_20000 0.1
R_VDD2_8235 METAL6_282000_20000 METAL6_282000_32000 0.024
R_VDD2_8236 METAL6_282000_32000 METAL6_282000_44000 0.024
R_VDD2_8237 METAL6_282000_44000 METAL6_282000_45000 0.002
R_VDD2_8238 METAL6_282000_45000 METAL6_282000_56000 0.022
R_VDD2_8239 METAL6_282000_56000 METAL6_281000_56000 0.002
R_VDD2_8240 METAL6_281000_56000 METAL6_280000_56000 0.002
R_VDD2_8241 METAL6_280000_56000 METAL6_278000_56000 0.004
R_VDD2_8242 METAL6_278000_56000 METAL6_276000_56000 0.004
R_VDD2_8243 METAL6_276000_56000 METAL6_270000_56000 0.012
R_VDD2_8244 METAL6_270000_56000 METAL6_270000_57000 0.002
R_VDD2_8245 METAL6_270000_57000 METAL6_270000_68000 0.022
R_VDD2_8246 METAL6_270000_68000 METAL6_270000_69000 0.002
R_VDD2_8247 METAL6_270000_69000 METAL6_270000_80000 0.022
R_VDD2_8248 METAL6_270000_80000 METAL6_270000_81000 0.002
R_VDD2_8249 METAL6_270000_81000 METAL6_270000_92000 0.022
R_VDD2_8250 METAL6_270000_92000 METAL6_270000_93000 0.002
R_VDD2_8251 METAL6_270000_93000 METAL6_270000_105000 0.024
R_VDD2_8252 METAL6_270000_105000 METAL6_270000_109000 0.008
R_VDD2_8253 METAL6_270000_109000 METAL6_270000_117000 0.016
R_VDD2_8254 METAL6_270000_117000 METAL6_270000_121000 0.008
R_VDD2_8255 METAL6_270000_121000 METAL6_269000_121000 0.002
R_VDD2_8256 METAL6_269000_121000 METAL5_269000_121000 0.1
R_VDD2_8257 METAL5_269000_121000 METAL5_269000_129000 0.032
R_VDD2_8258 METAL5_269000_129000 METAL5_269000_133000 0.016
R_VDD2_8259 METAL5_269000_133000 METAL5_269000_141000 0.032
R_VDD2_8260 METAL5_269000_141000 METAL5_269000_145000 0.016
R_VDD2_8261 METAL5_269000_145000 METAL5_269000_153000 0.032
R_VDD2_8262 METAL5_269000_153000 METAL5_269000_157000 0.016
R_VDD2_8263 METAL5_269000_157000 METAL5_269000_165000 0.032
R_VDD2_8264 METAL5_269000_165000 METAL5_269000_169000 0.016
R_VDD2_8265 METAL5_269000_169000 METAL5_269000_177000 0.032
R_VDD2_8266 METAL5_269000_177000 METAL5_269000_181000 0.016
R_VDD2_8267 METAL5_269000_181000 METAL5_269000_193000 0.048
R_VDD2_8268 METAL5_269000_193000 METAL5_269000_205000 0.048
R_VDD2_8269 METAL5_269000_205000 METAL5_269000_217000 0.048
R_VDD2_8270 METAL5_269000_217000 METAL5_269000_229000 0.048
R_VDD2_8271 METAL5_269000_229000 METAL5_269000_233000 0.016
R_VDD2_8272 METAL5_269000_233000 METAL5_269000_241000 0.032
R_VDD2_8273 METAL5_269000_241000 METAL4_269000_241000 0.1
R_VDD2_8274 METAL4_269000_241000 METAL4_269000_245000 0.032
R_VDD2_8275 METAL4_269000_245000 METAL4_269000_253000 0.064
R_VDD2_8276 METAL4_269000_253000 METAL4_269000_257000 0.032
R_VDD2_8277 METAL4_269000_257000 METAL4_269000_265000 0.064
R_VDD2_8278 METAL4_269000_265000 METAL4_269000_269000 0.032
R_VDD2_8279 METAL4_269000_269000 METAL5_269000_269000 0.1
R_VDD2_8280 METAL5_269000_269000 METAL5_269000_277000 0.032
R_VDD2_8281 METAL5_269000_277000 METAL5_269000_281000 0.016
R_VDD2_8282 METAL5_269000_281000 METAL5_269000_289000 0.032
R_VDD2_8283 METAL5_269000_289000 METAL5_269000_293000 0.016
R_VDD2_8284 METAL5_269000_293000 METAL5_269000_301000 0.032
R_VDD2_8285 METAL5_269000_301000 METAL5_269000_305000 0.016
R_VDD2_8286 METAL5_269000_305000 METAL5_266000_305000 0.012
R_VDD2_8287 METAL5_266000_305000 METAL5_264000_305000 0.008
R_VDD2_8288 METAL5_264000_305000 METAL5_264000_313000 0.032
R_VDD2_8289 METAL5_264000_313000 METAL5_264000_317000 0.016
R_VDD2_8290 METAL5_264000_317000 METAL5_264000_329000 0.048
R_VDD2_8291 METAL5_264000_329000 METAL5_264000_341000 0.048
R_VDD2_8292 METAL5_264000_341000 METAL5_264000_353000 0.048
R_VDD2_8293 METAL5_264000_353000 METAL4_264000_353000 0.1
R_VDD2_8294 METAL4_264000_353000 METAL4_266000_353000 0.016
R_VDD2_8295 METAL4_266000_353000 METAL4_269000_353000 0.024
R_VDD2_8296 METAL4_269000_353000 METAL4_269000_365000 0.096
R_VDD2_8297 METAL4_269000_365000 METAL4_269000_377000 0.096
R_VDD2_8298 METAL4_269000_377000 METAL4_266000_377000 0.024
R_VDD2_8299 METAL4_266000_377000 METAL4_264000_377000 0.016
R_VDD2_8300 METAL4_264000_377000 METAL5_264000_377000 0.1
R_VDD2_8301 METAL5_264000_377000 METAL5_264000_381000 0.016
R_VDD2_8302 METAL5_264000_381000 METAL5_264000_389000 0.032
R_VDD2_8303 METAL5_264000_389000 METAL5_264000_393000 0.016
R_VDD2_8304 METAL5_264000_393000 METAL5_264000_401000 0.032
R_VDD2_8305 METAL5_264000_401000 METAL5_264000_405000 0.016
R_VDD2_8306 METAL5_264000_405000 METAL5_264000_417000 0.048
R_VDD2_8307 METAL5_264000_417000 METAL5_264000_429000 0.048
R_VDD2_8308 METAL5_264000_429000 METAL5_264000_441000 0.048
R_VDD2_8309 METAL5_264000_441000 METAL5_264000_453000 0.048
R_VDD2_8310 METAL5_264000_453000 METAL4_264000_453000 0.1
R_VDD2_8311 METAL4_264000_453000 METAL4_266000_453000 0.016
R_VDD2_8312 METAL4_266000_453000 METAL4_269000_453000 0.024
R_VDD2_8313 METAL4_269000_453000 METAL4_269000_465000 0.096
R_VDD2_8314 METAL4_269000_465000 METAL4_269000_469000 0.032
R_VDD2_8315 METAL4_269000_469000 METAL4_269000_477000 0.064
R_VDD2_8316 METAL4_269000_477000 METAL4_269000_481000 0.032
R_VDD2_8317 METAL4_269000_481000 METAL4_269000_489000 0.064
R_VDD2_8318 METAL4_269000_489000 METAL5_269000_489000 0.1
R_VDD2_8319 METAL5_269000_489000 METAL5_269000_493000 0.016
R_VDD2_8320 METAL5_269000_493000 METAL5_269000_501000 0.032
R_VDD2_8321 METAL5_269000_501000 METAL5_269000_505000 0.016
R_VDD2_8322 METAL5_269000_505000 METAL5_269000_517000 0.048
R_VDD2_8323 METAL5_269000_517000 METAL5_269000_529000 0.048
R_VDD2_8324 METAL5_269000_529000 METAL5_269000_541000 0.048
R_VDD2_8325 METAL5_269000_541000 METAL4_269000_541000 0.1
R_VDD2_8326 METAL4_269000_541000 METAL3_269000_541000 0.1
R_VDD2_8327 METAL3_269000_541000 METAL3_269000_553000 0.096
R_VDD2_8328 METAL3_269000_553000 METAL3_269000_565000 0.096
R_VDD2_8329 METAL3_269000_565000 METAL3_269000_577000 0.096
R_VDD2_8330 METAL3_269000_577000 METAL3_266000_577000 0.024
R_VDD2_8331 METAL3_266000_577000 METAL3_264000_577000 0.016
R_VDD2_8332 METAL3_264000_577000 METAL4_264000_577000 0.1
R_VDD2_8333 METAL4_264000_577000 METAL4_258000_577000 0.048
R_VDD2_8334 METAL4_258000_577000 METAL4_257000_577000 0.008
R_VDD2_8335 METAL4_257000_577000 METAL5_257000_577000 0.1
R_VDD2_8336 METAL5_257000_577000 METAL5_257000_589000 0.048
R_VDD2_8337 METAL5_257000_589000 METAL5_257000_601000 0.048
R_VDD2_8338 METAL5_257000_601000 METAL5_257000_613000 0.048
R_VDD2_8339 METAL5_257000_613000 METAL5_257000_625000 0.048
R_VDD2_8340 METAL5_257000_625000 METAL5_257000_681000 0.224
R_VDD2_8341 METAL5_257000_681000 METAL5_257000_693000 0.048
R_VDD2_8342 METAL5_257000_693000 METAL5_257000_705000 0.048
R_VDD2_8343 METAL5_257000_705000 METAL5_257000_707000 0.008
R_VDD2_8344 METAL5_257000_707000 METAL5_257000_717000 0.04
R_VDD2_8345 METAL5_257000_717000 METAL5_257000_729000 0.048
R_VDD2_8346 METAL5_257000_729000 METAL5_257000_757000 0.112
R_VDD2_8347 METAL5_257000_757000 METAL5_257000_769000 0.048
R_VDD2_8348 METAL5_257000_769000 METAL5_257000_781000 0.048
R_VDD2_8349 METAL5_257000_781000 METAL5_257000_793000 0.048
R_VDD2_8350 METAL5_257000_793000 METAL5_257000_805000 0.048
R_VDD2_8351 METAL5_257000_805000 METAL5_257000_817000 0.048
R_VDD2_8352 METAL5_257000_817000 METAL5_257000_829000 0.048
R_VDD2_8353 METAL5_257000_829000 METAL5_257000_841000 0.048
R_VDD2_8354 METAL5_257000_841000 METAL4_257000_841000 0.1
R_VDD2_8355 METAL4_257000_841000 METAL3_257000_841000 0.1
R_VDD2_8356 METAL3_257000_841000 METAL3_257000_853000 0.096
R_VDD2_8357 METAL3_257000_853000 METAL3_258000_853000 0.008
R_VDD2_8358 METAL3_258000_853000 METAL3_264000_853000 0.048
R_VDD2_8359 METAL3_264000_853000 METAL3_266000_853000 0.016
R_VDD2_8360 METAL3_266000_853000 METAL3_269000_853000 0.024
R_VDD2_8361 METAL3_269000_853000 METAL3_269000_857000 0.032
R_VDD2_8362 METAL3_269000_857000 METAL3_269000_865000 0.064
R_VDD2_8363 METAL3_269000_865000 METAL3_269000_869000 0.032
R_VDD2_8364 METAL3_269000_869000 METAL3_269000_877000 0.064
R_VDD2_8365 METAL3_269000_877000 METAL3_266000_877000 0.024
R_VDD2_8366 METAL3_266000_877000 METAL3_264000_877000 0.016
R_VDD2_8367 METAL3_264000_877000 METAL3_258000_877000 0.048
R_VDD2_8368 METAL3_258000_877000 METAL3_257000_877000 0.008
R_VDD2_8369 METAL3_257000_877000 METAL4_257000_877000 0.1
R_VDD2_8370 METAL4_257000_877000 METAL5_257000_877000 0.1
R_VDD2_8371 METAL5_257000_877000 METAL6_257000_877000 0.1
R_VDD2_8372 METAL6_257000_877000 METAL6_257000_881000 0.008
R_VDD2_8373 METAL6_257000_881000 METAL6_257000_889000 0.016
R_VDD2_8374 METAL6_257000_889000 METAL6_257000_893000 0.008
R_VDD2_8375 METAL6_257000_893000 METAL6_257000_901000 0.016
R_VDD2_8376 METAL6_257000_901000 METAL6_257000_905000 0.008
R_VDD2_8377 METAL6_257000_905000 METAL6_257000_913000 0.016
R_VDD2_8378 METAL6_257000_913000 METAL6_257000_917000 0.008
R_VDD2_8379 METAL6_257000_917000 METAL6_257000_929000 0.024
R_VDD2_8380 METAL6_257000_929000 METAL6_257000_941000 0.024
R_VDD2_8381 METAL6_257000_941000 METAL6_257000_953000 0.024
R_VDD2_8382 METAL6_257000_953000 METAL6_257000_965000 0.024
R_VDD2_8383 METAL6_555000_265000 METAL6_543000_265000 0.024
R_VDD2_8384 METAL5_512000_217000 METAL5_519000_217000 0.028
R_VDD2_8385 METAL5_519000_217000 METAL5_522000_217000 0.012
R_VDD2_8386 METAL5_522000_217000 METAL5_524000_217000 0.008
R_VDD2_8387 METAL5_524000_217000 METAL5_531000_217000 0.028
R_VDD2_8388 METAL5_531000_217000 METAL5_536000_217000 0.02
R_VDD2_8389 METAL5_536000_217000 METAL5_543000_217000 0.028
R_VDD2_8390 METAL5_543000_217000 METAL6_543000_217000 0.1
R_VDD2_8391 METAL6_543000_217000 METAL6_543000_229000 0.024
R_VDD2_8392 METAL6_543000_229000 METAL6_543000_233000 0.008
R_VDD2_8393 METAL6_543000_233000 METAL6_543000_241000 0.016
R_VDD2_8394 METAL6_543000_241000 METAL6_543000_245000 0.008
R_VDD2_8395 METAL6_543000_245000 METAL6_543000_253000 0.016
R_VDD2_8396 METAL6_543000_253000 METAL6_543000_257000 0.008
R_VDD2_8397 METAL6_543000_257000 METAL6_543000_265000 0.016
R_VDD2_8398 METAL6_245000_265000 METAL6_257000_265000 0.024
R_VDD2_8399 METAL5_269000_293000 METAL5_266000_293000 0.012
R_VDD2_8400 METAL5_266000_293000 METAL5_264000_293000 0.008
R_VDD2_8401 METAL5_264000_293000 METAL5_258000_293000 0.024
R_VDD2_8402 METAL5_258000_293000 METAL5_257000_293000 0.004
R_VDD2_8403 METAL5_257000_293000 METAL5_257000_289000 0.016
R_VDD2_8404 METAL5_257000_289000 METAL6_257000_289000 0.1
R_VDD2_8405 METAL6_257000_289000 METAL6_257000_281000 0.016
R_VDD2_8406 METAL6_257000_281000 METAL6_257000_277000 0.008
R_VDD2_8407 METAL6_257000_277000 METAL6_257000_269000 0.016
R_VDD2_8408 METAL6_257000_269000 METAL6_257000_265000 0.008
R_VDD2_8409 METAL5_269000_241000 METAL5_268000_241000 0.004
R_VDD2_8410 METAL5_268000_241000 METAL5_266000_241000 0.008
R_VDD2_8411 METAL5_266000_241000 METAL5_264000_241000 0.008
R_VDD2_8412 METAL5_264000_241000 METAL5_258000_241000 0.024
R_VDD2_8413 METAL5_258000_241000 METAL5_257000_241000 0.004
R_VDD2_8414 METAL5_257000_241000 METAL5_257000_233000 0.032
R_VDD2_8415 METAL5_257000_233000 METAL5_257000_229000 0.016
R_VDD2_8416 METAL5_257000_229000 METAL5_257000_221000 0.032
R_VDD2_8417 METAL5_257000_221000 METAL5_257000_217000 0.016
R_VDD2_8418 METAL5_257000_217000 METAL5_257000_205000 0.048
R_VDD2_8419 METAL5_257000_205000 METAL5_257000_193000 0.048
R_VDD2_8420 METAL5_257000_193000 METAL5_257000_189000 0.016
R_VDD2_8421 METAL5_257000_189000 METAL5_257000_181000 0.032
R_VDD2_8422 METAL5_257000_181000 METAL5_257000_177000 0.016
R_VDD2_8423 METAL5_257000_177000 METAL4_257000_177000 0.1
R_VDD2_8424 METAL4_257000_177000 METAL4_258000_177000 0.008
R_VDD2_8425 METAL4_258000_177000 METAL4_264000_177000 0.048
R_VDD2_8426 METAL4_264000_177000 METAL4_266000_177000 0.016
R_VDD2_8427 METAL4_266000_177000 METAL4_268000_177000 0.016
R_VDD2_8428 METAL4_268000_177000 METAL4_269000_177000 0.008
R_VDD2_8429 METAL4_269000_177000 METAL4_270000_177000 0.008
R_VDD2_8430 METAL4_270000_177000 METAL4_276000_177000 0.048
R_VDD2_8431 METAL4_276000_177000 METAL4_278000_177000 0.016
R_VDD2_8432 METAL4_278000_177000 METAL4_280000_177000 0.016
R_VDD2_8433 METAL4_280000_177000 METAL4_281000_177000 0.008
R_VDD2_8434 METAL4_281000_177000 METAL4_281000_169000 0.064
R_VDD2_8435 METAL4_281000_169000 METAL4_281000_165000 0.032
R_VDD2_8436 METAL4_281000_165000 METAL4_281000_157000 0.064
R_VDD2_8437 METAL4_281000_157000 METAL4_281000_153000 0.032
R_VDD2_8438 METAL4_281000_153000 METAL4_281000_145000 0.064
R_VDD2_8439 METAL4_281000_145000 METAL4_281000_141000 0.032
R_VDD2_8440 METAL4_281000_141000 METAL4_281000_133000 0.064
R_VDD2_8441 METAL4_281000_133000 METAL4_281000_129000 0.032
R_VDD2_8442 METAL4_281000_129000 METAL4_281000_121000 0.064
R_VDD2_8443 METAL4_281000_121000 METAL4_281000_117000 0.032
R_VDD2_8444 METAL4_281000_117000 METAL4_281000_116000 0.008
R_VDD2_8445 METAL4_281000_116000 METAL4_282000_116000 0.008
R_VDD2_8446 METAL4_282000_116000 METAL4_282000_109000 0.056
R_VDD2_8447 METAL4_282000_109000 METAL5_282000_109000 0.1
R_VDD2_8448 METAL5_282000_109000 METAL5_282000_105000 0.016
R_VDD2_8449 METAL5_282000_105000 METAL5_282000_104000 0.004
R_VDD2_8450 METAL5_282000_104000 METAL5_281000_104000 0.004
R_VDD2_8451 METAL5_281000_104000 METAL5_280000_104000 0.004
R_VDD2_8452 METAL5_280000_104000 METAL5_278000_104000 0.008
R_VDD2_8453 METAL5_278000_104000 METAL5_276000_104000 0.008
R_VDD2_8454 METAL5_276000_104000 METAL5_270000_104000 0.024
R_VDD2_8455 METAL5_270000_104000 METAL5_270000_97000 0.028
R_VDD2_8456 METAL5_270000_97000 METAL5_270000_93000 0.016
R_VDD2_8457 METAL5_270000_93000 METAL5_270000_92000 0.004
R_VDD2_8458 METAL5_270000_92000 METAL5_270000_81000 0.044
R_VDD2_8459 METAL5_270000_81000 METAL5_270000_80000 0.004
R_VDD2_8460 METAL5_270000_80000 METAL5_270000_69000 0.044
R_VDD2_8461 METAL5_270000_69000 METAL5_270000_68000 0.004
R_VDD2_8462 METAL5_270000_68000 METAL4_270000_68000 0.1
R_VDD2_8463 METAL4_270000_68000 METAL4_270000_57000 0.088
R_VDD2_8464 METAL4_270000_57000 METAL4_270000_56000 0.008
R_VDD2_8465 METAL4_270000_56000 METAL4_270000_45000 0.088
R_VDD2_8466 METAL4_270000_45000 METAL4_276000_45000 0.048
R_VDD2_8467 METAL4_276000_45000 METAL4_278000_45000 0.016
R_VDD2_8468 METAL4_278000_45000 METAL4_280000_45000 0.016
R_VDD2_8469 METAL4_280000_45000 METAL4_280000_44000 0.008
R_VDD2_8470 METAL4_280000_44000 METAL4_280000_33000 0.088
R_VDD2_8471 METAL4_280000_33000 METAL4_281000_33000 0.008
R_VDD2_8472 METAL4_281000_33000 METAL4_282000_33000 0.008
R_VDD2_8473 METAL4_282000_33000 METAL4_288000_33000 0.048
R_VDD2_8474 METAL4_288000_33000 METAL4_290000_33000 0.016
R_VDD2_8475 METAL4_290000_33000 METAL4_292000_33000 0.016
R_VDD2_8476 METAL4_292000_33000 METAL4_292000_32000 0.008
R_VDD2_8477 METAL4_292000_32000 METAL4_293000_32000 0.008
R_VDD2_8478 METAL4_293000_32000 METAL4_294000_32000 0.008
R_VDD2_8479 METAL4_294000_32000 METAL4_300000_32000 0.048
R_VDD2_8480 METAL4_300000_32000 METAL4_302000_32000 0.016
R_VDD2_8481 METAL4_302000_32000 METAL4_304000_32000 0.016
R_VDD2_8482 METAL4_304000_32000 METAL4_305000_32000 0.008
R_VDD2_8483 METAL4_305000_32000 METAL4_306000_32000 0.008
R_VDD2_8484 METAL4_306000_32000 METAL4_312000_32000 0.048
R_VDD2_8485 METAL4_312000_32000 METAL4_314000_32000 0.016
R_VDD2_8486 METAL4_314000_32000 METAL4_316000_32000 0.016
R_VDD2_8487 METAL4_316000_32000 METAL4_317000_32000 0.008
R_VDD2_8488 METAL4_317000_32000 METAL4_318000_32000 0.008
R_VDD2_8489 METAL4_318000_32000 METAL4_324000_32000 0.048
R_VDD2_8490 METAL4_324000_32000 METAL4_326000_32000 0.016
R_VDD2_8491 METAL4_326000_32000 METAL3_326000_32000 0.1
R_VDD2_8492 METAL3_326000_32000 METAL3_326000_20000 0.096
R_VDD2_8493 METAL3_326000_20000 METAL3_326000_8000 0.096
R_VDD2_8494 METAL3_326000_8000 METAL2_326000_8000 0.1
R_VDD2_8495 METAL2_326000_8000 METAL2_328000_8000 0.016
R_VDD2_8496 METAL2_328000_8000 METAL2_329000_8000 0.008
R_VDD2_8497 METAL2_329000_8000 METAL2_330000_8000 0.008
R_VDD2_8498 METAL2_330000_8000 METAL2_336000_8000 0.048
R_VDD2_8499 METAL2_336000_8000 METAL2_338000_8000 0.016
R_VDD2_8500 METAL2_338000_8000 METAL2_340000_8000 0.016
R_VDD2_8501 METAL2_340000_8000 METAL2_342000_8000 0.016
R_VDD2_8502 METAL2_342000_8000 METAL2_348000_8000 0.048
R_VDD2_8503 METAL2_348000_8000 METAL2_350000_8000 0.016
R_VDD2_8504 METAL2_350000_8000 METAL3_350000_8000 0.1
R_VDD2_8505 METAL3_350000_8000 METAL4_350000_8000 0.1
R_VDD2_8506 METAL4_350000_8000 METAL5_350000_8000 0.1
R_VDD2_8507 METAL5_350000_8000 METAL6_350000_8000 0.1
R_VDD2_8508 METAL5_269000_229000 METAL4_269000_229000 0.1
R_VDD2_8509 METAL4_269000_229000 METAL4_269000_221000 0.064
R_VDD2_8510 METAL4_269000_221000 METAL4_269000_217000 0.032
R_VDD2_8511 METAL4_269000_217000 METAL4_269000_205000 0.096
R_VDD2_8512 METAL4_269000_205000 METAL4_269000_193000 0.096
R_VDD2_8513 METAL4_269000_193000 METAL4_269000_189000 0.032
R_VDD2_8514 METAL4_269000_189000 METAL4_270000_189000 0.008
R_VDD2_8515 METAL4_270000_189000 METAL4_276000_189000 0.048
R_VDD2_8516 METAL4_276000_189000 METAL4_278000_189000 0.016
R_VDD2_8517 METAL4_278000_189000 METAL4_280000_189000 0.016
R_VDD2_8518 METAL4_280000_189000 METAL4_281000_189000 0.008
R_VDD2_8519 METAL4_281000_189000 METAL4_282000_189000 0.008
R_VDD2_8520 METAL4_282000_189000 METAL4_288000_189000 0.048
R_VDD2_8521 METAL4_288000_189000 METAL4_290000_189000 0.016
R_VDD2_8522 METAL4_290000_189000 METAL4_292000_189000 0.016
R_VDD2_8523 METAL4_292000_189000 METAL4_293000_189000 0.008
R_VDD2_8524 METAL4_293000_189000 METAL3_293000_189000 0.1
R_VDD2_8525 METAL3_293000_189000 METAL2_293000_189000 0.1
R_VDD2_8526 METAL2_293000_189000 METAL1_293000_189000 0.1
R_VDD2_8527 METAL1_293000_189000 METAL1_293000_181000 0.064
R_VDD2_8528 METAL1_293000_181000 METAL1_293000_177000 0.032
R_VDD2_8529 METAL1_293000_177000 METAL1_293000_169000 0.064
R_VDD2_8530 METAL1_293000_169000 METAL1_293000_165000 0.032
R_VDD2_8531 METAL1_293000_165000 METAL1_293000_157000 0.064
R_VDD2_8532 METAL1_293000_157000 METAL1_293000_153000 0.032
R_VDD2_8533 METAL1_293000_153000 METAL1_293000_145000 0.064
R_VDD2_8534 METAL1_293000_145000 METAL1_293000_141000 0.032
R_VDD2_8535 METAL1_293000_141000 METAL1_293000_133000 0.064
R_VDD2_8536 METAL1_293000_133000 METAL1_293000_129000 0.032
R_VDD2_8537 METAL1_293000_129000 METAL1_293000_128000 0.008
R_VDD2_8538 METAL1_293000_128000 METAL1_293000_121000 0.056
R_VDD2_8539 METAL1_293000_121000 METAL1_293000_117000 0.032
R_VDD2_8540 METAL1_293000_117000 METAL1_293000_116000 0.008
R_VDD2_8541 METAL1_293000_116000 METAL1_293000_109000 0.056
R_VDD2_8542 METAL1_293000_109000 METAL1_293000_105000 0.032
R_VDD2_8543 METAL1_293000_105000 METAL1_294000_105000 0.008
R_VDD2_8544 METAL1_294000_105000 METAL1_300000_105000 0.048
R_VDD2_8545 METAL1_300000_105000 METAL1_302000_105000 0.016
R_VDD2_8546 METAL1_302000_105000 METAL1_304000_105000 0.016
R_VDD2_8547 METAL1_304000_105000 METAL1_305000_105000 0.008
R_VDD2_8548 METAL1_305000_105000 METAL1_306000_105000 0.008
R_VDD2_8549 METAL1_306000_105000 METAL1_312000_105000 0.048
R_VDD2_8550 METAL1_312000_105000 METAL1_314000_105000 0.016
R_VDD2_8551 METAL1_314000_105000 METAL1_316000_105000 0.016
R_VDD2_8552 METAL1_316000_105000 METAL1_317000_105000 0.008
R_VDD2_8553 METAL1_317000_105000 METAL1_318000_105000 0.008
R_VDD2_8554 METAL1_318000_105000 METAL1_324000_105000 0.048
R_VDD2_8555 METAL1_324000_105000 METAL1_326000_105000 0.016
R_VDD2_8556 METAL1_326000_105000 METAL1_328000_105000 0.016
R_VDD2_8557 METAL1_328000_105000 METAL1_329000_105000 0.008
R_VDD2_8558 METAL1_329000_105000 METAL1_330000_105000 0.008
R_VDD2_8559 METAL1_330000_105000 METAL1_336000_105000 0.048
R_VDD2_8560 METAL1_336000_105000 METAL1_338000_105000 0.016
R_VDD2_8561 METAL1_338000_105000 METAL1_340000_105000 0.016
R_VDD2_8562 METAL1_340000_105000 METAL1_342000_105000 0.016
R_VDD2_8563 METAL1_342000_105000 METAL1_348000_105000 0.048
R_VDD2_8564 METAL1_348000_105000 METAL1_350000_105000 0.016
R_VDD2_8565 METAL1_350000_105000 METAL1_350000_104000 0.008
R_VDD2_8566 METAL1_350000_104000 METAL1_350000_97000 0.056
R_VDD2_8567 METAL1_350000_97000 METAL1_350000_93000 0.032
R_VDD2_8568 METAL1_350000_93000 METAL1_350000_92000 0.008
R_VDD2_8569 METAL1_350000_92000 METAL1_350000_81000 0.088
R_VDD2_8570 METAL1_350000_81000 METAL1_350000_80000 0.008
R_VDD2_8571 METAL1_350000_80000 METAL1_350000_69000 0.088
R_VDD2_8572 METAL1_350000_69000 METAL1_350000_68000 0.008
R_VDD2_8573 METAL1_350000_68000 METAL1_350000_57000 0.088
R_VDD2_8574 METAL1_350000_57000 METAL1_350000_56000 0.008
R_VDD2_8575 METAL1_350000_56000 METAL1_350000_45000 0.088
R_VDD2_8576 METAL1_350000_45000 METAL1_350000_44000 0.008
R_VDD2_8577 METAL1_350000_44000 METAL1_350000_33000 0.088
R_VDD2_8578 METAL1_350000_33000 METAL1_350000_32000 0.008
R_VDD2_8579 METAL1_350000_32000 METAL1_350000_21000 0.088
R_VDD2_8580 METAL1_350000_21000 METAL1_350000_20000 0.008
R_VDD2_8581 METAL1_350000_20000 METAL1_350000_8000 0.096
R_VDD2_8582 METAL1_350000_8000 METAL2_350000_8000 0.1
R_VDD2_8583 METAL6_543000_265000 METAL5_543000_265000 0.1
R_VDD2_8584 METAL5_543000_265000 METAL5_543000_257000 0.032
R_VDD2_8585 METAL5_543000_257000 METAL5_543000_253000 0.016
R_VDD2_8586 METAL5_543000_253000 METAL5_543000_245000 0.032
R_VDD2_8587 METAL5_543000_245000 METAL5_543000_241000 0.016
R_VDD2_8588 METAL5_543000_241000 METAL5_543000_233000 0.032
R_VDD2_8589 METAL5_543000_233000 METAL5_543000_229000 0.016
R_VDD2_8590 METAL5_543000_229000 METAL4_543000_229000 0.1
R_VDD2_8591 METAL4_543000_229000 METAL4_543000_221000 0.064
R_VDD2_8592 METAL4_543000_221000 METAL4_543000_217000 0.032
R_VDD2_8593 METAL4_543000_217000 METAL4_543000_205000 0.096
R_VDD2_8594 METAL4_543000_205000 METAL4_543000_201000 0.032
R_VDD2_8595 METAL4_543000_201000 METAL4_543000_193000 0.064
R_VDD2_8596 METAL4_543000_193000 METAL4_536000_193000 0.056
R_VDD2_8597 METAL4_536000_193000 METAL4_531000_193000 0.04
R_VDD2_8598 METAL4_531000_193000 METAL4_524000_193000 0.056
R_VDD2_8599 METAL4_524000_193000 METAL4_524000_189000 0.032
R_VDD2_8600 METAL4_524000_189000 METAL4_524000_181000 0.064
R_VDD2_8601 METAL4_524000_181000 METAL4_524000_177000 0.032
R_VDD2_8602 METAL4_524000_177000 METAL4_524000_169000 0.064
R_VDD2_8603 METAL4_524000_169000 METAL4_524000_165000 0.032
R_VDD2_8604 METAL4_524000_165000 METAL4_524000_157000 0.064
R_VDD2_8605 METAL4_524000_157000 METAL4_524000_153000 0.032
R_VDD2_8606 METAL4_524000_153000 METAL4_524000_145000 0.064
R_VDD2_8607 METAL4_524000_145000 METAL4_524000_141000 0.032
R_VDD2_8608 METAL4_524000_141000 METAL4_524000_133000 0.064
R_VDD2_8609 METAL4_524000_133000 METAL4_524000_129000 0.032
R_VDD2_8610 METAL4_524000_129000 METAL4_524000_128000 0.008
R_VDD2_8611 METAL4_524000_128000 METAL4_524000_121000 0.056
R_VDD2_8612 METAL4_524000_121000 METAL4_524000_117000 0.032
R_VDD2_8613 METAL4_524000_117000 METAL4_522000_117000 0.016
R_VDD2_8614 METAL4_522000_117000 METAL4_519000_117000 0.024
R_VDD2_8615 METAL4_519000_117000 METAL5_519000_117000 0.1
R_VDD2_8616 METAL5_519000_117000 METAL5_512000_117000 0.028
R_VDD2_8617 METAL5_512000_117000 METAL5_512000_116000 0.004
R_VDD2_8618 METAL5_512000_116000 METAL5_512000_109000 0.028
R_VDD2_8619 METAL5_512000_109000 METAL5_512000_105000 0.016
R_VDD2_8620 METAL5_512000_105000 METAL5_512000_104000 0.004
R_VDD2_8621 METAL5_512000_104000 METAL5_512000_97000 0.028
R_VDD2_8622 METAL5_512000_97000 METAL5_512000_93000 0.016
R_VDD2_8623 METAL5_512000_93000 METAL5_512000_92000 0.004
R_VDD2_8624 METAL5_512000_92000 METAL5_512000_81000 0.044
R_VDD2_8625 METAL5_512000_81000 METAL5_512000_80000 0.004
R_VDD2_8626 METAL5_512000_80000 METAL5_512000_69000 0.044
R_VDD2_8627 METAL5_512000_69000 METAL5_512000_68000 0.004
R_VDD2_8628 METAL5_512000_68000 METAL5_512000_57000 0.044
R_VDD2_8629 METAL5_512000_57000 METAL5_512000_56000 0.004
R_VDD2_8630 METAL5_512000_56000 METAL4_512000_56000 0.1
R_VDD2_8631 METAL4_512000_56000 METAL4_510000_56000 0.016
R_VDD2_8632 METAL4_510000_56000 METAL4_508000_56000 0.016
R_VDD2_8633 METAL4_508000_56000 METAL4_507000_56000 0.008
R_VDD2_8634 METAL4_507000_56000 METAL4_506000_56000 0.008
R_VDD2_8635 METAL4_506000_56000 METAL4_500000_56000 0.048
R_VDD2_8636 METAL4_500000_56000 METAL4_498000_56000 0.016
R_VDD2_8637 METAL4_498000_56000 METAL4_496000_56000 0.016
R_VDD2_8638 METAL4_496000_56000 METAL4_495000_56000 0.008
R_VDD2_8639 METAL4_495000_56000 METAL3_495000_56000 0.1
R_VDD2_8640 METAL3_495000_56000 METAL2_495000_56000 0.1
R_VDD2_8641 METAL2_495000_56000 METAL1_495000_56000 0.1
R_VDD2_8642 METAL1_495000_56000 METAL1_495000_45000 0.088
R_VDD2_8643 METAL1_495000_45000 METAL1_495000_44000 0.008
R_VDD2_8644 METAL1_495000_44000 METAL1_495000_33000 0.088
R_VDD2_8645 METAL1_495000_33000 METAL1_495000_32000 0.008
R_VDD2_8646 METAL1_495000_32000 METAL1_495000_21000 0.088
R_VDD2_8647 METAL1_495000_21000 METAL1_495000_20000 0.008
R_VDD2_8648 METAL1_495000_20000 METAL1_494000_20000 0.008
R_VDD2_8649 METAL1_494000_20000 METAL1_488000_20000 0.048
R_VDD2_8650 METAL1_488000_20000 METAL1_486000_20000 0.016
R_VDD2_8651 METAL1_486000_20000 METAL1_484000_20000 0.016
R_VDD2_8652 METAL1_484000_20000 METAL1_483000_20000 0.008
R_VDD2_8653 METAL1_483000_20000 METAL1_482000_20000 0.008
R_VDD2_8654 METAL1_482000_20000 METAL1_476000_20000 0.048
R_VDD2_8655 METAL1_476000_20000 METAL1_474000_20000 0.016
R_VDD2_8656 METAL1_474000_20000 METAL1_472000_20000 0.016
R_VDD2_8657 METAL1_472000_20000 METAL1_471000_20000 0.008
R_VDD2_8658 METAL1_471000_20000 METAL1_470000_20000 0.008
R_VDD2_8659 METAL1_470000_20000 METAL1_464000_20000 0.048
R_VDD2_8660 METAL1_464000_20000 METAL1_462000_20000 0.016
R_VDD2_8661 METAL1_462000_20000 METAL1_460000_20000 0.016
R_VDD2_8662 METAL1_460000_20000 METAL1_458000_20000 0.016
R_VDD2_8663 METAL1_458000_20000 METAL1_452000_20000 0.048
R_VDD2_8664 METAL1_452000_20000 METAL1_450000_20000 0.016
R_VDD2_8665 METAL1_450000_20000 METAL1_448000_20000 0.016
R_VDD2_8666 METAL1_448000_20000 METAL1_446000_20000 0.016
R_VDD2_8667 METAL1_446000_20000 METAL1_444000_20000 0.016
R_VDD2_8668 METAL1_444000_20000 METAL1_440000_20000 0.032
R_VDD2_8669 METAL1_440000_20000 METAL1_438000_20000 0.016
R_VDD2_8670 METAL1_438000_20000 METAL1_436000_20000 0.016
R_VDD2_8671 METAL1_436000_20000 METAL1_434000_20000 0.016
R_VDD2_8672 METAL1_434000_20000 METAL1_432000_20000 0.016
R_VDD2_8673 METAL1_432000_20000 METAL1_428000_20000 0.032
R_VDD2_8674 METAL1_428000_20000 METAL1_426000_20000 0.016
R_VDD2_8675 METAL1_426000_20000 METAL1_424000_20000 0.016
R_VDD2_8676 METAL1_424000_20000 METAL1_422000_20000 0.016
R_VDD2_8677 METAL1_422000_20000 METAL1_420000_20000 0.016
R_VDD2_8678 METAL1_420000_20000 METAL1_416000_20000 0.032
R_VDD2_8679 METAL1_416000_20000 METAL1_414000_20000 0.016
R_VDD2_8680 METAL1_414000_20000 METAL1_412000_20000 0.016
R_VDD2_8681 METAL1_412000_20000 METAL1_410000_20000 0.016
R_VDD2_8682 METAL1_410000_20000 METAL1_408000_20000 0.016
R_VDD2_8683 METAL1_408000_20000 METAL1_404000_20000 0.032
R_VDD2_8684 METAL1_404000_20000 METAL1_402000_20000 0.016
R_VDD2_8685 METAL1_402000_20000 METAL1_400000_20000 0.016
R_VDD2_8686 METAL1_400000_20000 METAL1_398000_20000 0.016
R_VDD2_8687 METAL1_398000_20000 METAL1_396000_20000 0.016
R_VDD2_8688 METAL1_396000_20000 METAL1_390000_20000 0.048
R_VDD2_8689 METAL1_390000_20000 METAL1_388000_20000 0.016
R_VDD2_8690 METAL1_388000_20000 METAL1_388000_8000 0.096
R_VDD2_8691 METAL1_388000_8000 METAL2_388000_8000 0.1
R_VDD2_8692 METAL2_388000_8000 METAL3_388000_8000 0.1
R_VDD2_8693 METAL3_388000_8000 METAL3_386000_8000 0.016
R_VDD2_8694 METAL3_386000_8000 METAL3_384000_8000 0.016
R_VDD2_8695 METAL3_384000_8000 METAL3_378000_8000 0.048
R_VDD2_8696 METAL3_378000_8000 METAL3_376000_8000 0.016
R_VDD2_8697 METAL3_376000_8000 METAL3_374000_8000 0.016
R_VDD2_8698 METAL3_374000_8000 METAL3_372000_8000 0.016
R_VDD2_8699 METAL3_372000_8000 METAL3_366000_8000 0.048
R_VDD2_8700 METAL3_366000_8000 METAL3_364000_8000 0.016
R_VDD2_8701 METAL3_364000_8000 METAL3_362000_8000 0.016
R_VDD2_8702 METAL3_362000_8000 METAL3_360000_8000 0.016
R_VDD2_8703 METAL3_360000_8000 METAL3_354000_8000 0.048
R_VDD2_8704 METAL3_354000_8000 METAL3_352000_8000 0.016
R_VDD2_8705 METAL3_352000_8000 METAL3_350000_8000 0.016
R_VDD2_8706 METAL5_543000_265000 METAL4_543000_265000 0.1
R_VDD2_8707 METAL4_543000_265000 METAL3_543000_265000 0.1
R_VDD2_8708 METAL3_543000_265000 METAL2_543000_265000 0.1
R_VDD2_8709 METAL2_543000_265000 METAL1_543000_265000 0.1
R_VDD2_8710 METAL1_543000_265000 METAL1_543000_257000 0.064
R_VDD2_8711 METAL1_543000_257000 METAL1_543000_253000 0.032
R_VDD2_8712 METAL1_543000_253000 METAL1_543000_245000 0.064
R_VDD2_8713 METAL1_543000_245000 METAL1_536000_245000 0.056
R_VDD2_8714 METAL1_536000_245000 METAL1_531000_245000 0.04
R_VDD2_8715 METAL1_531000_245000 METAL1_524000_245000 0.056
R_VDD2_8716 METAL1_524000_245000 METAL1_524000_241000 0.032
R_VDD2_8717 METAL1_524000_241000 METAL1_524000_233000 0.064
R_VDD2_8718 METAL1_524000_233000 METAL1_524000_229000 0.032
R_VDD2_8719 METAL1_524000_229000 METAL1_524000_221000 0.064
R_VDD2_8720 METAL1_524000_221000 METAL1_524000_217000 0.032
R_VDD2_8721 METAL1_524000_217000 METAL1_524000_205000 0.096
R_VDD2_8722 METAL1_524000_205000 METAL1_524000_201000 0.032
R_VDD2_8723 METAL1_524000_201000 METAL1_524000_193000 0.064
R_VDD2_8724 METAL1_524000_193000 METAL1_524000_189000 0.032
R_VDD2_8725 METAL1_524000_189000 METAL1_524000_181000 0.064
R_VDD2_8726 METAL1_524000_181000 METAL1_524000_177000 0.032
R_VDD2_8727 METAL1_524000_177000 METAL1_524000_169000 0.064
R_VDD2_8728 METAL1_524000_169000 METAL1_524000_165000 0.032
R_VDD2_8729 METAL1_524000_165000 METAL1_524000_157000 0.064
R_VDD2_8730 METAL1_524000_157000 METAL1_524000_153000 0.032
R_VDD2_8731 METAL1_524000_153000 METAL1_524000_145000 0.064
R_VDD2_8732 METAL1_524000_145000 METAL1_524000_141000 0.032
R_VDD2_8733 METAL1_524000_141000 METAL1_524000_133000 0.064
R_VDD2_8734 METAL1_524000_133000 METAL1_524000_129000 0.032
R_VDD2_8735 METAL1_524000_129000 METAL1_522000_129000 0.016
R_VDD2_8736 METAL1_522000_129000 METAL1_519000_129000 0.024
R_VDD2_8737 METAL1_519000_129000 METAL1_512000_129000 0.056
R_VDD2_8738 METAL1_512000_129000 METAL1_510000_129000 0.016
R_VDD2_8739 METAL1_510000_129000 METAL1_508000_129000 0.016
R_VDD2_8740 METAL1_508000_129000 METAL1_508000_128000 0.008
R_VDD2_8741 METAL1_508000_128000 METAL1_508000_121000 0.056
R_VDD2_8742 METAL1_508000_121000 METAL1_508000_117000 0.032
R_VDD2_8743 METAL1_508000_117000 METAL1_508000_116000 0.008
R_VDD2_8744 METAL1_508000_116000 METAL1_508000_109000 0.056
R_VDD2_8745 METAL1_508000_109000 METAL1_508000_105000 0.032
R_VDD2_8746 METAL1_508000_105000 METAL1_508000_104000 0.008
R_VDD2_8747 METAL1_508000_104000 METAL1_508000_97000 0.056
R_VDD2_8748 METAL1_508000_97000 METAL1_508000_93000 0.032
R_VDD2_8749 METAL1_508000_93000 METAL1_508000_92000 0.008
R_VDD2_8750 METAL1_508000_92000 METAL1_508000_81000 0.088
R_VDD2_8751 METAL1_508000_81000 METAL1_508000_80000 0.008
R_VDD2_8752 METAL1_508000_80000 METAL1_508000_69000 0.088
R_VDD2_8753 METAL1_508000_69000 METAL1_508000_68000 0.008
R_VDD2_8754 METAL1_508000_68000 METAL1_507000_68000 0.008
R_VDD2_8755 METAL1_507000_68000 METAL1_506000_68000 0.008
R_VDD2_8756 METAL1_506000_68000 METAL1_500000_68000 0.048
R_VDD2_8757 METAL1_500000_68000 METAL1_498000_68000 0.016
R_VDD2_8758 METAL1_498000_68000 METAL1_496000_68000 0.016
R_VDD2_8759 METAL1_496000_68000 METAL1_495000_68000 0.008
R_VDD2_8760 METAL1_495000_68000 METAL1_494000_68000 0.008
R_VDD2_8761 METAL1_494000_68000 METAL1_488000_68000 0.048
R_VDD2_8762 METAL1_488000_68000 METAL1_486000_68000 0.016
R_VDD2_8763 METAL1_486000_68000 METAL1_484000_68000 0.016
R_VDD2_8764 METAL1_484000_68000 METAL1_483000_68000 0.008
R_VDD2_8765 METAL1_483000_68000 METAL1_483000_57000 0.088
R_VDD2_8766 METAL1_483000_57000 METAL1_483000_56000 0.008
R_VDD2_8767 METAL1_483000_56000 METAL1_483000_45000 0.088
R_VDD2_8768 METAL1_483000_45000 METAL1_483000_44000 0.008
R_VDD2_8769 METAL1_483000_44000 METAL1_483000_33000 0.088
R_VDD2_8770 METAL1_483000_33000 METAL1_483000_32000 0.008
R_VDD2_8771 METAL1_483000_32000 METAL1_482000_32000 0.008
R_VDD2_8772 METAL1_482000_32000 METAL1_476000_32000 0.048
R_VDD2_8773 METAL1_476000_32000 METAL1_474000_32000 0.016
R_VDD2_8774 METAL1_474000_32000 METAL1_472000_32000 0.016
R_VDD2_8775 METAL1_472000_32000 METAL1_471000_32000 0.008
R_VDD2_8776 METAL1_471000_32000 METAL1_470000_32000 0.008
R_VDD2_8777 METAL1_470000_32000 METAL1_464000_32000 0.048
R_VDD2_8778 METAL1_464000_32000 METAL1_462000_32000 0.016
R_VDD2_8779 METAL1_462000_32000 METAL1_460000_32000 0.016
R_VDD2_8780 METAL1_460000_32000 METAL1_458000_32000 0.016
R_VDD2_8781 METAL1_458000_32000 METAL1_452000_32000 0.048
R_VDD2_8782 METAL1_452000_32000 METAL1_450000_32000 0.016
R_VDD2_8783 METAL1_450000_32000 METAL1_448000_32000 0.016
R_VDD2_8784 METAL1_448000_32000 METAL1_446000_32000 0.016
R_VDD2_8785 METAL1_446000_32000 METAL1_444000_32000 0.016
R_VDD2_8786 METAL1_444000_32000 METAL1_440000_32000 0.032
R_VDD2_8787 METAL1_440000_32000 METAL1_438000_32000 0.016
R_VDD2_8788 METAL1_438000_32000 METAL1_436000_32000 0.016
R_VDD2_8789 METAL1_436000_32000 METAL1_434000_32000 0.016
R_VDD2_8790 METAL1_434000_32000 METAL1_432000_32000 0.016
R_VDD2_8791 METAL1_432000_32000 METAL1_428000_32000 0.032
R_VDD2_8792 METAL1_428000_32000 METAL1_426000_32000 0.016
R_VDD2_8793 METAL1_426000_32000 METAL1_424000_32000 0.016
R_VDD2_8794 METAL1_424000_32000 METAL1_422000_32000 0.016
R_VDD2_8795 METAL1_422000_32000 METAL1_420000_32000 0.016
R_VDD2_8796 METAL1_420000_32000 METAL1_416000_32000 0.032
R_VDD2_8797 METAL1_416000_32000 METAL1_414000_32000 0.016
R_VDD2_8798 METAL1_414000_32000 METAL1_412000_32000 0.016
R_VDD2_8799 METAL1_412000_32000 METAL1_410000_32000 0.016
R_VDD2_8800 METAL1_410000_32000 METAL1_408000_32000 0.016
R_VDD2_8801 METAL1_408000_32000 METAL1_404000_32000 0.032
R_VDD2_8802 METAL1_404000_32000 METAL1_402000_32000 0.016
R_VDD2_8803 METAL1_402000_32000 METAL1_400000_32000 0.016
R_VDD2_8804 METAL1_400000_32000 METAL1_398000_32000 0.016
R_VDD2_8805 METAL1_398000_32000 METAL1_396000_32000 0.016
R_VDD2_8806 METAL1_396000_32000 METAL1_390000_32000 0.048
R_VDD2_8807 METAL1_390000_32000 METAL1_388000_32000 0.016
R_VDD2_8808 METAL1_388000_32000 METAL1_386000_32000 0.016
R_VDD2_8809 METAL1_386000_32000 METAL1_384000_32000 0.016
R_VDD2_8810 METAL1_384000_32000 METAL1_378000_32000 0.048
R_VDD2_8811 METAL1_378000_32000 METAL1_376000_32000 0.016
R_VDD2_8812 METAL1_376000_32000 METAL1_376000_21000 0.088
R_VDD2_8813 METAL1_376000_21000 METAL1_374000_21000 0.016
R_VDD2_8814 METAL1_374000_21000 METAL1_372000_21000 0.016
R_VDD2_8815 METAL1_372000_21000 METAL1_366000_21000 0.048
R_VDD2_8816 METAL1_366000_21000 METAL1_364000_21000 0.016
R_VDD2_8817 METAL1_364000_21000 METAL1_362000_21000 0.016
R_VDD2_8818 METAL1_362000_21000 METAL1_362000_20000 0.008
R_VDD2_8819 METAL1_362000_20000 METAL1_362000_8000 0.096
R_VDD2_8820 METAL1_362000_8000 METAL2_362000_8000 0.1
R_VDD2_8821 METAL2_362000_8000 METAL2_360000_8000 0.016
R_VDD2_8822 METAL2_360000_8000 METAL2_354000_8000 0.048
R_VDD2_8823 METAL2_354000_8000 METAL2_352000_8000 0.016
R_VDD2_8824 METAL2_352000_8000 METAL2_350000_8000 0.016
R_VDD2_8825 METAL3_269000_553000 METAL4_269000_553000 0.1
R_VDD2_8826 METAL4_269000_553000 METAL4_270000_553000 0.008
R_VDD2_8827 METAL4_270000_553000 METAL4_276000_553000 0.048
R_VDD2_8828 METAL4_276000_553000 METAL4_278000_553000 0.016
R_VDD2_8829 METAL4_278000_553000 METAL4_280000_553000 0.016
R_VDD2_8830 METAL4_280000_553000 METAL4_281000_553000 0.008
R_VDD2_8831 METAL4_281000_553000 METAL4_281000_541000 0.096
R_VDD2_8832 METAL4_281000_541000 METAL4_282000_541000 0.008
R_VDD2_8833 METAL4_282000_541000 METAL4_288000_541000 0.048
R_VDD2_8834 METAL4_288000_541000 METAL4_290000_541000 0.016
R_VDD2_8835 METAL4_290000_541000 METAL4_292000_541000 0.016
R_VDD2_8836 METAL4_292000_541000 METAL4_293000_541000 0.008
R_VDD2_8837 METAL4_293000_541000 METAL3_293000_541000 0.1
R_VDD2_8838 METAL3_293000_541000 METAL3_294000_541000 0.008
R_VDD2_8839 METAL3_294000_541000 METAL3_300000_541000 0.048
R_VDD2_8840 METAL3_300000_541000 METAL3_302000_541000 0.016
R_VDD2_8841 METAL3_302000_541000 METAL3_304000_541000 0.016
R_VDD2_8842 METAL3_304000_541000 METAL3_305000_541000 0.008
R_VDD2_8843 METAL3_305000_541000 METAL3_306000_541000 0.008
R_VDD2_8844 METAL3_306000_541000 METAL3_312000_541000 0.048
R_VDD2_8845 METAL3_312000_541000 METAL3_314000_541000 0.016
R_VDD2_8846 METAL3_314000_541000 METAL3_316000_541000 0.016
R_VDD2_8847 METAL3_316000_541000 METAL3_317000_541000 0.008
R_VDD2_8848 METAL3_317000_541000 METAL2_317000_541000 0.1
R_VDD2_8849 METAL2_317000_541000 METAL1_317000_541000 0.1
R_VDD2_8850 METAL1_317000_541000 METAL1_317000_553000 0.096
R_VDD2_8851 METAL1_317000_553000 METAL1_317000_565000 0.096
R_VDD2_8852 METAL1_317000_565000 METAL1_316000_565000 0.008
R_VDD2_8853 METAL1_316000_565000 METAL1_314000_565000 0.016
R_VDD2_8854 METAL1_314000_565000 METAL1_312000_565000 0.016
R_VDD2_8855 METAL1_312000_565000 METAL1_306000_565000 0.048
R_VDD2_8856 METAL1_306000_565000 METAL1_305000_565000 0.008
R_VDD2_8857 METAL1_305000_565000 METAL1_305000_577000 0.096
R_VDD2_8858 METAL1_305000_577000 METAL1_305000_589000 0.096
R_VDD2_8859 METAL1_305000_589000 METAL1_305000_601000 0.096
R_VDD2_8860 METAL1_305000_601000 METAL1_305000_613000 0.096
R_VDD2_8861 METAL1_305000_613000 METAL1_305000_625000 0.096
R_VDD2_8862 METAL1_305000_625000 METAL1_305000_633000 0.064
R_VDD2_8863 METAL1_305000_633000 METAL1_305000_645000 0.096
R_VDD2_8864 METAL1_305000_645000 METAL1_305000_657000 0.096
R_VDD2_8865 METAL1_305000_657000 METAL1_305000_669000 0.096
R_VDD2_8866 METAL1_305000_669000 METAL1_305000_681000 0.096
R_VDD2_8867 METAL1_305000_681000 METAL1_305000_693000 0.096
R_VDD2_8868 METAL1_305000_693000 METAL1_305000_705000 0.096
R_VDD2_8869 METAL1_305000_705000 METAL1_305000_707000 0.016
R_VDD2_8870 METAL1_305000_707000 METAL1_305000_717000 0.08
R_VDD2_8871 METAL1_305000_717000 METAL1_305000_729000 0.096
R_VDD2_8872 METAL1_305000_729000 METAL1_305000_745000 0.128
R_VDD2_8873 METAL1_305000_745000 METAL1_305000_757000 0.096
R_VDD2_8874 METAL1_305000_757000 METAL1_305000_769000 0.096
R_VDD2_8875 METAL1_305000_769000 METAL1_304000_769000 0.008
R_VDD2_8876 METAL1_304000_769000 METAL1_302000_769000 0.016
R_VDD2_8877 METAL1_302000_769000 METAL1_300000_769000 0.016
R_VDD2_8878 METAL1_300000_769000 METAL1_294000_769000 0.048
R_VDD2_8879 METAL1_294000_769000 METAL1_293000_769000 0.008
R_VDD2_8880 METAL1_293000_769000 METAL1_293000_781000 0.096
R_VDD2_8881 METAL1_293000_781000 METAL1_293000_793000 0.096
R_VDD2_8882 METAL1_293000_793000 METAL1_293000_805000 0.096
R_VDD2_8883 METAL1_293000_805000 METAL1_293000_817000 0.096
R_VDD2_8884 METAL1_293000_817000 METAL1_293000_829000 0.096
R_VDD2_8885 METAL1_293000_829000 METAL1_293000_841000 0.096
R_VDD2_8886 METAL1_293000_841000 METAL1_293000_845000 0.032
R_VDD2_8887 METAL1_293000_845000 METAL1_293000_853000 0.064
R_VDD2_8888 METAL1_293000_853000 METAL1_293000_857000 0.032
R_VDD2_8889 METAL1_293000_857000 METAL1_293000_865000 0.064
R_VDD2_8890 METAL1_293000_865000 METAL1_293000_869000 0.032
R_VDD2_8891 METAL1_293000_869000 METAL1_293000_877000 0.064
R_VDD2_8892 METAL1_293000_877000 METAL1_293000_881000 0.032
R_VDD2_8893 METAL1_293000_881000 METAL1_293000_889000 0.064
R_VDD2_8894 METAL1_293000_889000 METAL1_293000_893000 0.032
R_VDD2_8895 METAL1_293000_893000 METAL1_293000_901000 0.064
R_VDD2_8896 METAL1_293000_901000 METAL1_293000_905000 0.032
R_VDD2_8897 METAL1_293000_905000 METAL1_293000_913000 0.064
R_VDD2_8898 METAL1_293000_913000 METAL1_292000_913000 0.008
R_VDD2_8899 METAL1_292000_913000 METAL1_290000_913000 0.016
R_VDD2_8900 METAL1_290000_913000 METAL1_288000_913000 0.016
R_VDD2_8901 METAL1_288000_913000 METAL1_282000_913000 0.048
R_VDD2_8902 METAL1_282000_913000 METAL1_281000_913000 0.008
R_VDD2_8903 METAL1_281000_913000 METAL1_280000_913000 0.008
R_VDD2_8904 METAL1_280000_913000 METAL1_278000_913000 0.016
R_VDD2_8905 METAL1_278000_913000 METAL1_276000_913000 0.016
R_VDD2_8906 METAL1_276000_913000 METAL1_270000_913000 0.048
R_VDD2_8907 METAL1_270000_913000 METAL1_269000_913000 0.008
R_VDD2_8908 METAL1_269000_913000 METAL1_268000_913000 0.008
R_VDD2_8909 METAL1_268000_913000 METAL1_266000_913000 0.016
R_VDD2_8910 METAL1_266000_913000 METAL1_264000_913000 0.016
R_VDD2_8911 METAL1_264000_913000 METAL2_264000_913000 0.1
R_VDD2_8912 METAL2_264000_913000 METAL2_258000_913000 0.048
R_VDD2_8913 METAL2_258000_913000 METAL2_257000_913000 0.008
R_VDD2_8914 METAL2_257000_913000 METAL3_257000_913000 0.1
R_VDD2_8915 METAL3_257000_913000 METAL4_257000_913000 0.1
R_VDD2_8916 METAL4_257000_913000 METAL5_257000_913000 0.1
R_VDD2_8917 METAL5_257000_913000 METAL5_257000_917000 0.016
R_VDD2_8918 METAL5_257000_917000 METAL5_257000_929000 0.048
R_VDD2_8919 METAL5_257000_929000 METAL5_257000_941000 0.048
R_VDD2_8920 METAL5_257000_941000 METAL5_257000_953000 0.048
R_VDD2_8921 METAL5_257000_953000 METAL5_257000_965000 0.048
R_VDD2_8922 METAL5_257000_965000 METAL6_257000_965000 0.1
I_VDD2_21 METAL6_555000_6565000 gnd 0.01
I_VDD2_22 METAL6_245000_6565000 gnd 0.01
I_VDD2_23 METAL6_555000_5865000 gnd 0.01
I_VDD2_24 METAL6_245000_5865000 gnd 0.01
I_VDD2_25 METAL6_555000_5165000 gnd 0.01
I_VDD2_26 METAL6_245000_5165000 gnd 0.01
I_VDD2_27 METAL6_555000_4465000 gnd 0.01
I_VDD2_28 METAL6_245000_4465000 gnd 0.01
I_VDD2_29 METAL6_555000_3765000 gnd 0.01
I_VDD2_30 METAL6_245000_3765000 gnd 0.01
I_VDD2_31 METAL6_555000_3065000 gnd 0.01
I_VDD2_32 METAL6_245000_3065000 gnd 0.01
I_VDD2_33 METAL6_555000_2365000 gnd 0.01
I_VDD2_34 METAL6_245000_2365000 gnd 0.01
I_VDD2_35 METAL6_555000_1665000 gnd 0.01
I_VDD2_36 METAL6_245000_1665000 gnd 0.01
I_VDD2_37 METAL6_555000_965000 gnd 0.01
I_VDD2_38 METAL6_245000_965000 gnd 0.01
I_VDD2_39 METAL6_555000_265000 gnd 0.01
I_VDD2_40 METAL6_245000_265000 gnd 0.01

V_VDD3_3 METAL6_400000_0 gnd 1
R_VDD3_8923 METAL6_400000_0 METAL6_400000_8000 0.016
R_VDD3_8924 METAL6_400000_8000 METAL6_400000_20000 0.024
R_VDD3_8925 METAL6_400000_20000 METAL6_400000_32000 0.024
R_VDD3_8926 METAL6_400000_32000 METAL6_400000_117000 0.17
R_VDD3_8927 METAL6_400000_117000 METAL6_398000_117000 0.004
R_VDD3_8928 METAL6_398000_117000 METAL6_390000_117000 0.016
R_VDD3_8929 METAL6_390000_117000 METAL6_390000_129000 0.024
R_VDD3_8930 METAL6_390000_129000 METAL6_390000_141000 0.024
R_VDD3_8931 METAL6_390000_141000 METAL6_390000_153000 0.024
R_VDD3_8932 METAL6_390000_153000 METAL6_390000_165000 0.024
R_VDD3_8933 METAL6_390000_165000 METAL6_390000_177000 0.024
R_VDD3_8934 METAL6_390000_177000 METAL6_390000_181000 0.008
R_VDD3_8935 METAL6_390000_181000 METAL6_388000_181000 0.004
R_VDD3_8936 METAL6_388000_181000 METAL6_386000_181000 0.004
R_VDD3_8937 METAL6_386000_181000 METAL6_378000_181000 0.016
R_VDD3_8938 METAL6_378000_181000 METAL6_376000_181000 0.004
R_VDD3_8939 METAL6_376000_181000 METAL6_374000_181000 0.004
R_VDD3_8940 METAL6_374000_181000 METAL6_366000_181000 0.016
R_VDD3_8941 METAL6_366000_181000 METAL6_366000_193000 0.024
R_VDD3_8942 METAL6_366000_193000 METAL6_364000_193000 0.004
R_VDD3_8943 METAL6_364000_193000 METAL6_362000_193000 0.004
R_VDD3_8944 METAL6_362000_193000 METAL6_354000_193000 0.016
R_VDD3_8945 METAL6_354000_193000 METAL6_354000_205000 0.024
R_VDD3_8946 METAL6_354000_205000 METAL6_352000_205000 0.004
R_VDD3_8947 METAL6_352000_205000 METAL6_350000_205000 0.004
R_VDD3_8948 METAL6_350000_205000 METAL6_348000_205000 0.004
R_VDD3_8949 METAL6_348000_205000 METAL6_342000_205000 0.012
R_VDD3_8950 METAL6_342000_205000 METAL6_342000_217000 0.024
R_VDD3_8951 METAL6_342000_217000 METAL6_342000_229000 0.024
R_VDD3_8952 METAL6_342000_229000 METAL6_342000_241000 0.024
R_VDD3_8953 METAL6_342000_241000 METAL6_342000_253000 0.024
R_VDD3_8954 METAL6_342000_253000 METAL6_342000_257000 0.008
R_VDD3_8955 METAL6_342000_257000 METAL6_340000_257000 0.004
R_VDD3_8956 METAL6_340000_257000 METAL6_338000_257000 0.004
R_VDD3_8957 METAL6_338000_257000 METAL6_336000_257000 0.004
R_VDD3_8958 METAL6_336000_257000 METAL6_330000_257000 0.012
R_VDD3_8959 METAL6_330000_257000 METAL6_330000_265000 0.016
R_VDD3_8960 METAL6_330000_265000 METAL6_330000_269000 0.008
R_VDD3_8961 METAL6_330000_269000 METAL6_330000_277000 0.016
R_VDD3_8962 METAL6_330000_277000 METAL6_330000_281000 0.008
R_VDD3_8963 METAL6_330000_281000 METAL6_330000_289000 0.016
R_VDD3_8964 METAL6_330000_289000 METAL6_330000_293000 0.008
R_VDD3_8965 METAL6_330000_293000 METAL5_330000_293000 0.1
R_VDD3_8966 METAL5_330000_293000 METAL5_330000_301000 0.032
R_VDD3_8967 METAL5_330000_301000 METAL5_336000_301000 0.024
R_VDD3_8968 METAL5_336000_301000 METAL5_336000_305000 0.016
R_VDD3_8969 METAL5_336000_305000 METAL5_336000_317000 0.048
R_VDD3_8970 METAL5_336000_317000 METAL5_338000_317000 0.008
R_VDD3_8971 METAL5_338000_317000 METAL5_338000_329000 0.048
R_VDD3_8972 METAL5_338000_329000 METAL5_338000_341000 0.048
R_VDD3_8973 METAL5_338000_341000 METAL5_338000_353000 0.048
R_VDD3_8974 METAL5_338000_353000 METAL5_338000_365000 0.048
R_VDD3_8975 METAL5_338000_365000 METAL5_338000_377000 0.048
R_VDD3_8976 METAL5_338000_377000 METAL6_338000_377000 0.1
R_VDD3_8977 METAL6_338000_377000 METAL6_338000_389000 0.024
R_VDD3_8978 METAL6_338000_389000 METAL6_338000_429000 0.08
R_VDD3_8979 METAL6_338000_429000 METAL6_338000_441000 0.024
R_VDD3_8980 METAL6_338000_441000 METAL6_338000_453000 0.024
R_VDD3_8981 METAL6_338000_453000 METAL6_338000_465000 0.024
R_VDD3_8982 METAL6_338000_465000 METAL6_338000_477000 0.024
R_VDD3_8983 METAL6_338000_477000 METAL6_338000_481000 0.008
R_VDD3_8984 METAL6_338000_481000 METAL5_338000_481000 0.1
R_VDD3_8985 METAL5_338000_481000 METAL5_338000_489000 0.032
R_VDD3_8986 METAL5_338000_489000 METAL5_338000_493000 0.016
R_VDD3_8987 METAL5_338000_493000 METAL5_338000_505000 0.048
R_VDD3_8988 METAL5_338000_505000 METAL5_338000_517000 0.048
R_VDD3_8989 METAL5_338000_517000 METAL5_338000_529000 0.048
R_VDD3_8990 METAL5_338000_529000 METAL5_338000_541000 0.048
R_VDD3_8991 METAL5_338000_541000 METAL5_338000_553000 0.048
R_VDD3_8992 METAL5_338000_553000 METAL5_338000_565000 0.048
R_VDD3_8993 METAL5_338000_565000 METAL5_338000_577000 0.048
R_VDD3_8994 METAL5_338000_577000 METAL4_338000_577000 0.1
R_VDD3_8995 METAL4_338000_577000 METAL4_338000_589000 0.096
R_VDD3_8996 METAL4_338000_589000 METAL4_338000_601000 0.096
R_VDD3_8997 METAL4_338000_601000 METAL5_338000_601000 0.1
R_VDD3_8998 METAL5_338000_601000 METAL5_338000_613000 0.048
R_VDD3_8999 METAL5_338000_613000 METAL5_338000_681000 0.272
R_VDD3_9000 METAL5_338000_681000 METAL5_338000_693000 0.048
R_VDD3_9001 METAL5_338000_693000 METAL5_338000_705000 0.048
R_VDD3_9002 METAL5_338000_705000 METAL5_338000_707000 0.008
R_VDD3_9003 METAL5_338000_707000 METAL5_338000_717000 0.04
R_VDD3_9004 METAL5_338000_717000 METAL5_338000_793000 0.304
R_VDD3_9005 METAL5_338000_793000 METAL5_338000_805000 0.048
R_VDD3_9006 METAL5_338000_805000 METAL5_338000_817000 0.048
R_VDD3_9007 METAL5_338000_817000 METAL5_336000_817000 0.008
R_VDD3_9008 METAL5_336000_817000 METAL5_330000_817000 0.024
R_VDD3_9009 METAL5_330000_817000 METAL5_328000_817000 0.008
R_VDD3_9010 METAL5_328000_817000 METAL5_326000_817000 0.008
R_VDD3_9011 METAL5_326000_817000 METAL5_324000_817000 0.008
R_VDD3_9012 METAL5_324000_817000 METAL5_324000_829000 0.048
R_VDD3_9013 METAL5_324000_829000 METAL5_324000_841000 0.048
R_VDD3_9014 METAL5_324000_841000 METAL5_324000_853000 0.048
R_VDD3_9015 METAL5_324000_853000 METAL5_324000_865000 0.048
R_VDD3_9016 METAL5_324000_865000 METAL5_324000_877000 0.048
R_VDD3_9017 METAL5_324000_877000 METAL5_324000_889000 0.048
R_VDD3_9018 METAL5_324000_889000 METAL5_314000_889000 0.04
R_VDD3_9019 METAL5_314000_889000 METAL5_314000_893000 0.016
R_VDD3_9020 METAL5_314000_893000 METAL4_314000_893000 0.1
R_VDD3_9021 METAL4_314000_893000 METAL4_314000_901000 0.064
R_VDD3_9022 METAL4_314000_901000 METAL4_314000_905000 0.032
R_VDD3_9023 METAL4_314000_905000 METAL4_314000_917000 0.096
R_VDD3_9024 METAL4_314000_917000 METAL4_314000_929000 0.096
R_VDD3_9025 METAL4_314000_929000 METAL4_314000_941000 0.096
R_VDD3_9026 METAL4_314000_941000 METAL4_314000_953000 0.096
R_VDD3_9027 METAL4_314000_953000 METAL4_314000_965000 0.096
R_VDD3_9028 METAL4_314000_965000 METAL4_314000_977000 0.096
R_VDD3_9029 METAL4_314000_977000 METAL4_314000_989000 0.096
R_VDD3_9030 METAL4_314000_989000 METAL4_314000_1001000 0.096
R_VDD3_9031 METAL4_314000_1001000 METAL4_314000_1013000 0.096
R_VDD3_9032 METAL4_314000_1013000 METAL5_314000_1013000 0.1
R_VDD3_9033 METAL5_314000_1013000 METAL5_314000_1041000 0.112
R_VDD3_9034 METAL5_314000_1041000 METAL5_314000_1053000 0.048
R_VDD3_9035 METAL5_314000_1053000 METAL5_314000_1065000 0.048
R_VDD3_9036 METAL5_314000_1065000 METAL5_312000_1065000 0.008
R_VDD3_9037 METAL5_312000_1065000 METAL6_312000_1065000 0.1
R_VDD3_9038 METAL6_312000_1065000 METAL6_312000_1077000 0.024
R_VDD3_9039 METAL6_312000_1077000 METAL6_312000_1089000 0.024
R_VDD3_9040 METAL6_312000_1089000 METAL6_312000_1153000 0.128
R_VDD3_9041 METAL6_312000_1153000 METAL6_312000_1165000 0.024
R_VDD3_9042 METAL6_312000_1165000 METAL6_312000_1177000 0.024
R_VDD3_9043 METAL6_312000_1177000 METAL6_312000_1189000 0.024
R_VDD3_9044 METAL6_312000_1189000 METAL6_312000_1201000 0.024
R_VDD3_9045 METAL6_312000_1201000 METAL6_312000_1253000 0.104
R_VDD3_9046 METAL6_312000_1253000 METAL5_312000_1253000 0.1
R_VDD3_9047 METAL5_312000_1253000 METAL5_312000_1265000 0.048
R_VDD3_9048 METAL5_312000_1265000 METAL5_312000_1277000 0.048
R_VDD3_9049 METAL5_312000_1277000 METAL5_302000_1277000 0.04
R_VDD3_9050 METAL5_302000_1277000 METAL5_300000_1277000 0.008
R_VDD3_9051 METAL5_300000_1277000 METAL5_293000_1277000 0.028
R_VDD3_9052 METAL5_293000_1277000 METAL5_288000_1277000 0.02
R_VDD3_9053 METAL5_288000_1277000 METAL5_281000_1277000 0.028
R_VDD3_9054 METAL5_281000_1277000 METAL5_276000_1277000 0.02
R_VDD3_9055 METAL5_276000_1277000 METAL5_269000_1277000 0.028
R_VDD3_9056 METAL5_269000_1277000 METAL5_264000_1277000 0.02
R_VDD3_9057 METAL5_264000_1277000 METAL5_257000_1277000 0.028
R_VDD3_9058 METAL5_257000_1277000 METAL6_257000_1277000 0.1
R_VDD3_9059 METAL6_257000_1277000 METAL6_257000_1289000 0.024
R_VDD3_9060 METAL6_257000_1289000 METAL6_257000_1369000 0.16
R_VDD3_9061 METAL6_257000_1369000 METAL6_257000_1381000 0.024
R_VDD3_9062 METAL6_257000_1381000 METAL6_257000_1393000 0.024
R_VDD3_9063 METAL6_257000_1393000 METAL6_257000_1405000 0.024
R_VDD3_9064 METAL6_257000_1405000 METAL6_257000_1407000 0.004
R_VDD3_9065 METAL6_257000_1407000 METAL6_257000_1417000 0.02
R_VDD3_9066 METAL6_257000_1417000 METAL6_257000_1541000 0.248
R_VDD3_9067 METAL6_257000_1541000 METAL6_257000_1553000 0.024
R_VDD3_9068 METAL6_257000_1553000 METAL5_257000_1553000 0.1
R_VDD3_9069 METAL5_257000_1553000 METAL5_264000_1553000 0.028
R_VDD3_9070 METAL5_264000_1553000 METAL5_269000_1553000 0.02
R_VDD3_9071 METAL5_269000_1553000 METAL5_269000_1565000 0.048
R_VDD3_9072 METAL5_269000_1565000 METAL5_269000_1577000 0.048
R_VDD3_9073 METAL5_269000_1577000 METAL5_269000_1641000 0.256
R_VDD3_9074 METAL5_269000_1641000 METAL5_276000_1641000 0.028
R_VDD3_9075 METAL5_276000_1641000 METAL5_281000_1641000 0.02
R_VDD3_9076 METAL5_281000_1641000 METAL5_288000_1641000 0.028
R_VDD3_9077 METAL5_288000_1641000 METAL5_293000_1641000 0.02
R_VDD3_9078 METAL5_293000_1641000 METAL5_293000_1653000 0.048
R_VDD3_9079 METAL5_293000_1653000 METAL4_293000_1653000 0.1
R_VDD3_9080 METAL4_293000_1653000 METAL4_293000_1665000 0.096
R_VDD3_9081 METAL4_293000_1665000 METAL4_293000_1677000 0.096
R_VDD3_9082 METAL4_293000_1677000 METAL5_293000_1677000 0.1
R_VDD3_9083 METAL5_293000_1677000 METAL5_293000_1753000 0.304
R_VDD3_9084 METAL5_293000_1753000 METAL5_293000_1765000 0.048
R_VDD3_9085 METAL5_293000_1765000 METAL5_293000_1777000 0.048
R_VDD3_9086 METAL5_293000_1777000 METAL5_293000_1789000 0.048
R_VDD3_9087 METAL5_293000_1789000 METAL5_293000_1829000 0.16
R_VDD3_9088 METAL5_293000_1829000 METAL5_300000_1829000 0.028
R_VDD3_9089 METAL5_300000_1829000 METAL5_300000_1841000 0.048
R_VDD3_9090 METAL5_300000_1841000 METAL5_300000_1853000 0.048
R_VDD3_9091 METAL5_300000_1853000 METAL5_302000_1853000 0.008
R_VDD3_9092 METAL5_302000_1853000 METAL5_312000_1853000 0.04
R_VDD3_9093 METAL5_312000_1853000 METAL5_312000_1865000 0.048
R_VDD3_9094 METAL5_312000_1865000 METAL5_312000_1877000 0.048
R_VDD3_9095 METAL5_312000_1877000 METAL5_312000_1917000 0.16
R_VDD3_9096 METAL5_312000_1917000 METAL5_312000_1929000 0.048
R_VDD3_9097 METAL5_312000_1929000 METAL5_312000_1941000 0.048
R_VDD3_9098 METAL5_312000_1941000 METAL4_312000_1941000 0.1
R_VDD3_9099 METAL4_312000_1941000 METAL4_312000_1953000 0.096
R_VDD3_9100 METAL4_312000_1953000 METAL4_312000_1965000 0.096
R_VDD3_9101 METAL4_312000_1965000 METAL4_312000_1977000 0.096
R_VDD3_9102 METAL4_312000_1977000 METAL4_312000_1989000 0.096
R_VDD3_9103 METAL4_312000_1989000 METAL5_312000_1989000 0.1
R_VDD3_9104 METAL5_312000_1989000 METAL5_312000_2093000 0.416
R_VDD3_9105 METAL5_312000_2093000 METAL5_312000_2107000 0.056
R_VDD3_9106 METAL5_312000_2107000 METAL5_312000_2229000 0.488
R_VDD3_9107 METAL5_312000_2229000 METAL5_312000_2241000 0.048
R_VDD3_9108 METAL5_312000_2241000 METAL5_312000_2253000 0.048
R_VDD3_9109 METAL5_312000_2253000 METAL5_314000_2253000 0.008
R_VDD3_9110 METAL5_314000_2253000 METAL5_324000_2253000 0.04
R_VDD3_9111 METAL5_324000_2253000 METAL5_324000_2265000 0.048
R_VDD3_9112 METAL5_324000_2265000 METAL5_324000_2277000 0.048
R_VDD3_9113 METAL5_324000_2277000 METAL5_324000_2341000 0.256
R_VDD3_9114 METAL5_324000_2341000 METAL5_324000_2353000 0.048
R_VDD3_9115 METAL5_324000_2353000 METAL5_324000_2365000 0.048
R_VDD3_9116 METAL5_324000_2365000 METAL5_324000_2377000 0.048
R_VDD3_9117 METAL5_324000_2377000 METAL5_324000_2453000 0.304
R_VDD3_9118 METAL5_324000_2453000 METAL5_324000_2465000 0.048
R_VDD3_9119 METAL5_324000_2465000 METAL5_324000_2477000 0.048
R_VDD3_9120 METAL5_324000_2477000 METAL5_324000_2489000 0.048
R_VDD3_9121 METAL5_324000_2489000 METAL5_324000_2553000 0.256
R_VDD3_9122 METAL5_324000_2553000 METAL5_324000_2565000 0.048
R_VDD3_9123 METAL5_324000_2565000 METAL5_324000_2577000 0.048
R_VDD3_9124 METAL5_324000_2577000 METAL5_324000_2617000 0.16
R_VDD3_9125 METAL5_324000_2617000 METAL4_324000_2617000 0.1
R_VDD3_9126 METAL4_324000_2617000 METAL4_324000_2629000 0.096
R_VDD3_9127 METAL4_324000_2629000 METAL4_324000_2641000 0.096
R_VDD3_9128 METAL4_324000_2641000 METAL4_324000_2653000 0.096
R_VDD3_9129 METAL4_324000_2653000 METAL5_324000_2653000 0.1
R_VDD3_9130 METAL5_324000_2653000 METAL5_314000_2653000 0.04
R_VDD3_9131 METAL5_314000_2653000 METAL5_314000_2665000 0.048
R_VDD3_9132 METAL5_314000_2665000 METAL5_314000_2677000 0.048
R_VDD3_9133 METAL5_314000_2677000 METAL5_314000_2689000 0.048
R_VDD3_9134 METAL5_314000_2689000 METAL5_314000_2701000 0.048
R_VDD3_9135 METAL5_314000_2701000 METAL5_314000_2781000 0.32
R_VDD3_9136 METAL5_314000_2781000 METAL4_314000_2781000 0.1
R_VDD3_9137 METAL4_314000_2781000 METAL4_314000_2793000 0.096
R_VDD3_9138 METAL4_314000_2793000 METAL4_314000_2805000 0.096
R_VDD3_9139 METAL4_314000_2805000 METAL5_314000_2805000 0.1
R_VDD3_9140 METAL5_314000_2805000 METAL5_324000_2805000 0.04
R_VDD3_9141 METAL5_324000_2805000 METAL5_324000_2807000 0.008
R_VDD3_9142 METAL5_324000_2807000 METAL5_324000_2941000 0.536
R_VDD3_9143 METAL5_324000_2941000 METAL5_324000_2953000 0.048
R_VDD3_9144 METAL5_324000_2953000 METAL5_324000_2965000 0.048
R_VDD3_9145 METAL5_324000_2965000 METAL5_324000_2977000 0.048
R_VDD3_9146 METAL5_324000_2977000 METAL5_324000_2989000 0.048
R_VDD3_9147 METAL5_324000_2989000 METAL5_324000_3053000 0.256
R_VDD3_9148 METAL5_324000_3053000 METAL5_324000_3065000 0.048
R_VDD3_9149 METAL5_324000_3065000 METAL5_324000_3077000 0.048
R_VDD3_9150 METAL5_324000_3077000 METAL5_324000_3153000 0.304
R_VDD3_9151 METAL5_324000_3153000 METAL5_324000_3165000 0.048
R_VDD3_9152 METAL5_324000_3165000 METAL5_324000_3177000 0.048
R_VDD3_9153 METAL5_324000_3177000 METAL5_324000_3189000 0.048
R_VDD3_9154 METAL5_324000_3189000 METAL5_324000_3253000 0.256
R_VDD3_9155 METAL5_324000_3253000 METAL5_324000_3265000 0.048
R_VDD3_9156 METAL5_324000_3265000 METAL5_324000_3277000 0.048
R_VDD3_9157 METAL5_324000_3277000 METAL5_324000_3341000 0.256
R_VDD3_9158 METAL5_324000_3341000 METAL5_324000_3353000 0.048
R_VDD3_9159 METAL5_324000_3353000 METAL5_324000_3365000 0.048
R_VDD3_9160 METAL5_324000_3365000 METAL5_314000_3365000 0.04
R_VDD3_9161 METAL5_314000_3365000 METAL6_314000_3365000 0.1
R_VDD3_9162 METAL6_314000_3365000 METAL6_314000_3377000 0.024
R_VDD3_9163 METAL6_314000_3377000 METAL6_314000_3389000 0.024
R_VDD3_9164 METAL6_314000_3389000 METAL6_314000_3401000 0.024
R_VDD3_9165 METAL6_314000_3401000 METAL6_314000_3493000 0.184
R_VDD3_9166 METAL6_314000_3493000 METAL6_314000_3507000 0.028
R_VDD3_9167 METAL6_314000_3507000 METAL6_314000_3653000 0.292
R_VDD3_9168 METAL6_314000_3653000 METAL6_314000_3665000 0.024
R_VDD3_9169 METAL6_314000_3665000 METAL6_314000_3677000 0.024
R_VDD3_9170 METAL6_314000_3677000 METAL6_314000_3753000 0.152
R_VDD3_9171 METAL6_314000_3753000 METAL6_314000_3765000 0.024
R_VDD3_9172 METAL6_314000_3765000 METAL6_314000_3777000 0.024
R_VDD3_9173 METAL6_314000_3777000 METAL6_314000_3853000 0.152
R_VDD3_9174 METAL6_314000_3853000 METAL6_314000_3865000 0.024
R_VDD3_9175 METAL6_314000_3865000 METAL6_314000_3877000 0.024
R_VDD3_9176 METAL6_314000_3877000 METAL6_314000_3941000 0.128
R_VDD3_9177 METAL6_314000_3941000 METAL6_314000_3953000 0.024
R_VDD3_9178 METAL6_314000_3953000 METAL5_314000_3953000 0.1
R_VDD3_9179 METAL5_314000_3953000 METAL5_324000_3953000 0.04
R_VDD3_9180 METAL5_324000_3953000 METAL5_324000_3965000 0.048
R_VDD3_9181 METAL5_324000_3965000 METAL5_324000_3977000 0.048
R_VDD3_9182 METAL5_324000_3977000 METAL5_324000_4041000 0.256
R_VDD3_9183 METAL5_324000_4041000 METAL5_324000_4053000 0.048
R_VDD3_9184 METAL5_324000_4053000 METAL5_324000_4065000 0.048
R_VDD3_9185 METAL5_324000_4065000 METAL5_324000_4077000 0.048
R_VDD3_9186 METAL5_324000_4077000 METAL6_324000_4077000 0.1
R_VDD3_9187 METAL6_324000_4077000 METAL6_324000_4089000 0.024
R_VDD3_9188 METAL6_324000_4089000 METAL6_324000_4193000 0.208
R_VDD3_9189 METAL6_324000_4193000 METAL6_324000_4207000 0.028
R_VDD3_9190 METAL6_324000_4207000 METAL6_324000_4353000 0.292
R_VDD3_9191 METAL6_324000_4353000 METAL6_324000_4365000 0.024
R_VDD3_9192 METAL6_324000_4365000 METAL6_324000_4377000 0.024
R_VDD3_9193 METAL6_324000_4377000 METAL6_324000_4453000 0.152
R_VDD3_9194 METAL6_324000_4453000 METAL6_324000_4465000 0.024
R_VDD3_9195 METAL6_324000_4465000 METAL6_324000_4477000 0.024
R_VDD3_9196 METAL6_324000_4477000 METAL6_324000_4553000 0.152
R_VDD3_9197 METAL6_324000_4553000 METAL6_324000_4565000 0.024
R_VDD3_9198 METAL6_324000_4565000 METAL6_324000_4577000 0.024
R_VDD3_9199 METAL6_324000_4577000 METAL6_324000_4653000 0.152
R_VDD3_9200 METAL6_324000_4653000 METAL5_324000_4653000 0.1
R_VDD3_9201 METAL5_324000_4653000 METAL5_324000_4665000 0.048
R_VDD3_9202 METAL5_324000_4665000 METAL5_324000_4677000 0.048
R_VDD3_9203 METAL5_324000_4677000 METAL6_324000_4677000 0.1
R_VDD3_9204 METAL6_324000_4677000 METAL6_324000_4729000 0.104
R_VDD3_9205 METAL6_324000_4729000 METAL6_324000_4741000 0.024
R_VDD3_9206 METAL6_324000_4741000 METAL6_324000_4753000 0.024
R_VDD3_9207 METAL6_324000_4753000 METAL6_324000_4765000 0.024
R_VDD3_9208 METAL6_324000_4765000 METAL6_324000_4777000 0.024
R_VDD3_9209 METAL6_324000_4777000 METAL6_324000_4893000 0.232
R_VDD3_9210 METAL6_324000_4893000 METAL6_324000_4907000 0.028
R_VDD3_9211 METAL6_324000_4907000 METAL6_324000_5053000 0.292
R_VDD3_9212 METAL6_324000_5053000 METAL6_324000_5065000 0.024
R_VDD3_9213 METAL6_324000_5065000 METAL6_324000_5077000 0.024
R_VDD3_9214 METAL6_324000_5077000 METAL6_324000_5153000 0.152
R_VDD3_9215 METAL6_324000_5153000 METAL6_324000_5165000 0.024
R_VDD3_9216 METAL6_324000_5165000 METAL6_324000_5177000 0.024
R_VDD3_9217 METAL6_324000_5177000 METAL6_324000_5253000 0.152
R_VDD3_9218 METAL6_324000_5253000 METAL6_324000_5265000 0.024
R_VDD3_9219 METAL6_324000_5265000 METAL6_324000_5277000 0.024
R_VDD3_9220 METAL6_324000_5277000 METAL6_324000_5353000 0.152
R_VDD3_9221 METAL6_324000_5353000 METAL5_324000_5353000 0.1
R_VDD3_9222 METAL5_324000_5353000 METAL5_324000_5365000 0.048
R_VDD3_9223 METAL5_324000_5365000 METAL5_324000_5377000 0.048
R_VDD3_9224 METAL5_324000_5377000 METAL5_324000_5429000 0.208
R_VDD3_9225 METAL5_324000_5429000 METAL5_324000_5441000 0.048
R_VDD3_9226 METAL5_324000_5441000 METAL5_324000_5453000 0.048
R_VDD3_9227 METAL5_324000_5453000 METAL5_324000_5465000 0.048
R_VDD3_9228 METAL5_324000_5465000 METAL5_324000_5477000 0.048
R_VDD3_9229 METAL5_324000_5477000 METAL6_324000_5477000 0.1
R_VDD3_9230 METAL6_324000_5477000 METAL6_324000_5489000 0.024
R_VDD3_9231 METAL6_324000_5489000 METAL6_324000_5593000 0.208
R_VDD3_9232 METAL6_324000_5593000 METAL6_324000_5607000 0.028
R_VDD3_9233 METAL6_324000_5607000 METAL6_324000_5753000 0.292
R_VDD3_9234 METAL6_324000_5753000 METAL6_324000_5765000 0.024
R_VDD3_9235 METAL6_324000_5765000 METAL6_324000_5777000 0.024
R_VDD3_9236 METAL6_324000_5777000 METAL6_324000_5853000 0.152
R_VDD3_9237 METAL6_324000_5853000 METAL6_324000_5865000 0.024
R_VDD3_9238 METAL6_324000_5865000 METAL6_324000_5877000 0.024
R_VDD3_9239 METAL6_324000_5877000 METAL6_324000_5953000 0.152
R_VDD3_9240 METAL6_324000_5953000 METAL6_324000_5965000 0.024
R_VDD3_9241 METAL6_324000_5965000 METAL6_324000_5977000 0.024
R_VDD3_9242 METAL6_324000_5977000 METAL6_324000_6053000 0.152
R_VDD3_9243 METAL6_324000_6053000 METAL5_324000_6053000 0.1
R_VDD3_9244 METAL5_324000_6053000 METAL5_324000_6065000 0.048
R_VDD3_9245 METAL5_324000_6065000 METAL5_324000_6077000 0.048
R_VDD3_9246 METAL5_324000_6077000 METAL6_324000_6077000 0.1
R_VDD3_9247 METAL6_324000_6077000 METAL6_324000_6153000 0.152
R_VDD3_9248 METAL6_324000_6153000 METAL6_324000_6165000 0.024
R_VDD3_9249 METAL6_324000_6165000 METAL6_324000_6177000 0.024
R_VDD3_9250 METAL6_324000_6177000 METAL6_324000_6293000 0.232
R_VDD3_9251 METAL6_324000_6293000 METAL6_324000_6307000 0.028
R_VDD3_9252 METAL6_324000_6307000 METAL6_324000_6453000 0.292
R_VDD3_9253 METAL6_324000_6453000 METAL6_324000_6465000 0.024
R_VDD3_9254 METAL6_324000_6465000 METAL6_324000_6477000 0.024
R_VDD3_9255 METAL6_324000_6477000 METAL6_324000_6553000 0.152
R_VDD3_9256 METAL6_324000_6553000 METAL6_324000_6565000 0.024
R_VDD3_9257 METAL6_324000_6565000 METAL6_324000_6577000 0.024
R_VDD3_9258 METAL6_324000_6577000 METAL6_324000_6653000 0.152
R_VDD3_9259 METAL6_324000_6653000 METAL6_324000_6665000 0.024
R_VDD3_9260 METAL6_324000_6665000 METAL6_314000_6665000 0.02
R_VDD3_9261 METAL6_314000_6665000 METAL6_312000_6665000 0.004
R_VDD3_9262 METAL6_312000_6665000 METAL6_302000_6665000 0.02
R_VDD3_9263 METAL6_302000_6665000 METAL6_300000_6665000 0.004
R_VDD3_9264 METAL6_300000_6665000 METAL6_293000_6665000 0.014
R_VDD3_9265 METAL6_293000_6665000 METAL6_288000_6665000 0.01
R_VDD3_9266 METAL6_288000_6665000 METAL6_281000_6665000 0.014
R_VDD3_9267 METAL6_281000_6665000 METAL5_281000_6665000 0.1
R_VDD3_9268 METAL5_281000_6665000 METAL5_276000_6665000 0.02
R_VDD3_9269 METAL5_276000_6665000 METAL5_269000_6665000 0.028
R_VDD3_9270 METAL5_269000_6665000 METAL5_264000_6665000 0.02
R_VDD3_9271 METAL5_264000_6665000 METAL5_257000_6665000 0.028
R_VDD3_9272 METAL5_257000_6665000 METAL6_257000_6665000 0.1
R_VDD3_9273 METAL6_245000_6665000 METAL6_257000_6665000 0.024
R_VDD3_9274 METAL6_555000_6665000 METAL6_543000_6665000 0.024
R_VDD3_9275 METAL5_324000_2989000 METAL5_326000_2989000 0.008
R_VDD3_9276 METAL5_326000_2989000 METAL5_328000_2989000 0.008
R_VDD3_9277 METAL5_328000_2989000 METAL5_330000_2989000 0.008
R_VDD3_9278 METAL5_330000_2989000 METAL5_336000_2989000 0.024
R_VDD3_9279 METAL5_336000_2989000 METAL5_336000_3053000 0.256
R_VDD3_9280 METAL5_336000_3053000 METAL5_336000_3065000 0.048
R_VDD3_9281 METAL5_336000_3065000 METAL5_336000_3077000 0.048
R_VDD3_9282 METAL5_336000_3077000 METAL5_336000_3153000 0.304
R_VDD3_9283 METAL5_336000_3153000 METAL5_336000_3165000 0.048
R_VDD3_9284 METAL5_336000_3165000 METAL5_336000_3177000 0.048
R_VDD3_9285 METAL5_336000_3177000 METAL5_336000_3189000 0.048
R_VDD3_9286 METAL5_336000_3189000 METAL5_336000_3253000 0.256
R_VDD3_9287 METAL5_336000_3253000 METAL5_336000_3265000 0.048
R_VDD3_9288 METAL5_336000_3265000 METAL5_336000_3277000 0.048
R_VDD3_9289 METAL5_336000_3277000 METAL5_336000_3341000 0.256
R_VDD3_9290 METAL5_336000_3341000 METAL5_336000_3353000 0.048
R_VDD3_9291 METAL5_336000_3353000 METAL5_336000_3365000 0.048
R_VDD3_9292 METAL5_336000_3365000 METAL5_336000_3377000 0.048
R_VDD3_9293 METAL5_336000_3377000 METAL5_336000_3389000 0.048
R_VDD3_9294 METAL5_336000_3389000 METAL5_336000_3401000 0.048
R_VDD3_9295 METAL5_336000_3401000 METAL5_336000_3493000 0.368
R_VDD3_9296 METAL5_336000_3493000 METAL5_336000_3507000 0.056
R_VDD3_9297 METAL5_336000_3507000 METAL5_336000_3653000 0.584
R_VDD3_9298 METAL5_336000_3653000 METAL5_336000_3665000 0.048
R_VDD3_9299 METAL5_336000_3665000 METAL5_336000_3677000 0.048
R_VDD3_9300 METAL5_336000_3677000 METAL5_336000_3753000 0.304
R_VDD3_9301 METAL5_336000_3753000 METAL5_336000_3765000 0.048
R_VDD3_9302 METAL5_336000_3765000 METAL5_336000_3777000 0.048
R_VDD3_9303 METAL5_336000_3777000 METAL5_336000_3853000 0.304
R_VDD3_9304 METAL5_336000_3853000 METAL5_336000_3865000 0.048
R_VDD3_9305 METAL5_336000_3865000 METAL5_336000_3877000 0.048
R_VDD3_9306 METAL5_336000_3877000 METAL5_336000_3941000 0.256
R_VDD3_9307 METAL5_336000_3941000 METAL5_336000_3953000 0.048
R_VDD3_9308 METAL5_336000_3953000 METAL5_336000_3965000 0.048
R_VDD3_9309 METAL5_336000_3965000 METAL5_336000_3977000 0.048
R_VDD3_9310 METAL5_336000_3977000 METAL5_336000_4041000 0.256
R_VDD3_9311 METAL5_336000_4041000 METAL5_336000_4053000 0.048
R_VDD3_9312 METAL5_336000_4053000 METAL5_336000_4065000 0.048
R_VDD3_9313 METAL5_336000_4065000 METAL5_336000_4077000 0.048
R_VDD3_9314 METAL5_336000_4077000 METAL6_336000_4077000 0.1
R_VDD3_9315 METAL6_336000_4077000 METAL6_336000_4089000 0.024
R_VDD3_9316 METAL6_336000_4089000 METAL6_336000_4193000 0.208
R_VDD3_9317 METAL6_336000_4193000 METAL6_336000_4207000 0.028
R_VDD3_9318 METAL6_336000_4207000 METAL6_336000_4353000 0.292
R_VDD3_9319 METAL6_336000_4353000 METAL6_336000_4365000 0.024
R_VDD3_9320 METAL6_336000_4365000 METAL6_336000_4377000 0.024
R_VDD3_9321 METAL6_336000_4377000 METAL6_336000_4453000 0.152
R_VDD3_9322 METAL6_336000_4453000 METAL6_336000_4465000 0.024
R_VDD3_9323 METAL6_336000_4465000 METAL6_336000_4477000 0.024
R_VDD3_9324 METAL6_336000_4477000 METAL6_336000_4553000 0.152
R_VDD3_9325 METAL6_336000_4553000 METAL6_336000_4565000 0.024
R_VDD3_9326 METAL6_336000_4565000 METAL6_336000_4577000 0.024
R_VDD3_9327 METAL6_336000_4577000 METAL6_336000_4641000 0.128
R_VDD3_9328 METAL6_336000_4641000 METAL6_336000_4653000 0.024
R_VDD3_9329 METAL6_336000_4653000 METAL5_336000_4653000 0.1
R_VDD3_9330 METAL5_336000_4653000 METAL5_336000_4665000 0.048
R_VDD3_9331 METAL5_336000_4665000 METAL5_336000_4677000 0.048
R_VDD3_9332 METAL5_336000_4677000 METAL6_336000_4677000 0.1
R_VDD3_9333 METAL6_336000_4677000 METAL6_336000_4689000 0.024
R_VDD3_9334 METAL6_336000_4689000 METAL6_336000_4729000 0.08
R_VDD3_9335 METAL6_336000_4729000 METAL6_336000_4741000 0.024
R_VDD3_9336 METAL6_336000_4741000 METAL6_336000_4753000 0.024
R_VDD3_9337 METAL6_336000_4753000 METAL6_336000_4765000 0.024
R_VDD3_9338 METAL6_336000_4765000 METAL6_336000_4777000 0.024
R_VDD3_9339 METAL6_336000_4777000 METAL6_336000_4893000 0.232
R_VDD3_9340 METAL6_336000_4893000 METAL6_336000_4907000 0.028
R_VDD3_9341 METAL6_336000_4907000 METAL6_336000_5053000 0.292
R_VDD3_9342 METAL6_336000_5053000 METAL6_336000_5065000 0.024
R_VDD3_9343 METAL6_336000_5065000 METAL6_336000_5077000 0.024
R_VDD3_9344 METAL6_336000_5077000 METAL6_336000_5153000 0.152
R_VDD3_9345 METAL6_336000_5153000 METAL6_336000_5165000 0.024
R_VDD3_9346 METAL6_336000_5165000 METAL6_336000_5177000 0.024
R_VDD3_9347 METAL6_336000_5177000 METAL6_336000_5253000 0.152
R_VDD3_9348 METAL6_336000_5253000 METAL6_336000_5265000 0.024
R_VDD3_9349 METAL6_336000_5265000 METAL6_336000_5277000 0.024
R_VDD3_9350 METAL6_336000_5277000 METAL6_336000_5341000 0.128
R_VDD3_9351 METAL6_336000_5341000 METAL6_336000_5353000 0.024
R_VDD3_9352 METAL6_336000_5353000 METAL6_338000_5353000 0.004
R_VDD3_9353 METAL6_338000_5353000 METAL6_340000_5353000 0.004
R_VDD3_9354 METAL6_340000_5353000 METAL6_342000_5353000 0.004
R_VDD3_9355 METAL6_342000_5353000 METAL6_348000_5353000 0.012
R_VDD3_9356 METAL6_348000_5353000 METAL6_350000_5353000 0.004
R_VDD3_9357 METAL6_350000_5353000 METAL5_350000_5353000 0.1
R_VDD3_9358 METAL5_350000_5353000 METAL5_350000_5365000 0.048
R_VDD3_9359 METAL5_350000_5365000 METAL5_350000_5377000 0.048
R_VDD3_9360 METAL5_350000_5377000 METAL5_350000_5429000 0.208
R_VDD3_9361 METAL5_350000_5429000 METAL5_350000_5441000 0.048
R_VDD3_9362 METAL5_350000_5441000 METAL5_350000_5453000 0.048
R_VDD3_9363 METAL5_350000_5453000 METAL5_350000_5465000 0.048
R_VDD3_9364 METAL5_350000_5465000 METAL5_350000_5477000 0.048
R_VDD3_9365 METAL5_350000_5477000 METAL5_350000_5489000 0.048
R_VDD3_9366 METAL5_350000_5489000 METAL5_352000_5489000 0.008
R_VDD3_9367 METAL5_352000_5489000 METAL5_354000_5489000 0.008
R_VDD3_9368 METAL5_354000_5489000 METAL5_362000_5489000 0.032
R_VDD3_9369 METAL5_362000_5489000 METAL5_364000_5489000 0.008
R_VDD3_9370 METAL5_364000_5489000 METAL5_366000_5489000 0.008
R_VDD3_9371 METAL5_366000_5489000 METAL5_374000_5489000 0.032
R_VDD3_9372 METAL5_374000_5489000 METAL5_376000_5489000 0.008
R_VDD3_9373 METAL5_376000_5489000 METAL5_378000_5489000 0.008
R_VDD3_9374 METAL5_378000_5489000 METAL5_386000_5489000 0.032
R_VDD3_9375 METAL5_386000_5489000 METAL5_388000_5489000 0.008
R_VDD3_9376 METAL5_388000_5489000 METAL5_390000_5489000 0.008
R_VDD3_9377 METAL5_390000_5489000 METAL5_398000_5489000 0.032
R_VDD3_9378 METAL5_398000_5489000 METAL6_398000_5489000 0.1
R_VDD3_9379 METAL6_398000_5489000 METAL6_398000_5593000 0.208
R_VDD3_9380 METAL6_398000_5593000 METAL6_398000_5607000 0.028
R_VDD3_9381 METAL6_398000_5607000 METAL6_398000_5753000 0.292
R_VDD3_9382 METAL6_398000_5753000 METAL6_398000_5765000 0.024
R_VDD3_9383 METAL6_398000_5765000 METAL6_398000_5777000 0.024
R_VDD3_9384 METAL6_398000_5777000 METAL6_398000_5853000 0.152
R_VDD3_9385 METAL6_398000_5853000 METAL6_398000_5865000 0.024
R_VDD3_9386 METAL6_398000_5865000 METAL6_398000_5877000 0.024
R_VDD3_9387 METAL6_398000_5877000 METAL6_398000_5953000 0.152
R_VDD3_9388 METAL6_398000_5953000 METAL6_398000_5965000 0.024
R_VDD3_9389 METAL6_398000_5965000 METAL6_398000_5977000 0.024
R_VDD3_9390 METAL6_398000_5977000 METAL6_398000_6041000 0.128
R_VDD3_9391 METAL6_398000_6041000 METAL6_398000_6053000 0.024
R_VDD3_9392 METAL6_398000_6053000 METAL6_398000_6065000 0.024
R_VDD3_9393 METAL6_398000_6065000 METAL6_398000_6077000 0.024
R_VDD3_9394 METAL6_398000_6077000 METAL6_398000_6089000 0.024
R_VDD3_9395 METAL6_398000_6089000 METAL6_398000_6153000 0.128
R_VDD3_9396 METAL6_398000_6153000 METAL6_398000_6165000 0.024
R_VDD3_9397 METAL6_398000_6165000 METAL6_398000_6177000 0.024
R_VDD3_9398 METAL6_398000_6177000 METAL6_398000_6293000 0.232
R_VDD3_9399 METAL6_398000_6293000 METAL6_398000_6307000 0.028
R_VDD3_9400 METAL6_398000_6307000 METAL6_398000_6453000 0.292
R_VDD3_9401 METAL6_398000_6453000 METAL6_398000_6465000 0.024
R_VDD3_9402 METAL6_398000_6465000 METAL6_398000_6477000 0.024
R_VDD3_9403 METAL6_398000_6477000 METAL6_398000_6553000 0.152
R_VDD3_9404 METAL6_398000_6553000 METAL6_398000_6565000 0.024
R_VDD3_9405 METAL6_398000_6565000 METAL6_398000_6577000 0.024
R_VDD3_9406 METAL6_398000_6577000 METAL6_398000_6653000 0.152
R_VDD3_9407 METAL6_398000_6653000 METAL6_398000_6665000 0.024
R_VDD3_9408 METAL6_398000_6665000 METAL6_400000_6665000 0.004
R_VDD3_9409 METAL6_400000_6665000 METAL6_402000_6665000 0.004
R_VDD3_9410 METAL6_402000_6665000 METAL6_410000_6665000 0.016
R_VDD3_9411 METAL6_410000_6665000 METAL6_412000_6665000 0.004
R_VDD3_9412 METAL6_412000_6665000 METAL6_414000_6665000 0.004
R_VDD3_9413 METAL6_414000_6665000 METAL6_422000_6665000 0.016
R_VDD3_9414 METAL6_422000_6665000 METAL6_424000_6665000 0.004
R_VDD3_9415 METAL6_424000_6665000 METAL6_426000_6665000 0.004
R_VDD3_9416 METAL6_426000_6665000 METAL6_434000_6665000 0.016
R_VDD3_9417 METAL6_434000_6665000 METAL6_436000_6665000 0.004
R_VDD3_9418 METAL6_436000_6665000 METAL6_438000_6665000 0.004
R_VDD3_9419 METAL6_438000_6665000 METAL6_440000_6665000 0.004
R_VDD3_9420 METAL6_440000_6665000 METAL6_448000_6665000 0.016
R_VDD3_9421 METAL6_448000_6665000 METAL6_450000_6665000 0.004
R_VDD3_9422 METAL6_450000_6665000 METAL6_452000_6665000 0.004
R_VDD3_9423 METAL6_452000_6665000 METAL6_460000_6665000 0.016
R_VDD3_9424 METAL6_460000_6665000 METAL6_462000_6665000 0.004
R_VDD3_9425 METAL6_462000_6665000 METAL6_464000_6665000 0.004
R_VDD3_9426 METAL6_464000_6665000 METAL6_472000_6665000 0.016
R_VDD3_9427 METAL6_472000_6665000 METAL6_474000_6665000 0.004
R_VDD3_9428 METAL6_474000_6665000 METAL6_476000_6665000 0.004
R_VDD3_9429 METAL6_476000_6665000 METAL6_484000_6665000 0.016
R_VDD3_9430 METAL6_484000_6665000 METAL6_486000_6665000 0.004
R_VDD3_9431 METAL6_486000_6665000 METAL6_488000_6665000 0.004
R_VDD3_9432 METAL6_488000_6665000 METAL6_500000_6665000 0.024
R_VDD3_9433 METAL6_500000_6665000 METAL6_507000_6665000 0.014
R_VDD3_9434 METAL6_507000_6665000 METAL6_512000_6665000 0.01
R_VDD3_9435 METAL6_512000_6665000 METAL6_519000_6665000 0.014
R_VDD3_9436 METAL6_519000_6665000 METAL5_519000_6665000 0.1
R_VDD3_9437 METAL5_519000_6665000 METAL5_524000_6665000 0.02
R_VDD3_9438 METAL5_524000_6665000 METAL5_531000_6665000 0.028
R_VDD3_9439 METAL5_531000_6665000 METAL5_543000_6665000 0.048
R_VDD3_9440 METAL5_543000_6665000 METAL6_543000_6665000 0.1
R_VDD3_9441 METAL6_245000_5965000 METAL6_257000_5965000 0.024
R_VDD3_9442 METAL5_336000_3177000 METAL5_338000_3177000 0.008
R_VDD3_9443 METAL5_338000_3177000 METAL5_340000_3177000 0.008
R_VDD3_9444 METAL5_340000_3177000 METAL5_342000_3177000 0.008
R_VDD3_9445 METAL5_342000_3177000 METAL5_348000_3177000 0.024
R_VDD3_9446 METAL5_348000_3177000 METAL5_348000_3189000 0.048
R_VDD3_9447 METAL5_348000_3189000 METAL5_348000_3253000 0.256
R_VDD3_9448 METAL5_348000_3253000 METAL5_348000_3265000 0.048
R_VDD3_9449 METAL5_348000_3265000 METAL5_348000_3277000 0.048
R_VDD3_9450 METAL5_348000_3277000 METAL5_348000_3341000 0.256
R_VDD3_9451 METAL5_348000_3341000 METAL5_348000_3353000 0.048
R_VDD3_9452 METAL5_348000_3353000 METAL5_348000_3365000 0.048
R_VDD3_9453 METAL5_348000_3365000 METAL5_348000_3377000 0.048
R_VDD3_9454 METAL5_348000_3377000 METAL5_348000_3389000 0.048
R_VDD3_9455 METAL5_348000_3389000 METAL5_348000_3401000 0.048
R_VDD3_9456 METAL5_348000_3401000 METAL5_348000_3493000 0.368
R_VDD3_9457 METAL5_348000_3493000 METAL5_348000_3507000 0.056
R_VDD3_9458 METAL5_348000_3507000 METAL5_348000_3653000 0.584
R_VDD3_9459 METAL5_348000_3653000 METAL5_348000_3665000 0.048
R_VDD3_9460 METAL5_348000_3665000 METAL5_348000_3677000 0.048
R_VDD3_9461 METAL5_348000_3677000 METAL5_348000_3753000 0.304
R_VDD3_9462 METAL5_348000_3753000 METAL5_348000_3765000 0.048
R_VDD3_9463 METAL5_348000_3765000 METAL5_348000_3777000 0.048
R_VDD3_9464 METAL5_348000_3777000 METAL5_348000_3853000 0.304
R_VDD3_9465 METAL5_348000_3853000 METAL5_348000_3865000 0.048
R_VDD3_9466 METAL5_348000_3865000 METAL5_348000_3877000 0.048
R_VDD3_9467 METAL5_348000_3877000 METAL5_348000_3941000 0.256
R_VDD3_9468 METAL5_348000_3941000 METAL5_348000_3953000 0.048
R_VDD3_9469 METAL5_348000_3953000 METAL5_348000_3965000 0.048
R_VDD3_9470 METAL5_348000_3965000 METAL5_348000_3977000 0.048
R_VDD3_9471 METAL5_348000_3977000 METAL5_348000_4041000 0.256
R_VDD3_9472 METAL5_348000_4041000 METAL5_348000_4053000 0.048
R_VDD3_9473 METAL5_348000_4053000 METAL5_348000_4065000 0.048
R_VDD3_9474 METAL5_348000_4065000 METAL5_348000_4077000 0.048
R_VDD3_9475 METAL5_348000_4077000 METAL5_348000_4089000 0.048
R_VDD3_9476 METAL5_348000_4089000 METAL5_342000_4089000 0.024
R_VDD3_9477 METAL5_342000_4089000 METAL5_340000_4089000 0.008
R_VDD3_9478 METAL5_340000_4089000 METAL5_338000_4089000 0.008
R_VDD3_9479 METAL5_338000_4089000 METAL5_336000_4089000 0.008
R_VDD3_9480 METAL5_336000_4089000 METAL5_330000_4089000 0.024
R_VDD3_9481 METAL5_330000_4089000 METAL5_328000_4089000 0.008
R_VDD3_9482 METAL5_328000_4089000 METAL5_326000_4089000 0.008
R_VDD3_9483 METAL5_326000_4089000 METAL5_324000_4089000 0.008
R_VDD3_9484 METAL5_324000_4089000 METAL5_318000_4089000 0.024
R_VDD3_9485 METAL5_318000_4089000 METAL5_314000_4089000 0.016
R_VDD3_9486 METAL5_314000_4089000 METAL5_312000_4089000 0.008
R_VDD3_9487 METAL5_312000_4089000 METAL6_312000_4089000 0.1
R_VDD3_9488 METAL6_312000_4089000 METAL6_312000_4193000 0.208
R_VDD3_9489 METAL6_312000_4193000 METAL6_312000_4207000 0.028
R_VDD3_9490 METAL6_312000_4207000 METAL6_312000_4353000 0.292
R_VDD3_9491 METAL6_312000_4353000 METAL6_312000_4365000 0.024
R_VDD3_9492 METAL6_312000_4365000 METAL6_312000_4377000 0.024
R_VDD3_9493 METAL6_312000_4377000 METAL6_312000_4453000 0.152
R_VDD3_9494 METAL6_312000_4453000 METAL6_312000_4465000 0.024
R_VDD3_9495 METAL6_312000_4465000 METAL6_312000_4477000 0.024
R_VDD3_9496 METAL6_312000_4477000 METAL6_312000_4553000 0.152
R_VDD3_9497 METAL6_312000_4553000 METAL6_312000_4565000 0.024
R_VDD3_9498 METAL6_312000_4565000 METAL6_312000_4577000 0.024
R_VDD3_9499 METAL6_312000_4577000 METAL6_312000_4641000 0.128
R_VDD3_9500 METAL6_312000_4641000 METAL5_312000_4641000 0.1
R_VDD3_9501 METAL5_312000_4641000 METAL5_314000_4641000 0.008
R_VDD3_9502 METAL5_314000_4641000 METAL5_318000_4641000 0.016
R_VDD3_9503 METAL5_318000_4641000 METAL5_324000_4641000 0.024
R_VDD3_9504 METAL5_324000_4641000 METAL5_326000_4641000 0.008
R_VDD3_9505 METAL5_326000_4641000 METAL5_328000_4641000 0.008
R_VDD3_9506 METAL5_328000_4641000 METAL5_330000_4641000 0.008
R_VDD3_9507 METAL5_330000_4641000 METAL5_336000_4641000 0.024
R_VDD3_9508 METAL5_336000_4641000 METAL5_338000_4641000 0.008
R_VDD3_9509 METAL5_338000_4641000 METAL5_340000_4641000 0.008
R_VDD3_9510 METAL5_340000_4641000 METAL5_342000_4641000 0.008
R_VDD3_9511 METAL5_342000_4641000 METAL5_348000_4641000 0.024
R_VDD3_9512 METAL5_348000_4641000 METAL5_348000_4653000 0.048
R_VDD3_9513 METAL5_348000_4653000 METAL5_348000_4665000 0.048
R_VDD3_9514 METAL5_348000_4665000 METAL5_348000_4677000 0.048
R_VDD3_9515 METAL5_348000_4677000 METAL6_348000_4677000 0.1
R_VDD3_9516 METAL6_348000_4677000 METAL6_348000_4689000 0.024
R_VDD3_9517 METAL6_348000_4689000 METAL6_348000_4729000 0.08
R_VDD3_9518 METAL6_348000_4729000 METAL6_348000_4741000 0.024
R_VDD3_9519 METAL6_348000_4741000 METAL6_348000_4753000 0.024
R_VDD3_9520 METAL6_348000_4753000 METAL6_348000_4765000 0.024
R_VDD3_9521 METAL6_348000_4765000 METAL6_348000_4777000 0.024
R_VDD3_9522 METAL6_348000_4777000 METAL6_348000_4893000 0.232
R_VDD3_9523 METAL6_348000_4893000 METAL6_348000_4907000 0.028
R_VDD3_9524 METAL6_348000_4907000 METAL6_348000_5053000 0.292
R_VDD3_9525 METAL6_348000_5053000 METAL6_348000_5065000 0.024
R_VDD3_9526 METAL6_348000_5065000 METAL6_348000_5077000 0.024
R_VDD3_9527 METAL6_348000_5077000 METAL6_348000_5153000 0.152
R_VDD3_9528 METAL6_348000_5153000 METAL6_348000_5165000 0.024
R_VDD3_9529 METAL6_348000_5165000 METAL6_348000_5177000 0.024
R_VDD3_9530 METAL6_348000_5177000 METAL6_348000_5253000 0.152
R_VDD3_9531 METAL6_348000_5253000 METAL6_348000_5265000 0.024
R_VDD3_9532 METAL6_348000_5265000 METAL6_348000_5277000 0.024
R_VDD3_9533 METAL6_348000_5277000 METAL6_348000_5341000 0.128
R_VDD3_9534 METAL6_348000_5341000 METAL5_348000_5341000 0.1
R_VDD3_9535 METAL5_348000_5341000 METAL5_342000_5341000 0.024
R_VDD3_9536 METAL5_342000_5341000 METAL5_340000_5341000 0.008
R_VDD3_9537 METAL5_340000_5341000 METAL5_338000_5341000 0.008
R_VDD3_9538 METAL5_338000_5341000 METAL5_338000_5353000 0.048
R_VDD3_9539 METAL5_338000_5353000 METAL5_338000_5365000 0.048
R_VDD3_9540 METAL5_338000_5365000 METAL5_338000_5377000 0.048
R_VDD3_9541 METAL5_338000_5377000 METAL6_338000_5377000 0.1
R_VDD3_9542 METAL6_338000_5377000 METAL6_338000_5429000 0.104
R_VDD3_9543 METAL6_338000_5429000 METAL6_338000_5441000 0.024
R_VDD3_9544 METAL6_338000_5441000 METAL6_338000_5453000 0.024
R_VDD3_9545 METAL6_338000_5453000 METAL6_336000_5453000 0.004
R_VDD3_9546 METAL6_336000_5453000 METAL6_330000_5453000 0.012
R_VDD3_9547 METAL6_330000_5453000 METAL6_328000_5453000 0.004
R_VDD3_9548 METAL6_328000_5453000 METAL6_326000_5453000 0.004
R_VDD3_9549 METAL6_326000_5453000 METAL6_324000_5453000 0.004
R_VDD3_9550 METAL6_324000_5453000 METAL6_318000_5453000 0.012
R_VDD3_9551 METAL6_318000_5453000 METAL6_314000_5453000 0.008
R_VDD3_9552 METAL6_314000_5453000 METAL6_312000_5453000 0.004
R_VDD3_9553 METAL6_312000_5453000 METAL5_312000_5453000 0.1
R_VDD3_9554 METAL5_312000_5453000 METAL5_312000_5465000 0.048
R_VDD3_9555 METAL5_312000_5465000 METAL5_312000_5477000 0.048
R_VDD3_9556 METAL5_312000_5477000 METAL6_312000_5477000 0.1
R_VDD3_9557 METAL6_312000_5477000 METAL6_312000_5489000 0.024
R_VDD3_9558 METAL6_312000_5489000 METAL6_312000_5501000 0.024
R_VDD3_9559 METAL6_312000_5501000 METAL6_312000_5593000 0.184
R_VDD3_9560 METAL6_312000_5593000 METAL6_312000_5607000 0.028
R_VDD3_9561 METAL6_312000_5607000 METAL6_312000_5753000 0.292
R_VDD3_9562 METAL6_312000_5753000 METAL6_312000_5765000 0.024
R_VDD3_9563 METAL6_312000_5765000 METAL6_312000_5777000 0.024
R_VDD3_9564 METAL6_312000_5777000 METAL6_312000_5853000 0.152
R_VDD3_9565 METAL6_312000_5853000 METAL6_312000_5865000 0.024
R_VDD3_9566 METAL6_312000_5865000 METAL6_312000_5877000 0.024
R_VDD3_9567 METAL6_312000_5877000 METAL6_312000_5953000 0.152
R_VDD3_9568 METAL6_312000_5953000 METAL6_312000_5965000 0.024
R_VDD3_9569 METAL6_312000_5965000 METAL6_305000_5965000 0.014
R_VDD3_9570 METAL6_305000_5965000 METAL6_302000_5965000 0.006
R_VDD3_9571 METAL6_302000_5965000 METAL6_300000_5965000 0.004
R_VDD3_9572 METAL6_300000_5965000 METAL5_300000_5965000 0.1
R_VDD3_9573 METAL5_300000_5965000 METAL5_293000_5965000 0.028
R_VDD3_9574 METAL5_293000_5965000 METAL5_288000_5965000 0.02
R_VDD3_9575 METAL5_288000_5965000 METAL5_281000_5965000 0.028
R_VDD3_9576 METAL5_281000_5965000 METAL5_276000_5965000 0.02
R_VDD3_9577 METAL5_276000_5965000 METAL5_269000_5965000 0.028
R_VDD3_9578 METAL5_269000_5965000 METAL5_264000_5965000 0.02
R_VDD3_9579 METAL5_264000_5965000 METAL5_257000_5965000 0.028
R_VDD3_9580 METAL5_257000_5965000 METAL6_257000_5965000 0.1
R_VDD3_9581 METAL6_555000_5965000 METAL6_543000_5965000 0.024
R_VDD3_9582 METAL5_348000_3277000 METAL5_350000_3277000 0.008
R_VDD3_9583 METAL5_350000_3277000 METAL5_352000_3277000 0.008
R_VDD3_9584 METAL5_352000_3277000 METAL5_354000_3277000 0.008
R_VDD3_9585 METAL5_354000_3277000 METAL5_360000_3277000 0.024
R_VDD3_9586 METAL5_360000_3277000 METAL5_360000_3341000 0.256
R_VDD3_9587 METAL5_360000_3341000 METAL5_360000_3353000 0.048
R_VDD3_9588 METAL5_360000_3353000 METAL5_360000_3365000 0.048
R_VDD3_9589 METAL5_360000_3365000 METAL5_360000_3377000 0.048
R_VDD3_9590 METAL5_360000_3377000 METAL5_360000_3389000 0.048
R_VDD3_9591 METAL5_360000_3389000 METAL5_360000_3401000 0.048
R_VDD3_9592 METAL5_360000_3401000 METAL5_360000_3493000 0.368
R_VDD3_9593 METAL5_360000_3493000 METAL5_360000_3507000 0.056
R_VDD3_9594 METAL5_360000_3507000 METAL5_360000_3653000 0.584
R_VDD3_9595 METAL5_360000_3653000 METAL5_360000_3665000 0.048
R_VDD3_9596 METAL5_360000_3665000 METAL5_360000_3677000 0.048
R_VDD3_9597 METAL5_360000_3677000 METAL5_360000_3753000 0.304
R_VDD3_9598 METAL5_360000_3753000 METAL5_360000_3765000 0.048
R_VDD3_9599 METAL5_360000_3765000 METAL5_360000_3777000 0.048
R_VDD3_9600 METAL5_360000_3777000 METAL5_360000_3853000 0.304
R_VDD3_9601 METAL5_360000_3853000 METAL5_360000_3865000 0.048
R_VDD3_9602 METAL5_360000_3865000 METAL5_360000_3877000 0.048
R_VDD3_9603 METAL5_360000_3877000 METAL5_360000_3941000 0.256
R_VDD3_9604 METAL5_360000_3941000 METAL5_360000_3953000 0.048
R_VDD3_9605 METAL5_360000_3953000 METAL5_360000_3965000 0.048
R_VDD3_9606 METAL5_360000_3965000 METAL5_360000_3977000 0.048
R_VDD3_9607 METAL5_360000_3977000 METAL5_360000_4041000 0.256
R_VDD3_9608 METAL5_360000_4041000 METAL5_360000_4053000 0.048
R_VDD3_9609 METAL5_360000_4053000 METAL5_360000_4065000 0.048
R_VDD3_9610 METAL5_360000_4065000 METAL5_360000_4077000 0.048
R_VDD3_9611 METAL5_360000_4077000 METAL5_362000_4077000 0.008
R_VDD3_9612 METAL5_362000_4077000 METAL5_364000_4077000 0.008
R_VDD3_9613 METAL5_364000_4077000 METAL5_366000_4077000 0.008
R_VDD3_9614 METAL5_366000_4077000 METAL5_374000_4077000 0.032
R_VDD3_9615 METAL5_374000_4077000 METAL5_376000_4077000 0.008
R_VDD3_9616 METAL5_376000_4077000 METAL5_378000_4077000 0.008
R_VDD3_9617 METAL5_378000_4077000 METAL5_386000_4077000 0.032
R_VDD3_9618 METAL5_386000_4077000 METAL5_388000_4077000 0.008
R_VDD3_9619 METAL5_388000_4077000 METAL5_390000_4077000 0.008
R_VDD3_9620 METAL5_390000_4077000 METAL5_398000_4077000 0.032
R_VDD3_9621 METAL5_398000_4077000 METAL5_400000_4077000 0.008
R_VDD3_9622 METAL5_400000_4077000 METAL5_402000_4077000 0.008
R_VDD3_9623 METAL5_402000_4077000 METAL5_410000_4077000 0.032
R_VDD3_9624 METAL5_410000_4077000 METAL5_412000_4077000 0.008
R_VDD3_9625 METAL5_412000_4077000 METAL5_414000_4077000 0.008
R_VDD3_9626 METAL5_414000_4077000 METAL5_422000_4077000 0.032
R_VDD3_9627 METAL5_422000_4077000 METAL5_424000_4077000 0.008
R_VDD3_9628 METAL5_424000_4077000 METAL5_426000_4077000 0.008
R_VDD3_9629 METAL5_426000_4077000 METAL5_434000_4077000 0.032
R_VDD3_9630 METAL5_434000_4077000 METAL6_434000_4077000 0.1
R_VDD3_9631 METAL6_434000_4077000 METAL6_434000_4089000 0.024
R_VDD3_9632 METAL6_434000_4089000 METAL6_434000_4101000 0.024
R_VDD3_9633 METAL6_434000_4101000 METAL6_434000_4193000 0.184
R_VDD3_9634 METAL6_434000_4193000 METAL6_434000_4207000 0.028
R_VDD3_9635 METAL6_434000_4207000 METAL6_434000_4353000 0.292
R_VDD3_9636 METAL6_434000_4353000 METAL6_434000_4365000 0.024
R_VDD3_9637 METAL6_434000_4365000 METAL6_434000_4377000 0.024
R_VDD3_9638 METAL6_434000_4377000 METAL6_434000_4453000 0.152
R_VDD3_9639 METAL6_434000_4453000 METAL6_434000_4465000 0.024
R_VDD3_9640 METAL6_434000_4465000 METAL6_434000_4477000 0.024
R_VDD3_9641 METAL6_434000_4477000 METAL6_434000_4553000 0.152
R_VDD3_9642 METAL6_434000_4553000 METAL6_434000_4565000 0.024
R_VDD3_9643 METAL6_434000_4565000 METAL6_434000_4577000 0.024
R_VDD3_9644 METAL6_434000_4577000 METAL6_434000_4629000 0.104
R_VDD3_9645 METAL6_434000_4629000 METAL6_434000_4641000 0.024
R_VDD3_9646 METAL6_434000_4641000 METAL6_434000_4653000 0.024
R_VDD3_9647 METAL6_434000_4653000 METAL6_434000_4665000 0.024
R_VDD3_9648 METAL6_434000_4665000 METAL6_434000_4677000 0.024
R_VDD3_9649 METAL6_434000_4677000 METAL6_434000_4689000 0.024
R_VDD3_9650 METAL6_434000_4689000 METAL6_434000_4729000 0.08
R_VDD3_9651 METAL6_434000_4729000 METAL6_434000_4741000 0.024
R_VDD3_9652 METAL6_434000_4741000 METAL6_434000_4753000 0.024
R_VDD3_9653 METAL6_434000_4753000 METAL6_434000_4765000 0.024
R_VDD3_9654 METAL6_434000_4765000 METAL6_434000_4777000 0.024
R_VDD3_9655 METAL6_434000_4777000 METAL6_434000_4893000 0.232
R_VDD3_9656 METAL6_434000_4893000 METAL6_434000_4907000 0.028
R_VDD3_9657 METAL6_434000_4907000 METAL6_434000_5053000 0.292
R_VDD3_9658 METAL6_434000_5053000 METAL6_434000_5065000 0.024
R_VDD3_9659 METAL6_434000_5065000 METAL6_434000_5077000 0.024
R_VDD3_9660 METAL6_434000_5077000 METAL6_434000_5153000 0.152
R_VDD3_9661 METAL6_434000_5153000 METAL6_434000_5165000 0.024
R_VDD3_9662 METAL6_434000_5165000 METAL6_434000_5177000 0.024
R_VDD3_9663 METAL6_434000_5177000 METAL6_434000_5253000 0.152
R_VDD3_9664 METAL6_434000_5253000 METAL6_434000_5265000 0.024
R_VDD3_9665 METAL6_434000_5265000 METAL6_434000_5277000 0.024
R_VDD3_9666 METAL6_434000_5277000 METAL6_434000_5329000 0.104
R_VDD3_9667 METAL6_434000_5329000 METAL6_434000_5341000 0.024
R_VDD3_9668 METAL6_434000_5341000 METAL6_434000_5353000 0.024
R_VDD3_9669 METAL6_434000_5353000 METAL5_434000_5353000 0.1
R_VDD3_9670 METAL5_434000_5353000 METAL5_434000_5365000 0.048
R_VDD3_9671 METAL5_434000_5365000 METAL5_434000_5377000 0.048
R_VDD3_9672 METAL5_434000_5377000 METAL5_434000_5389000 0.048
R_VDD3_9673 METAL5_434000_5389000 METAL5_434000_5429000 0.16
R_VDD3_9674 METAL5_434000_5429000 METAL5_434000_5441000 0.048
R_VDD3_9675 METAL5_434000_5441000 METAL5_434000_5453000 0.048
R_VDD3_9676 METAL5_434000_5453000 METAL5_434000_5465000 0.048
R_VDD3_9677 METAL5_434000_5465000 METAL5_434000_5477000 0.048
R_VDD3_9678 METAL5_434000_5477000 METAL6_434000_5477000 0.1
R_VDD3_9679 METAL6_434000_5477000 METAL6_434000_5489000 0.024
R_VDD3_9680 METAL6_434000_5489000 METAL6_434000_5501000 0.024
R_VDD3_9681 METAL6_434000_5501000 METAL6_434000_5593000 0.184
R_VDD3_9682 METAL6_434000_5593000 METAL6_434000_5607000 0.028
R_VDD3_9683 METAL6_434000_5607000 METAL6_434000_5753000 0.292
R_VDD3_9684 METAL6_434000_5753000 METAL6_434000_5765000 0.024
R_VDD3_9685 METAL6_434000_5765000 METAL6_434000_5777000 0.024
R_VDD3_9686 METAL6_434000_5777000 METAL6_434000_5853000 0.152
R_VDD3_9687 METAL6_434000_5853000 METAL6_434000_5865000 0.024
R_VDD3_9688 METAL6_434000_5865000 METAL6_434000_5877000 0.024
R_VDD3_9689 METAL6_434000_5877000 METAL6_434000_5953000 0.152
R_VDD3_9690 METAL6_434000_5953000 METAL6_434000_5965000 0.024
R_VDD3_9691 METAL6_434000_5965000 METAL6_436000_5965000 0.004
R_VDD3_9692 METAL6_436000_5965000 METAL6_438000_5965000 0.004
R_VDD3_9693 METAL6_438000_5965000 METAL6_440000_5965000 0.004
R_VDD3_9694 METAL6_440000_5965000 METAL6_448000_5965000 0.016
R_VDD3_9695 METAL6_448000_5965000 METAL6_450000_5965000 0.004
R_VDD3_9696 METAL6_450000_5965000 METAL6_452000_5965000 0.004
R_VDD3_9697 METAL6_452000_5965000 METAL6_460000_5965000 0.016
R_VDD3_9698 METAL6_460000_5965000 METAL6_462000_5965000 0.004
R_VDD3_9699 METAL6_462000_5965000 METAL6_464000_5965000 0.004
R_VDD3_9700 METAL6_464000_5965000 METAL6_472000_5965000 0.016
R_VDD3_9701 METAL6_472000_5965000 METAL6_474000_5965000 0.004
R_VDD3_9702 METAL6_474000_5965000 METAL6_476000_5965000 0.004
R_VDD3_9703 METAL6_476000_5965000 METAL6_484000_5965000 0.016
R_VDD3_9704 METAL6_484000_5965000 METAL6_486000_5965000 0.004
R_VDD3_9705 METAL6_486000_5965000 METAL6_488000_5965000 0.004
R_VDD3_9706 METAL6_488000_5965000 METAL6_500000_5965000 0.024
R_VDD3_9707 METAL6_500000_5965000 METAL5_500000_5965000 0.1
R_VDD3_9708 METAL5_500000_5965000 METAL5_507000_5965000 0.028
R_VDD3_9709 METAL5_507000_5965000 METAL5_512000_5965000 0.02
R_VDD3_9710 METAL5_512000_5965000 METAL5_519000_5965000 0.028
R_VDD3_9711 METAL5_519000_5965000 METAL5_524000_5965000 0.02
R_VDD3_9712 METAL5_524000_5965000 METAL5_531000_5965000 0.028
R_VDD3_9713 METAL5_531000_5965000 METAL5_543000_5965000 0.048
R_VDD3_9714 METAL5_543000_5965000 METAL6_543000_5965000 0.1
R_VDD3_9715 METAL6_245000_5265000 METAL6_257000_5265000 0.024
R_VDD3_9716 METAL6_324000_4353000 METAL5_324000_4353000 0.1
R_VDD3_9717 METAL5_324000_4353000 METAL5_324000_4365000 0.048
R_VDD3_9718 METAL5_324000_4365000 METAL5_324000_4377000 0.048
R_VDD3_9719 METAL5_324000_4377000 METAL5_324000_4453000 0.304
R_VDD3_9720 METAL5_324000_4453000 METAL5_324000_4465000 0.048
R_VDD3_9721 METAL5_324000_4465000 METAL5_324000_4477000 0.048
R_VDD3_9722 METAL5_324000_4477000 METAL5_324000_4553000 0.304
R_VDD3_9723 METAL5_324000_4553000 METAL5_324000_4565000 0.048
R_VDD3_9724 METAL5_324000_4565000 METAL5_324000_4577000 0.048
R_VDD3_9725 METAL5_324000_4577000 METAL5_324000_4629000 0.208
R_VDD3_9726 METAL5_324000_4629000 METAL5_326000_4629000 0.008
R_VDD3_9727 METAL5_326000_4629000 METAL5_328000_4629000 0.008
R_VDD3_9728 METAL5_328000_4629000 METAL5_330000_4629000 0.008
R_VDD3_9729 METAL5_330000_4629000 METAL5_336000_4629000 0.024
R_VDD3_9730 METAL5_336000_4629000 METAL5_338000_4629000 0.008
R_VDD3_9731 METAL5_338000_4629000 METAL5_340000_4629000 0.008
R_VDD3_9732 METAL5_340000_4629000 METAL5_342000_4629000 0.008
R_VDD3_9733 METAL5_342000_4629000 METAL5_348000_4629000 0.024
R_VDD3_9734 METAL5_348000_4629000 METAL5_350000_4629000 0.008
R_VDD3_9735 METAL5_350000_4629000 METAL5_352000_4629000 0.008
R_VDD3_9736 METAL5_352000_4629000 METAL5_354000_4629000 0.008
R_VDD3_9737 METAL5_354000_4629000 METAL5_360000_4629000 0.024
R_VDD3_9738 METAL5_360000_4629000 METAL5_360000_4641000 0.048
R_VDD3_9739 METAL5_360000_4641000 METAL5_360000_4653000 0.048
R_VDD3_9740 METAL5_360000_4653000 METAL5_360000_4665000 0.048
R_VDD3_9741 METAL5_360000_4665000 METAL5_360000_4677000 0.048
R_VDD3_9742 METAL5_360000_4677000 METAL5_360000_4689000 0.048
R_VDD3_9743 METAL5_360000_4689000 METAL5_354000_4689000 0.024
R_VDD3_9744 METAL5_354000_4689000 METAL5_352000_4689000 0.008
R_VDD3_9745 METAL5_352000_4689000 METAL5_350000_4689000 0.008
R_VDD3_9746 METAL5_350000_4689000 METAL5_348000_4689000 0.008
R_VDD3_9747 METAL5_348000_4689000 METAL5_342000_4689000 0.024
R_VDD3_9748 METAL5_342000_4689000 METAL5_340000_4689000 0.008
R_VDD3_9749 METAL5_340000_4689000 METAL5_338000_4689000 0.008
R_VDD3_9750 METAL5_338000_4689000 METAL5_336000_4689000 0.008
R_VDD3_9751 METAL5_336000_4689000 METAL5_330000_4689000 0.024
R_VDD3_9752 METAL5_330000_4689000 METAL5_328000_4689000 0.008
R_VDD3_9753 METAL5_328000_4689000 METAL5_326000_4689000 0.008
R_VDD3_9754 METAL5_326000_4689000 METAL5_324000_4689000 0.008
R_VDD3_9755 METAL5_324000_4689000 METAL5_318000_4689000 0.024
R_VDD3_9756 METAL5_318000_4689000 METAL5_314000_4689000 0.016
R_VDD3_9757 METAL5_314000_4689000 METAL5_312000_4689000 0.008
R_VDD3_9758 METAL5_312000_4689000 METAL6_312000_4689000 0.1
R_VDD3_9759 METAL6_312000_4689000 METAL6_312000_4729000 0.08
R_VDD3_9760 METAL6_312000_4729000 METAL6_312000_4741000 0.024
R_VDD3_9761 METAL6_312000_4741000 METAL6_312000_4753000 0.024
R_VDD3_9762 METAL6_312000_4753000 METAL6_312000_4765000 0.024
R_VDD3_9763 METAL6_312000_4765000 METAL6_312000_4777000 0.024
R_VDD3_9764 METAL6_312000_4777000 METAL6_312000_4893000 0.232
R_VDD3_9765 METAL6_312000_4893000 METAL6_312000_4907000 0.028
R_VDD3_9766 METAL6_312000_4907000 METAL6_312000_5053000 0.292
R_VDD3_9767 METAL6_312000_5053000 METAL6_312000_5065000 0.024
R_VDD3_9768 METAL6_312000_5065000 METAL6_312000_5077000 0.024
R_VDD3_9769 METAL6_312000_5077000 METAL6_312000_5153000 0.152
R_VDD3_9770 METAL6_312000_5153000 METAL6_312000_5165000 0.024
R_VDD3_9771 METAL6_312000_5165000 METAL6_312000_5177000 0.024
R_VDD3_9772 METAL6_312000_5177000 METAL6_312000_5253000 0.152
R_VDD3_9773 METAL6_312000_5253000 METAL6_312000_5265000 0.024
R_VDD3_9774 METAL6_312000_5265000 METAL6_305000_5265000 0.014
R_VDD3_9775 METAL6_305000_5265000 METAL6_302000_5265000 0.006
R_VDD3_9776 METAL6_302000_5265000 METAL6_300000_5265000 0.004
R_VDD3_9777 METAL6_300000_5265000 METAL5_300000_5265000 0.1
R_VDD3_9778 METAL5_300000_5265000 METAL5_293000_5265000 0.028
R_VDD3_9779 METAL5_293000_5265000 METAL5_288000_5265000 0.02
R_VDD3_9780 METAL5_288000_5265000 METAL5_281000_5265000 0.028
R_VDD3_9781 METAL5_281000_5265000 METAL5_276000_5265000 0.02
R_VDD3_9782 METAL5_276000_5265000 METAL5_269000_5265000 0.028
R_VDD3_9783 METAL5_269000_5265000 METAL5_264000_5265000 0.02
R_VDD3_9784 METAL5_264000_5265000 METAL5_257000_5265000 0.028
R_VDD3_9785 METAL5_257000_5265000 METAL6_257000_5265000 0.1
R_VDD3_9786 METAL6_555000_5265000 METAL6_543000_5265000 0.024
R_VDD3_9787 METAL6_336000_4193000 METAL5_336000_4193000 0.1
R_VDD3_9788 METAL5_336000_4193000 METAL5_338000_4193000 0.008
R_VDD3_9789 METAL5_338000_4193000 METAL5_340000_4193000 0.008
R_VDD3_9790 METAL5_340000_4193000 METAL5_342000_4193000 0.008
R_VDD3_9791 METAL5_342000_4193000 METAL5_348000_4193000 0.024
R_VDD3_9792 METAL5_348000_4193000 METAL5_350000_4193000 0.008
R_VDD3_9793 METAL5_350000_4193000 METAL5_352000_4193000 0.008
R_VDD3_9794 METAL5_352000_4193000 METAL5_354000_4193000 0.008
R_VDD3_9795 METAL5_354000_4193000 METAL5_360000_4193000 0.024
R_VDD3_9796 METAL5_360000_4193000 METAL5_362000_4193000 0.008
R_VDD3_9797 METAL5_362000_4193000 METAL5_364000_4193000 0.008
R_VDD3_9798 METAL5_364000_4193000 METAL5_366000_4193000 0.008
R_VDD3_9799 METAL5_366000_4193000 METAL5_372000_4193000 0.024
R_VDD3_9800 METAL5_372000_4193000 METAL5_374000_4193000 0.008
R_VDD3_9801 METAL5_374000_4193000 METAL5_376000_4193000 0.008
R_VDD3_9802 METAL5_376000_4193000 METAL5_378000_4193000 0.008
R_VDD3_9803 METAL5_378000_4193000 METAL5_386000_4193000 0.032
R_VDD3_9804 METAL5_386000_4193000 METAL5_388000_4193000 0.008
R_VDD3_9805 METAL5_388000_4193000 METAL5_390000_4193000 0.008
R_VDD3_9806 METAL5_390000_4193000 METAL5_398000_4193000 0.032
R_VDD3_9807 METAL5_398000_4193000 METAL5_400000_4193000 0.008
R_VDD3_9808 METAL5_400000_4193000 METAL5_402000_4193000 0.008
R_VDD3_9809 METAL5_402000_4193000 METAL5_410000_4193000 0.032
R_VDD3_9810 METAL5_410000_4193000 METAL5_412000_4193000 0.008
R_VDD3_9811 METAL5_412000_4193000 METAL5_414000_4193000 0.008
R_VDD3_9812 METAL5_414000_4193000 METAL5_422000_4193000 0.032
R_VDD3_9813 METAL5_422000_4193000 METAL5_424000_4193000 0.008
R_VDD3_9814 METAL5_424000_4193000 METAL5_426000_4193000 0.008
R_VDD3_9815 METAL5_426000_4193000 METAL5_434000_4193000 0.032
R_VDD3_9816 METAL5_434000_4193000 METAL5_436000_4193000 0.008
R_VDD3_9817 METAL5_436000_4193000 METAL5_438000_4193000 0.008
R_VDD3_9818 METAL5_438000_4193000 METAL5_440000_4193000 0.008
R_VDD3_9819 METAL5_440000_4193000 METAL5_446000_4193000 0.024
R_VDD3_9820 METAL5_446000_4193000 METAL5_448000_4193000 0.008
R_VDD3_9821 METAL5_448000_4193000 METAL5_450000_4193000 0.008
R_VDD3_9822 METAL5_450000_4193000 METAL5_452000_4193000 0.008
R_VDD3_9823 METAL5_452000_4193000 METAL5_460000_4193000 0.032
R_VDD3_9824 METAL5_460000_4193000 METAL5_462000_4193000 0.008
R_VDD3_9825 METAL5_462000_4193000 METAL5_464000_4193000 0.008
R_VDD3_9826 METAL5_464000_4193000 METAL6_464000_4193000 0.1
R_VDD3_9827 METAL6_464000_4193000 METAL6_464000_4207000 0.028
R_VDD3_9828 METAL6_464000_4207000 METAL6_464000_4341000 0.268
R_VDD3_9829 METAL6_464000_4341000 METAL6_464000_4353000 0.024
R_VDD3_9830 METAL6_464000_4353000 METAL6_464000_4365000 0.024
R_VDD3_9831 METAL6_464000_4365000 METAL6_464000_4377000 0.024
R_VDD3_9832 METAL6_464000_4377000 METAL6_464000_4453000 0.152
R_VDD3_9833 METAL6_464000_4453000 METAL6_464000_4465000 0.024
R_VDD3_9834 METAL6_464000_4465000 METAL6_464000_4477000 0.024
R_VDD3_9835 METAL6_464000_4477000 METAL6_464000_4553000 0.152
R_VDD3_9836 METAL6_464000_4553000 METAL6_464000_4565000 0.024
R_VDD3_9837 METAL6_464000_4565000 METAL6_464000_4577000 0.024
R_VDD3_9838 METAL6_464000_4577000 METAL6_464000_4617000 0.08
R_VDD3_9839 METAL6_464000_4617000 METAL6_464000_4629000 0.024
R_VDD3_9840 METAL6_464000_4629000 METAL6_464000_4641000 0.024
R_VDD3_9841 METAL6_464000_4641000 METAL6_464000_4653000 0.024
R_VDD3_9842 METAL6_464000_4653000 METAL5_464000_4653000 0.1
R_VDD3_9843 METAL5_464000_4653000 METAL5_462000_4653000 0.008
R_VDD3_9844 METAL5_462000_4653000 METAL5_460000_4653000 0.008
R_VDD3_9845 METAL5_460000_4653000 METAL5_452000_4653000 0.032
R_VDD3_9846 METAL5_452000_4653000 METAL5_452000_4665000 0.048
R_VDD3_9847 METAL5_452000_4665000 METAL5_452000_4677000 0.048
R_VDD3_9848 METAL5_452000_4677000 METAL6_452000_4677000 0.1
R_VDD3_9849 METAL6_452000_4677000 METAL6_452000_4689000 0.024
R_VDD3_9850 METAL6_452000_4689000 METAL6_452000_4701000 0.024
R_VDD3_9851 METAL6_452000_4701000 METAL6_452000_4729000 0.056
R_VDD3_9852 METAL6_452000_4729000 METAL6_452000_4741000 0.024
R_VDD3_9853 METAL6_452000_4741000 METAL6_452000_4753000 0.024
R_VDD3_9854 METAL6_452000_4753000 METAL6_452000_4765000 0.024
R_VDD3_9855 METAL6_452000_4765000 METAL6_452000_4777000 0.024
R_VDD3_9856 METAL6_452000_4777000 METAL6_452000_4893000 0.232
R_VDD3_9857 METAL6_452000_4893000 METAL6_452000_4907000 0.028
R_VDD3_9858 METAL6_452000_4907000 METAL6_452000_5053000 0.292
R_VDD3_9859 METAL6_452000_5053000 METAL6_452000_5065000 0.024
R_VDD3_9860 METAL6_452000_5065000 METAL6_452000_5077000 0.024
R_VDD3_9861 METAL6_452000_5077000 METAL6_452000_5153000 0.152
R_VDD3_9862 METAL6_452000_5153000 METAL6_452000_5165000 0.024
R_VDD3_9863 METAL6_452000_5165000 METAL6_452000_5177000 0.024
R_VDD3_9864 METAL6_452000_5177000 METAL6_452000_5253000 0.152
R_VDD3_9865 METAL6_452000_5253000 METAL6_452000_5265000 0.024
R_VDD3_9866 METAL6_452000_5265000 METAL6_460000_5265000 0.016
R_VDD3_9867 METAL6_460000_5265000 METAL6_462000_5265000 0.004
R_VDD3_9868 METAL6_462000_5265000 METAL6_464000_5265000 0.004
R_VDD3_9869 METAL6_464000_5265000 METAL6_472000_5265000 0.016
R_VDD3_9870 METAL6_472000_5265000 METAL6_474000_5265000 0.004
R_VDD3_9871 METAL6_474000_5265000 METAL6_476000_5265000 0.004
R_VDD3_9872 METAL6_476000_5265000 METAL5_476000_5265000 0.1
R_VDD3_9873 METAL5_476000_5265000 METAL5_484000_5265000 0.032
R_VDD3_9874 METAL5_484000_5265000 METAL5_486000_5265000 0.008
R_VDD3_9875 METAL5_486000_5265000 METAL5_488000_5265000 0.008
R_VDD3_9876 METAL5_488000_5265000 METAL5_500000_5265000 0.048
R_VDD3_9877 METAL5_500000_5265000 METAL5_507000_5265000 0.028
R_VDD3_9878 METAL5_507000_5265000 METAL5_512000_5265000 0.02
R_VDD3_9879 METAL5_512000_5265000 METAL5_519000_5265000 0.028
R_VDD3_9880 METAL5_519000_5265000 METAL5_524000_5265000 0.02
R_VDD3_9881 METAL5_524000_5265000 METAL5_531000_5265000 0.028
R_VDD3_9882 METAL5_531000_5265000 METAL5_543000_5265000 0.048
R_VDD3_9883 METAL5_543000_5265000 METAL6_543000_5265000 0.1
R_VDD3_9884 METAL6_245000_4565000 METAL6_257000_4565000 0.024
R_VDD3_9885 METAL5_324000_4377000 METAL5_318000_4377000 0.024
R_VDD3_9886 METAL5_318000_4377000 METAL5_314000_4377000 0.016
R_VDD3_9887 METAL5_314000_4377000 METAL5_312000_4377000 0.008
R_VDD3_9888 METAL5_312000_4377000 METAL5_312000_4453000 0.304
R_VDD3_9889 METAL5_312000_4453000 METAL5_312000_4465000 0.048
R_VDD3_9890 METAL5_312000_4465000 METAL5_312000_4477000 0.048
R_VDD3_9891 METAL5_312000_4477000 METAL5_305000_4477000 0.028
R_VDD3_9892 METAL5_305000_4477000 METAL5_302000_4477000 0.012
R_VDD3_9893 METAL5_302000_4477000 METAL5_300000_4477000 0.008
R_VDD3_9894 METAL5_300000_4477000 METAL5_293000_4477000 0.028
R_VDD3_9895 METAL5_293000_4477000 METAL5_288000_4477000 0.02
R_VDD3_9896 METAL5_288000_4477000 METAL5_281000_4477000 0.028
R_VDD3_9897 METAL5_281000_4477000 METAL5_276000_4477000 0.02
R_VDD3_9898 METAL5_276000_4477000 METAL5_269000_4477000 0.028
R_VDD3_9899 METAL5_269000_4477000 METAL5_264000_4477000 0.02
R_VDD3_9900 METAL5_264000_4477000 METAL5_257000_4477000 0.028
R_VDD3_9901 METAL5_257000_4477000 METAL6_257000_4477000 0.1
R_VDD3_9902 METAL6_257000_4477000 METAL6_257000_4553000 0.152
R_VDD3_9903 METAL6_257000_4553000 METAL6_257000_4565000 0.024
R_VDD3_9904 METAL6_555000_4565000 METAL6_543000_4565000 0.024
R_VDD3_9905 METAL5_412000_4077000 METAL5_412000_4089000 0.048
R_VDD3_9906 METAL5_412000_4089000 METAL5_414000_4089000 0.008
R_VDD3_9907 METAL5_414000_4089000 METAL5_422000_4089000 0.032
R_VDD3_9908 METAL5_422000_4089000 METAL5_424000_4089000 0.008
R_VDD3_9909 METAL5_424000_4089000 METAL5_426000_4089000 0.008
R_VDD3_9910 METAL5_426000_4089000 METAL5_434000_4089000 0.032
R_VDD3_9911 METAL5_434000_4089000 METAL5_436000_4089000 0.008
R_VDD3_9912 METAL5_436000_4089000 METAL5_438000_4089000 0.008
R_VDD3_9913 METAL5_438000_4089000 METAL5_440000_4089000 0.008
R_VDD3_9914 METAL5_440000_4089000 METAL5_446000_4089000 0.024
R_VDD3_9915 METAL5_446000_4089000 METAL5_448000_4089000 0.008
R_VDD3_9916 METAL5_448000_4089000 METAL5_450000_4089000 0.008
R_VDD3_9917 METAL5_450000_4089000 METAL5_452000_4089000 0.008
R_VDD3_9918 METAL5_452000_4089000 METAL5_460000_4089000 0.032
R_VDD3_9919 METAL5_460000_4089000 METAL5_462000_4089000 0.008
R_VDD3_9920 METAL5_462000_4089000 METAL5_464000_4089000 0.008
R_VDD3_9921 METAL5_464000_4089000 METAL5_472000_4089000 0.032
R_VDD3_9922 METAL5_472000_4089000 METAL5_474000_4089000 0.008
R_VDD3_9923 METAL5_474000_4089000 METAL5_476000_4089000 0.008
R_VDD3_9924 METAL5_476000_4089000 METAL5_484000_4089000 0.032
R_VDD3_9925 METAL5_484000_4089000 METAL5_486000_4089000 0.008
R_VDD3_9926 METAL5_486000_4089000 METAL5_488000_4089000 0.008
R_VDD3_9927 METAL5_488000_4089000 METAL5_500000_4089000 0.048
R_VDD3_9928 METAL5_500000_4089000 METAL5_507000_4089000 0.028
R_VDD3_9929 METAL5_507000_4089000 METAL5_512000_4089000 0.02
R_VDD3_9930 METAL5_512000_4089000 METAL5_519000_4089000 0.028
R_VDD3_9931 METAL5_519000_4089000 METAL5_524000_4089000 0.02
R_VDD3_9932 METAL5_524000_4089000 METAL5_531000_4089000 0.028
R_VDD3_9933 METAL5_531000_4089000 METAL5_543000_4089000 0.048
R_VDD3_9934 METAL5_543000_4089000 METAL6_543000_4089000 0.1
R_VDD3_9935 METAL6_543000_4089000 METAL6_543000_4101000 0.024
R_VDD3_9936 METAL6_543000_4101000 METAL6_543000_4181000 0.16
R_VDD3_9937 METAL6_543000_4181000 METAL6_543000_4193000 0.024
R_VDD3_9938 METAL6_543000_4193000 METAL6_543000_4205000 0.024
R_VDD3_9939 METAL6_543000_4205000 METAL6_543000_4207000 0.004
R_VDD3_9940 METAL6_543000_4207000 METAL6_543000_4341000 0.268
R_VDD3_9941 METAL6_543000_4341000 METAL6_543000_4353000 0.024
R_VDD3_9942 METAL6_543000_4353000 METAL5_543000_4353000 0.1
R_VDD3_9943 METAL5_543000_4353000 METAL5_531000_4353000 0.048
R_VDD3_9944 METAL5_531000_4353000 METAL5_531000_4365000 0.048
R_VDD3_9945 METAL5_531000_4365000 METAL5_531000_4377000 0.048
R_VDD3_9946 METAL5_531000_4377000 METAL5_531000_4389000 0.048
R_VDD3_9947 METAL5_531000_4389000 METAL5_531000_4453000 0.256
R_VDD3_9948 METAL5_531000_4453000 METAL5_531000_4465000 0.048
R_VDD3_9949 METAL5_531000_4465000 METAL5_531000_4477000 0.048
R_VDD3_9950 METAL5_531000_4477000 METAL5_543000_4477000 0.048
R_VDD3_9951 METAL5_543000_4477000 METAL6_543000_4477000 0.1
R_VDD3_9952 METAL6_543000_4477000 METAL6_543000_4489000 0.024
R_VDD3_9953 METAL6_543000_4489000 METAL6_543000_4553000 0.128
R_VDD3_9954 METAL6_543000_4553000 METAL6_543000_4565000 0.024
R_VDD3_9955 METAL6_245000_3865000 METAL6_257000_3865000 0.024
R_VDD3_9956 METAL5_336000_3507000 METAL5_330000_3507000 0.024
R_VDD3_9957 METAL5_330000_3507000 METAL5_328000_3507000 0.008
R_VDD3_9958 METAL5_328000_3507000 METAL5_326000_3507000 0.008
R_VDD3_9959 METAL5_326000_3507000 METAL5_324000_3507000 0.008
R_VDD3_9960 METAL5_324000_3507000 METAL5_324000_3653000 0.584
R_VDD3_9961 METAL5_324000_3653000 METAL5_324000_3665000 0.048
R_VDD3_9962 METAL5_324000_3665000 METAL5_324000_3677000 0.048
R_VDD3_9963 METAL5_324000_3677000 METAL5_324000_3753000 0.304
R_VDD3_9964 METAL5_324000_3753000 METAL5_324000_3765000 0.048
R_VDD3_9965 METAL5_324000_3765000 METAL5_324000_3777000 0.048
R_VDD3_9966 METAL5_324000_3777000 METAL5_318000_3777000 0.024
R_VDD3_9967 METAL5_318000_3777000 METAL5_314000_3777000 0.016
R_VDD3_9968 METAL5_314000_3777000 METAL5_312000_3777000 0.008
R_VDD3_9969 METAL5_312000_3777000 METAL5_305000_3777000 0.028
R_VDD3_9970 METAL5_305000_3777000 METAL5_302000_3777000 0.012
R_VDD3_9971 METAL5_302000_3777000 METAL5_300000_3777000 0.008
R_VDD3_9972 METAL5_300000_3777000 METAL5_293000_3777000 0.028
R_VDD3_9973 METAL5_293000_3777000 METAL5_288000_3777000 0.02
R_VDD3_9974 METAL5_288000_3777000 METAL5_281000_3777000 0.028
R_VDD3_9975 METAL5_281000_3777000 METAL5_276000_3777000 0.02
R_VDD3_9976 METAL5_276000_3777000 METAL5_269000_3777000 0.028
R_VDD3_9977 METAL5_269000_3777000 METAL5_264000_3777000 0.02
R_VDD3_9978 METAL5_264000_3777000 METAL5_257000_3777000 0.028
R_VDD3_9979 METAL5_257000_3777000 METAL6_257000_3777000 0.1
R_VDD3_9980 METAL6_257000_3777000 METAL6_257000_3853000 0.152
R_VDD3_9981 METAL6_257000_3853000 METAL6_257000_3865000 0.024
R_VDD3_9982 METAL6_555000_3865000 METAL6_543000_3865000 0.024
R_VDD3_9983 METAL5_360000_3401000 METAL5_362000_3401000 0.008
R_VDD3_9984 METAL5_362000_3401000 METAL5_364000_3401000 0.008
R_VDD3_9985 METAL5_364000_3401000 METAL5_366000_3401000 0.008
R_VDD3_9986 METAL5_366000_3401000 METAL5_372000_3401000 0.024
R_VDD3_9987 METAL5_372000_3401000 METAL5_374000_3401000 0.008
R_VDD3_9988 METAL5_374000_3401000 METAL5_376000_3401000 0.008
R_VDD3_9989 METAL5_376000_3401000 METAL5_378000_3401000 0.008
R_VDD3_9990 METAL5_378000_3401000 METAL5_386000_3401000 0.032
R_VDD3_9991 METAL5_386000_3401000 METAL5_388000_3401000 0.008
R_VDD3_9992 METAL5_388000_3401000 METAL5_390000_3401000 0.008
R_VDD3_9993 METAL5_390000_3401000 METAL5_398000_3401000 0.032
R_VDD3_9994 METAL5_398000_3401000 METAL5_400000_3401000 0.008
R_VDD3_9995 METAL5_400000_3401000 METAL5_402000_3401000 0.008
R_VDD3_9996 METAL5_402000_3401000 METAL5_410000_3401000 0.032
R_VDD3_9997 METAL5_410000_3401000 METAL5_412000_3401000 0.008
R_VDD3_9998 METAL5_412000_3401000 METAL5_414000_3401000 0.008
R_VDD3_9999 METAL5_414000_3401000 METAL5_422000_3401000 0.032
R_VDD3_10000 METAL5_422000_3401000 METAL5_424000_3401000 0.008
R_VDD3_10001 METAL5_424000_3401000 METAL5_426000_3401000 0.008
R_VDD3_10002 METAL5_426000_3401000 METAL5_434000_3401000 0.032
R_VDD3_10003 METAL5_434000_3401000 METAL5_436000_3401000 0.008
R_VDD3_10004 METAL5_436000_3401000 METAL5_438000_3401000 0.008
R_VDD3_10005 METAL5_438000_3401000 METAL5_440000_3401000 0.008
R_VDD3_10006 METAL5_440000_3401000 METAL5_446000_3401000 0.024
R_VDD3_10007 METAL5_446000_3401000 METAL5_448000_3401000 0.008
R_VDD3_10008 METAL5_448000_3401000 METAL5_450000_3401000 0.008
R_VDD3_10009 METAL5_450000_3401000 METAL5_452000_3401000 0.008
R_VDD3_10010 METAL5_452000_3401000 METAL5_460000_3401000 0.032
R_VDD3_10011 METAL5_460000_3401000 METAL5_462000_3401000 0.008
R_VDD3_10012 METAL5_462000_3401000 METAL5_464000_3401000 0.008
R_VDD3_10013 METAL5_464000_3401000 METAL5_472000_3401000 0.032
R_VDD3_10014 METAL5_472000_3401000 METAL5_474000_3401000 0.008
R_VDD3_10015 METAL5_474000_3401000 METAL5_476000_3401000 0.008
R_VDD3_10016 METAL5_476000_3401000 METAL5_484000_3401000 0.032
R_VDD3_10017 METAL5_484000_3401000 METAL5_486000_3401000 0.008
R_VDD3_10018 METAL5_486000_3401000 METAL5_488000_3401000 0.008
R_VDD3_10019 METAL5_488000_3401000 METAL5_500000_3401000 0.048
R_VDD3_10020 METAL5_500000_3401000 METAL5_507000_3401000 0.028
R_VDD3_10021 METAL5_507000_3401000 METAL5_512000_3401000 0.02
R_VDD3_10022 METAL5_512000_3401000 METAL5_519000_3401000 0.028
R_VDD3_10023 METAL5_519000_3401000 METAL5_524000_3401000 0.02
R_VDD3_10024 METAL5_524000_3401000 METAL5_531000_3401000 0.028
R_VDD3_10025 METAL5_531000_3401000 METAL5_543000_3401000 0.048
R_VDD3_10026 METAL5_543000_3401000 METAL6_543000_3401000 0.1
R_VDD3_10027 METAL6_543000_3401000 METAL6_543000_3493000 0.184
R_VDD3_10028 METAL6_543000_3493000 METAL6_543000_3495000 0.004
R_VDD3_10029 METAL6_543000_3495000 METAL6_543000_3507000 0.024
R_VDD3_10030 METAL6_543000_3507000 METAL6_543000_3519000 0.024
R_VDD3_10031 METAL6_543000_3519000 METAL6_543000_3653000 0.268
R_VDD3_10032 METAL6_543000_3653000 METAL5_543000_3653000 0.1
R_VDD3_10033 METAL5_543000_3653000 METAL5_531000_3653000 0.048
R_VDD3_10034 METAL5_531000_3653000 METAL5_531000_3665000 0.048
R_VDD3_10035 METAL5_531000_3665000 METAL5_531000_3677000 0.048
R_VDD3_10036 METAL5_531000_3677000 METAL5_531000_3753000 0.304
R_VDD3_10037 METAL5_531000_3753000 METAL5_531000_3765000 0.048
R_VDD3_10038 METAL5_531000_3765000 METAL5_531000_3777000 0.048
R_VDD3_10039 METAL5_531000_3777000 METAL5_543000_3777000 0.048
R_VDD3_10040 METAL5_543000_3777000 METAL6_543000_3777000 0.1
R_VDD3_10041 METAL6_543000_3777000 METAL6_543000_3789000 0.024
R_VDD3_10042 METAL6_543000_3789000 METAL6_543000_3853000 0.128
R_VDD3_10043 METAL6_543000_3853000 METAL6_543000_3865000 0.024
R_VDD3_10044 METAL6_245000_3165000 METAL6_257000_3165000 0.024
R_VDD3_10045 METAL6_400000_8000 METAL6_398000_8000 0.004
R_VDD3_10046 METAL6_398000_8000 METAL6_390000_8000 0.016
R_VDD3_10047 METAL6_390000_8000 METAL6_388000_8000 0.004
R_VDD3_10048 METAL6_388000_8000 METAL6_388000_20000 0.024
R_VDD3_10049 METAL6_388000_20000 METAL6_388000_32000 0.024
R_VDD3_10050 METAL6_388000_32000 METAL6_388000_105000 0.146
R_VDD3_10051 METAL6_388000_105000 METAL6_386000_105000 0.004
R_VDD3_10052 METAL6_386000_105000 METAL6_378000_105000 0.016
R_VDD3_10053 METAL6_378000_105000 METAL6_378000_117000 0.024
R_VDD3_10054 METAL6_378000_117000 METAL6_378000_129000 0.024
R_VDD3_10055 METAL6_378000_129000 METAL6_378000_141000 0.024
R_VDD3_10056 METAL6_378000_141000 METAL6_378000_153000 0.024
R_VDD3_10057 METAL6_378000_153000 METAL6_378000_165000 0.024
R_VDD3_10058 METAL6_378000_165000 METAL6_378000_169000 0.008
R_VDD3_10059 METAL6_378000_169000 METAL6_376000_169000 0.004
R_VDD3_10060 METAL6_376000_169000 METAL6_374000_169000 0.004
R_VDD3_10061 METAL6_374000_169000 METAL6_372000_169000 0.004
R_VDD3_10062 METAL6_372000_169000 METAL6_366000_169000 0.012
R_VDD3_10063 METAL6_366000_169000 METAL6_364000_169000 0.004
R_VDD3_10064 METAL6_364000_169000 METAL6_362000_169000 0.004
R_VDD3_10065 METAL6_362000_169000 METAL6_360000_169000 0.004
R_VDD3_10066 METAL6_360000_169000 METAL6_354000_169000 0.012
R_VDD3_10067 METAL6_354000_169000 METAL6_354000_177000 0.016
R_VDD3_10068 METAL6_354000_177000 METAL6_354000_181000 0.008
R_VDD3_10069 METAL6_354000_181000 METAL6_352000_181000 0.004
R_VDD3_10070 METAL6_352000_181000 METAL6_350000_181000 0.004
R_VDD3_10071 METAL6_350000_181000 METAL6_348000_181000 0.004
R_VDD3_10072 METAL6_348000_181000 METAL6_342000_181000 0.012
R_VDD3_10073 METAL6_342000_181000 METAL6_342000_193000 0.024
R_VDD3_10074 METAL6_342000_193000 METAL6_340000_193000 0.004
R_VDD3_10075 METAL6_340000_193000 METAL6_338000_193000 0.004
R_VDD3_10076 METAL6_338000_193000 METAL6_336000_193000 0.004
R_VDD3_10077 METAL6_336000_193000 METAL6_330000_193000 0.012
R_VDD3_10078 METAL6_330000_193000 METAL6_330000_205000 0.024
R_VDD3_10079 METAL6_330000_205000 METAL6_330000_217000 0.024
R_VDD3_10080 METAL6_330000_217000 METAL6_330000_229000 0.024
R_VDD3_10081 METAL6_330000_229000 METAL6_330000_241000 0.024
R_VDD3_10082 METAL6_330000_241000 METAL6_330000_245000 0.008
R_VDD3_10083 METAL6_330000_245000 METAL5_330000_245000 0.1
R_VDD3_10084 METAL5_330000_245000 METAL5_330000_253000 0.032
R_VDD3_10085 METAL5_330000_253000 METAL5_336000_253000 0.024
R_VDD3_10086 METAL5_336000_253000 METAL5_336000_257000 0.016
R_VDD3_10087 METAL5_336000_257000 METAL5_336000_265000 0.032
R_VDD3_10088 METAL5_336000_265000 METAL5_336000_269000 0.016
R_VDD3_10089 METAL5_336000_269000 METAL5_336000_277000 0.032
R_VDD3_10090 METAL5_336000_277000 METAL5_336000_281000 0.016
R_VDD3_10091 METAL5_336000_281000 METAL5_338000_281000 0.008
R_VDD3_10092 METAL5_338000_281000 METAL5_340000_281000 0.008
R_VDD3_10093 METAL5_340000_281000 METAL5_342000_281000 0.008
R_VDD3_10094 METAL5_342000_281000 METAL5_342000_289000 0.032
R_VDD3_10095 METAL5_342000_289000 METAL5_348000_289000 0.024
R_VDD3_10096 METAL5_348000_289000 METAL5_348000_293000 0.016
R_VDD3_10097 METAL5_348000_293000 METAL5_348000_301000 0.032
R_VDD3_10098 METAL5_348000_301000 METAL5_348000_305000 0.016
R_VDD3_10099 METAL5_348000_305000 METAL5_350000_305000 0.008
R_VDD3_10100 METAL5_350000_305000 METAL5_350000_313000 0.032
R_VDD3_10101 METAL5_350000_313000 METAL5_350000_317000 0.016
R_VDD3_10102 METAL5_350000_317000 METAL5_350000_329000 0.048
R_VDD3_10103 METAL5_350000_329000 METAL5_350000_341000 0.048
R_VDD3_10104 METAL5_350000_341000 METAL5_350000_353000 0.048
R_VDD3_10105 METAL5_350000_353000 METAL5_350000_365000 0.048
R_VDD3_10106 METAL5_350000_365000 METAL5_350000_377000 0.048
R_VDD3_10107 METAL5_350000_377000 METAL6_350000_377000 0.1
R_VDD3_10108 METAL6_350000_377000 METAL6_350000_389000 0.024
R_VDD3_10109 METAL6_350000_389000 METAL6_350000_429000 0.08
R_VDD3_10110 METAL6_350000_429000 METAL6_350000_441000 0.024
R_VDD3_10111 METAL6_350000_441000 METAL6_350000_453000 0.024
R_VDD3_10112 METAL6_350000_453000 METAL6_350000_465000 0.024
R_VDD3_10113 METAL6_350000_465000 METAL6_350000_469000 0.008
R_VDD3_10114 METAL6_350000_469000 METAL6_350000_477000 0.016
R_VDD3_10115 METAL6_350000_477000 METAL6_350000_481000 0.008
R_VDD3_10116 METAL6_350000_481000 METAL5_350000_481000 0.1
R_VDD3_10117 METAL5_350000_481000 METAL5_350000_489000 0.032
R_VDD3_10118 METAL5_350000_489000 METAL5_350000_493000 0.016
R_VDD3_10119 METAL5_350000_493000 METAL5_350000_505000 0.048
R_VDD3_10120 METAL5_350000_505000 METAL5_350000_517000 0.048
R_VDD3_10121 METAL5_350000_517000 METAL5_350000_529000 0.048
R_VDD3_10122 METAL5_350000_529000 METAL5_350000_541000 0.048
R_VDD3_10123 METAL5_350000_541000 METAL5_350000_553000 0.048
R_VDD3_10124 METAL5_350000_553000 METAL5_350000_565000 0.048
R_VDD3_10125 METAL5_350000_565000 METAL5_350000_577000 0.048
R_VDD3_10126 METAL5_350000_577000 METAL4_350000_577000 0.1
R_VDD3_10127 METAL4_350000_577000 METAL4_350000_589000 0.096
R_VDD3_10128 METAL4_350000_589000 METAL4_350000_601000 0.096
R_VDD3_10129 METAL4_350000_601000 METAL5_350000_601000 0.1
R_VDD3_10130 METAL5_350000_601000 METAL5_350000_613000 0.048
R_VDD3_10131 METAL5_350000_613000 METAL5_350000_681000 0.272
R_VDD3_10132 METAL5_350000_681000 METAL5_350000_693000 0.048
R_VDD3_10133 METAL5_350000_693000 METAL5_350000_705000 0.048
R_VDD3_10134 METAL5_350000_705000 METAL5_350000_707000 0.008
R_VDD3_10135 METAL5_350000_707000 METAL5_350000_717000 0.04
R_VDD3_10136 METAL5_350000_717000 METAL5_350000_793000 0.304
R_VDD3_10137 METAL5_350000_793000 METAL5_350000_805000 0.048
R_VDD3_10138 METAL5_350000_805000 METAL5_350000_817000 0.048
R_VDD3_10139 METAL5_350000_817000 METAL5_350000_829000 0.048
R_VDD3_10140 METAL5_350000_829000 METAL5_350000_841000 0.048
R_VDD3_10141 METAL5_350000_841000 METAL5_350000_853000 0.048
R_VDD3_10142 METAL5_350000_853000 METAL5_350000_865000 0.048
R_VDD3_10143 METAL5_350000_865000 METAL5_350000_877000 0.048
R_VDD3_10144 METAL5_350000_877000 METAL5_350000_881000 0.016
R_VDD3_10145 METAL5_350000_881000 METAL5_350000_889000 0.032
R_VDD3_10146 METAL5_350000_889000 METAL5_350000_893000 0.016
R_VDD3_10147 METAL5_350000_893000 METAL5_350000_901000 0.032
R_VDD3_10148 METAL5_350000_901000 METAL5_350000_905000 0.016
R_VDD3_10149 METAL5_350000_905000 METAL4_350000_905000 0.1
R_VDD3_10150 METAL4_350000_905000 METAL4_350000_917000 0.096
R_VDD3_10151 METAL4_350000_917000 METAL4_350000_929000 0.096
R_VDD3_10152 METAL4_350000_929000 METAL4_350000_941000 0.096
R_VDD3_10153 METAL4_350000_941000 METAL4_350000_953000 0.096
R_VDD3_10154 METAL4_350000_953000 METAL4_350000_965000 0.096
R_VDD3_10155 METAL4_350000_965000 METAL4_350000_977000 0.096
R_VDD3_10156 METAL4_350000_977000 METAL4_350000_989000 0.096
R_VDD3_10157 METAL4_350000_989000 METAL4_350000_1001000 0.096
R_VDD3_10158 METAL4_350000_1001000 METAL4_350000_1013000 0.096
R_VDD3_10159 METAL4_350000_1013000 METAL5_350000_1013000 0.1
R_VDD3_10160 METAL5_350000_1013000 METAL5_350000_1025000 0.048
R_VDD3_10161 METAL5_350000_1025000 METAL5_350000_1041000 0.064
R_VDD3_10162 METAL5_350000_1041000 METAL5_350000_1053000 0.048
R_VDD3_10163 METAL5_350000_1053000 METAL5_350000_1065000 0.048
R_VDD3_10164 METAL5_350000_1065000 METAL4_350000_1065000 0.1
R_VDD3_10165 METAL4_350000_1065000 METAL4_350000_1077000 0.096
R_VDD3_10166 METAL4_350000_1077000 METAL4_350000_1089000 0.096
R_VDD3_10167 METAL4_350000_1089000 METAL5_350000_1089000 0.1
R_VDD3_10168 METAL5_350000_1089000 METAL5_350000_1153000 0.256
R_VDD3_10169 METAL5_350000_1153000 METAL5_350000_1165000 0.048
R_VDD3_10170 METAL5_350000_1165000 METAL5_350000_1177000 0.048
R_VDD3_10171 METAL5_350000_1177000 METAL5_350000_1189000 0.048
R_VDD3_10172 METAL5_350000_1189000 METAL5_350000_1201000 0.048
R_VDD3_10173 METAL5_350000_1201000 METAL5_350000_1241000 0.16
R_VDD3_10174 METAL5_350000_1241000 METAL5_350000_1253000 0.048
R_VDD3_10175 METAL5_350000_1253000 METAL5_350000_1265000 0.048
R_VDD3_10176 METAL5_350000_1265000 METAL5_350000_1277000 0.048
R_VDD3_10177 METAL5_350000_1277000 METAL5_350000_1289000 0.048
R_VDD3_10178 METAL5_350000_1289000 METAL5_350000_1369000 0.32
R_VDD3_10179 METAL5_350000_1369000 METAL5_350000_1381000 0.048
R_VDD3_10180 METAL5_350000_1381000 METAL5_350000_1393000 0.048
R_VDD3_10181 METAL5_350000_1393000 METAL5_350000_1405000 0.048
R_VDD3_10182 METAL5_350000_1405000 METAL5_348000_1405000 0.008
R_VDD3_10183 METAL5_348000_1405000 METAL5_342000_1405000 0.024
R_VDD3_10184 METAL5_342000_1405000 METAL5_342000_1407000 0.008
R_VDD3_10185 METAL5_342000_1407000 METAL5_342000_1417000 0.04
R_VDD3_10186 METAL5_342000_1417000 METAL5_342000_1541000 0.496
R_VDD3_10187 METAL5_342000_1541000 METAL4_342000_1541000 0.1
R_VDD3_10188 METAL4_342000_1541000 METAL4_342000_1553000 0.096
R_VDD3_10189 METAL4_342000_1553000 METAL4_342000_1565000 0.096
R_VDD3_10190 METAL4_342000_1565000 METAL5_342000_1565000 0.1
R_VDD3_10191 METAL5_342000_1565000 METAL5_342000_1577000 0.048
R_VDD3_10192 METAL5_342000_1577000 METAL5_342000_1629000 0.208
R_VDD3_10193 METAL5_342000_1629000 METAL5_342000_1641000 0.048
R_VDD3_10194 METAL5_342000_1641000 METAL5_342000_1653000 0.048
R_VDD3_10195 METAL5_342000_1653000 METAL4_342000_1653000 0.1
R_VDD3_10196 METAL4_342000_1653000 METAL4_342000_1665000 0.096
R_VDD3_10197 METAL4_342000_1665000 METAL4_342000_1677000 0.096
R_VDD3_10198 METAL4_342000_1677000 METAL5_342000_1677000 0.1
R_VDD3_10199 METAL5_342000_1677000 METAL5_342000_1689000 0.048
R_VDD3_10200 METAL5_342000_1689000 METAL5_342000_1753000 0.256
R_VDD3_10201 METAL5_342000_1753000 METAL5_342000_1765000 0.048
R_VDD3_10202 METAL5_342000_1765000 METAL5_342000_1777000 0.048
R_VDD3_10203 METAL5_342000_1777000 METAL5_342000_1789000 0.048
R_VDD3_10204 METAL5_342000_1789000 METAL5_342000_1817000 0.112
R_VDD3_10205 METAL5_342000_1817000 METAL5_342000_1829000 0.048
R_VDD3_10206 METAL5_342000_1829000 METAL5_342000_1841000 0.048
R_VDD3_10207 METAL5_342000_1841000 METAL5_342000_1853000 0.048
R_VDD3_10208 METAL5_342000_1853000 METAL5_342000_1865000 0.048
R_VDD3_10209 METAL5_342000_1865000 METAL5_342000_1877000 0.048
R_VDD3_10210 METAL5_342000_1877000 METAL5_342000_1917000 0.16
R_VDD3_10211 METAL5_342000_1917000 METAL5_342000_1929000 0.048
R_VDD3_10212 METAL5_342000_1929000 METAL5_342000_1941000 0.048
R_VDD3_10213 METAL5_342000_1941000 METAL5_340000_1941000 0.008
R_VDD3_10214 METAL5_340000_1941000 METAL5_338000_1941000 0.008
R_VDD3_10215 METAL5_338000_1941000 METAL5_336000_1941000 0.008
R_VDD3_10216 METAL5_336000_1941000 METAL5_330000_1941000 0.024
R_VDD3_10217 METAL5_330000_1941000 METAL5_328000_1941000 0.008
R_VDD3_10218 METAL5_328000_1941000 METAL5_326000_1941000 0.008
R_VDD3_10219 METAL5_326000_1941000 METAL5_324000_1941000 0.008
R_VDD3_10220 METAL5_324000_1941000 METAL4_324000_1941000 0.1
R_VDD3_10221 METAL4_324000_1941000 METAL4_324000_1953000 0.096
R_VDD3_10222 METAL4_324000_1953000 METAL4_324000_1965000 0.096
R_VDD3_10223 METAL4_324000_1965000 METAL4_324000_1977000 0.096
R_VDD3_10224 METAL4_324000_1977000 METAL4_324000_1989000 0.096
R_VDD3_10225 METAL4_324000_1989000 METAL4_324000_2001000 0.096
R_VDD3_10226 METAL4_324000_2001000 METAL4_318000_2001000 0.048
R_VDD3_10227 METAL4_318000_2001000 METAL4_314000_2001000 0.032
R_VDD3_10228 METAL4_314000_2001000 METAL4_312000_2001000 0.016
R_VDD3_10229 METAL4_312000_2001000 METAL4_305000_2001000 0.056
R_VDD3_10230 METAL4_305000_2001000 METAL4_302000_2001000 0.024
R_VDD3_10231 METAL4_302000_2001000 METAL4_300000_2001000 0.016
R_VDD3_10232 METAL4_300000_2001000 METAL5_300000_2001000 0.1
R_VDD3_10233 METAL5_300000_2001000 METAL5_300000_2093000 0.368
R_VDD3_10234 METAL5_300000_2093000 METAL5_300000_2107000 0.056
R_VDD3_10235 METAL5_300000_2107000 METAL5_300000_2229000 0.488
R_VDD3_10236 METAL5_300000_2229000 METAL5_293000_2229000 0.028
R_VDD3_10237 METAL5_293000_2229000 METAL5_288000_2229000 0.02
R_VDD3_10238 METAL5_288000_2229000 METAL5_288000_2241000 0.048
R_VDD3_10239 METAL5_288000_2241000 METAL5_288000_2253000 0.048
R_VDD3_10240 METAL5_288000_2253000 METAL5_288000_2265000 0.048
R_VDD3_10241 METAL5_288000_2265000 METAL5_288000_2277000 0.048
R_VDD3_10242 METAL5_288000_2277000 METAL5_288000_2341000 0.256
R_VDD3_10243 METAL5_288000_2341000 METAL5_288000_2353000 0.048
R_VDD3_10244 METAL5_288000_2353000 METAL5_288000_2365000 0.048
R_VDD3_10245 METAL5_288000_2365000 METAL5_288000_2377000 0.048
R_VDD3_10246 METAL5_288000_2377000 METAL5_288000_2453000 0.304
R_VDD3_10247 METAL5_288000_2453000 METAL5_288000_2465000 0.048
R_VDD3_10248 METAL5_288000_2465000 METAL5_288000_2477000 0.048
R_VDD3_10249 METAL5_288000_2477000 METAL5_288000_2489000 0.048
R_VDD3_10250 METAL5_288000_2489000 METAL5_288000_2553000 0.256
R_VDD3_10251 METAL5_288000_2553000 METAL5_288000_2565000 0.048
R_VDD3_10252 METAL5_288000_2565000 METAL5_288000_2577000 0.048
R_VDD3_10253 METAL5_288000_2577000 METAL5_288000_2605000 0.112
R_VDD3_10254 METAL5_288000_2605000 METAL5_288000_2617000 0.048
R_VDD3_10255 METAL5_288000_2617000 METAL5_288000_2629000 0.048
R_VDD3_10256 METAL5_288000_2629000 METAL4_288000_2629000 0.1
R_VDD3_10257 METAL4_288000_2629000 METAL4_288000_2641000 0.096
R_VDD3_10258 METAL4_288000_2641000 METAL4_288000_2653000 0.096
R_VDD3_10259 METAL4_288000_2653000 METAL5_288000_2653000 0.1
R_VDD3_10260 METAL5_288000_2653000 METAL5_288000_2665000 0.048
R_VDD3_10261 METAL5_288000_2665000 METAL5_288000_2677000 0.048
R_VDD3_10262 METAL5_288000_2677000 METAL5_288000_2689000 0.048
R_VDD3_10263 METAL5_288000_2689000 METAL5_288000_2701000 0.048
R_VDD3_10264 METAL5_288000_2701000 METAL5_288000_2769000 0.272
R_VDD3_10265 METAL5_288000_2769000 METAL5_288000_2781000 0.048
R_VDD3_10266 METAL5_288000_2781000 METAL4_288000_2781000 0.1
R_VDD3_10267 METAL4_288000_2781000 METAL4_288000_2793000 0.096
R_VDD3_10268 METAL4_288000_2793000 METAL4_288000_2805000 0.096
R_VDD3_10269 METAL4_288000_2805000 METAL5_288000_2805000 0.1
R_VDD3_10270 METAL5_288000_2805000 METAL5_281000_2805000 0.028
R_VDD3_10271 METAL5_281000_2805000 METAL5_281000_2807000 0.008
R_VDD3_10272 METAL5_281000_2807000 METAL5_281000_2817000 0.04
R_VDD3_10273 METAL5_281000_2817000 METAL5_281000_2941000 0.496
R_VDD3_10274 METAL5_281000_2941000 METAL5_281000_2953000 0.048
R_VDD3_10275 METAL5_281000_2953000 METAL5_281000_2965000 0.048
R_VDD3_10276 METAL5_281000_2965000 METAL5_281000_2977000 0.048
R_VDD3_10277 METAL5_281000_2977000 METAL5_281000_2989000 0.048
R_VDD3_10278 METAL5_281000_2989000 METAL5_281000_3001000 0.048
R_VDD3_10279 METAL5_281000_3001000 METAL5_281000_3053000 0.208
R_VDD3_10280 METAL5_281000_3053000 METAL5_281000_3065000 0.048
R_VDD3_10281 METAL5_281000_3065000 METAL5_281000_3077000 0.048
R_VDD3_10282 METAL5_281000_3077000 METAL4_281000_3077000 0.1
R_VDD3_10283 METAL4_281000_3077000 METAL4_276000_3077000 0.04
R_VDD3_10284 METAL4_276000_3077000 METAL4_269000_3077000 0.056
R_VDD3_10285 METAL4_269000_3077000 METAL4_264000_3077000 0.04
R_VDD3_10286 METAL4_264000_3077000 METAL4_257000_3077000 0.056
R_VDD3_10287 METAL4_257000_3077000 METAL5_257000_3077000 0.1
R_VDD3_10288 METAL5_257000_3077000 METAL6_257000_3077000 0.1
R_VDD3_10289 METAL6_257000_3077000 METAL6_257000_3153000 0.152
R_VDD3_10290 METAL6_257000_3153000 METAL6_257000_3165000 0.024
R_VDD3_10291 METAL6_555000_3165000 METAL6_543000_3165000 0.024
R_VDD3_10292 METAL6_400000_8000 METAL5_400000_8000 0.1
R_VDD3_10293 METAL5_400000_8000 METAL5_398000_8000 0.008
R_VDD3_10294 METAL5_398000_8000 METAL5_390000_8000 0.032
R_VDD3_10295 METAL5_390000_8000 METAL5_388000_8000 0.008
R_VDD3_10296 METAL5_388000_8000 METAL5_386000_8000 0.008
R_VDD3_10297 METAL5_386000_8000 METAL5_378000_8000 0.032
R_VDD3_10298 METAL5_378000_8000 METAL5_376000_8000 0.008
R_VDD3_10299 METAL5_376000_8000 METAL6_376000_8000 0.1
R_VDD3_10300 METAL6_376000_8000 METAL6_376000_20000 0.024
R_VDD3_10301 METAL6_376000_20000 METAL6_376000_32000 0.024
R_VDD3_10302 METAL6_376000_32000 METAL6_376000_93000 0.122
R_VDD3_10303 METAL6_376000_93000 METAL6_374000_93000 0.004
R_VDD3_10304 METAL6_374000_93000 METAL6_372000_93000 0.004
R_VDD3_10305 METAL6_372000_93000 METAL6_366000_93000 0.012
R_VDD3_10306 METAL6_366000_93000 METAL6_366000_105000 0.024
R_VDD3_10307 METAL6_366000_105000 METAL6_366000_117000 0.024
R_VDD3_10308 METAL6_366000_117000 METAL6_366000_129000 0.024
R_VDD3_10309 METAL6_366000_129000 METAL6_366000_141000 0.024
R_VDD3_10310 METAL6_366000_141000 METAL6_366000_153000 0.024
R_VDD3_10311 METAL6_366000_153000 METAL6_366000_157000 0.008
R_VDD3_10312 METAL6_366000_157000 METAL5_366000_157000 0.1
R_VDD3_10313 METAL5_366000_157000 METAL5_366000_165000 0.032
R_VDD3_10314 METAL5_366000_165000 METAL5_366000_169000 0.016
R_VDD3_10315 METAL5_366000_169000 METAL5_366000_177000 0.032
R_VDD3_10316 METAL5_366000_177000 METAL5_366000_181000 0.016
R_VDD3_10317 METAL5_366000_181000 METAL5_366000_193000 0.048
R_VDD3_10318 METAL5_366000_193000 METAL5_366000_205000 0.048
R_VDD3_10319 METAL5_366000_205000 METAL5_366000_217000 0.048
R_VDD3_10320 METAL5_366000_217000 METAL5_366000_229000 0.048
R_VDD3_10321 METAL5_366000_229000 METAL5_366000_233000 0.016
R_VDD3_10322 METAL5_366000_233000 METAL5_366000_241000 0.032
R_VDD3_10323 METAL5_366000_241000 METAL5_366000_245000 0.016
R_VDD3_10324 METAL5_366000_245000 METAL5_366000_253000 0.032
R_VDD3_10325 METAL5_366000_253000 METAL5_366000_257000 0.016
R_VDD3_10326 METAL5_366000_257000 METAL5_366000_265000 0.032
R_VDD3_10327 METAL5_366000_265000 METAL5_366000_269000 0.016
R_VDD3_10328 METAL5_366000_269000 METAL5_366000_277000 0.032
R_VDD3_10329 METAL5_366000_277000 METAL5_366000_281000 0.016
R_VDD3_10330 METAL5_366000_281000 METAL5_366000_289000 0.032
R_VDD3_10331 METAL5_366000_289000 METAL5_366000_293000 0.016
R_VDD3_10332 METAL5_366000_293000 METAL5_366000_301000 0.032
R_VDD3_10333 METAL5_366000_301000 METAL5_366000_305000 0.016
R_VDD3_10334 METAL5_366000_305000 METAL5_366000_313000 0.032
R_VDD3_10335 METAL5_366000_313000 METAL5_366000_317000 0.016
R_VDD3_10336 METAL5_366000_317000 METAL5_366000_329000 0.048
R_VDD3_10337 METAL5_366000_329000 METAL5_366000_341000 0.048
R_VDD3_10338 METAL5_366000_341000 METAL5_366000_353000 0.048
R_VDD3_10339 METAL5_366000_353000 METAL5_366000_365000 0.048
R_VDD3_10340 METAL5_366000_365000 METAL5_366000_377000 0.048
R_VDD3_10341 METAL5_366000_377000 METAL6_366000_377000 0.1
R_VDD3_10342 METAL6_366000_377000 METAL6_366000_389000 0.024
R_VDD3_10343 METAL6_366000_389000 METAL6_366000_429000 0.08
R_VDD3_10344 METAL6_366000_429000 METAL6_366000_441000 0.024
R_VDD3_10345 METAL6_366000_441000 METAL6_366000_453000 0.024
R_VDD3_10346 METAL6_366000_453000 METAL6_366000_465000 0.024
R_VDD3_10347 METAL6_366000_465000 METAL6_366000_469000 0.008
R_VDD3_10348 METAL6_366000_469000 METAL6_366000_477000 0.016
R_VDD3_10349 METAL6_366000_477000 METAL6_366000_481000 0.008
R_VDD3_10350 METAL6_366000_481000 METAL5_366000_481000 0.1
R_VDD3_10351 METAL5_366000_481000 METAL5_366000_489000 0.032
R_VDD3_10352 METAL5_366000_489000 METAL5_372000_489000 0.024
R_VDD3_10353 METAL5_372000_489000 METAL5_372000_493000 0.016
R_VDD3_10354 METAL5_372000_493000 METAL5_372000_505000 0.048
R_VDD3_10355 METAL5_372000_505000 METAL5_372000_517000 0.048
R_VDD3_10356 METAL5_372000_517000 METAL5_372000_529000 0.048
R_VDD3_10357 METAL5_372000_529000 METAL5_372000_541000 0.048
R_VDD3_10358 METAL5_372000_541000 METAL5_372000_553000 0.048
R_VDD3_10359 METAL5_372000_553000 METAL5_372000_565000 0.048
R_VDD3_10360 METAL5_372000_565000 METAL5_372000_577000 0.048
R_VDD3_10361 METAL5_372000_577000 METAL4_372000_577000 0.1
R_VDD3_10362 METAL4_372000_577000 METAL4_372000_589000 0.096
R_VDD3_10363 METAL4_372000_589000 METAL4_372000_601000 0.096
R_VDD3_10364 METAL4_372000_601000 METAL5_372000_601000 0.1
R_VDD3_10365 METAL5_372000_601000 METAL5_372000_613000 0.048
R_VDD3_10366 METAL5_372000_613000 METAL5_372000_681000 0.272
R_VDD3_10367 METAL5_372000_681000 METAL5_372000_693000 0.048
R_VDD3_10368 METAL5_372000_693000 METAL5_372000_705000 0.048
R_VDD3_10369 METAL5_372000_705000 METAL5_372000_707000 0.008
R_VDD3_10370 METAL5_372000_707000 METAL5_372000_717000 0.04
R_VDD3_10371 METAL5_372000_717000 METAL5_372000_793000 0.304
R_VDD3_10372 METAL5_372000_793000 METAL5_372000_805000 0.048
R_VDD3_10373 METAL5_372000_805000 METAL5_374000_805000 0.008
R_VDD3_10374 METAL5_374000_805000 METAL4_374000_805000 0.1
R_VDD3_10375 METAL4_374000_805000 METAL4_374000_817000 0.096
R_VDD3_10376 METAL4_374000_817000 METAL4_374000_829000 0.096
R_VDD3_10377 METAL4_374000_829000 METAL5_374000_829000 0.1
R_VDD3_10378 METAL5_374000_829000 METAL5_374000_841000 0.048
R_VDD3_10379 METAL5_374000_841000 METAL5_374000_853000 0.048
R_VDD3_10380 METAL5_374000_853000 METAL5_374000_865000 0.048
R_VDD3_10381 METAL5_374000_865000 METAL5_374000_877000 0.048
R_VDD3_10382 METAL5_374000_877000 METAL5_374000_881000 0.016
R_VDD3_10383 METAL5_374000_881000 METAL5_374000_889000 0.032
R_VDD3_10384 METAL5_374000_889000 METAL5_374000_893000 0.016
R_VDD3_10385 METAL5_374000_893000 METAL5_374000_901000 0.032
R_VDD3_10386 METAL5_374000_901000 METAL5_374000_905000 0.016
R_VDD3_10387 METAL5_374000_905000 METAL5_374000_917000 0.048
R_VDD3_10388 METAL5_374000_917000 METAL5_374000_929000 0.048
R_VDD3_10389 METAL5_374000_929000 METAL5_374000_941000 0.048
R_VDD3_10390 METAL5_374000_941000 METAL5_374000_953000 0.048
R_VDD3_10391 METAL5_374000_953000 METAL5_374000_965000 0.048
R_VDD3_10392 METAL5_374000_965000 METAL5_374000_977000 0.048
R_VDD3_10393 METAL5_374000_977000 METAL5_376000_977000 0.008
R_VDD3_10394 METAL5_376000_977000 METAL5_378000_977000 0.008
R_VDD3_10395 METAL5_378000_977000 METAL5_386000_977000 0.032
R_VDD3_10396 METAL5_386000_977000 METAL5_388000_977000 0.008
R_VDD3_10397 METAL5_388000_977000 METAL5_390000_977000 0.008
R_VDD3_10398 METAL5_390000_977000 METAL5_398000_977000 0.032
R_VDD3_10399 METAL5_398000_977000 METAL5_398000_989000 0.048
R_VDD3_10400 METAL5_398000_989000 METAL5_400000_989000 0.008
R_VDD3_10401 METAL5_400000_989000 METAL5_402000_989000 0.008
R_VDD3_10402 METAL5_402000_989000 METAL5_410000_989000 0.032
R_VDD3_10403 METAL5_410000_989000 METAL5_410000_1001000 0.048
R_VDD3_10404 METAL5_410000_1001000 METAL5_410000_1013000 0.048
R_VDD3_10405 METAL5_410000_1013000 METAL5_410000_1025000 0.048
R_VDD3_10406 METAL5_410000_1025000 METAL5_410000_1041000 0.064
R_VDD3_10407 METAL5_410000_1041000 METAL5_410000_1053000 0.048
R_VDD3_10408 METAL5_410000_1053000 METAL5_410000_1065000 0.048
R_VDD3_10409 METAL5_410000_1065000 METAL4_410000_1065000 0.1
R_VDD3_10410 METAL4_410000_1065000 METAL4_410000_1077000 0.096
R_VDD3_10411 METAL4_410000_1077000 METAL4_410000_1089000 0.096
R_VDD3_10412 METAL4_410000_1089000 METAL5_410000_1089000 0.1
R_VDD3_10413 METAL5_410000_1089000 METAL5_410000_1101000 0.048
R_VDD3_10414 METAL5_410000_1101000 METAL5_410000_1153000 0.208
R_VDD3_10415 METAL5_410000_1153000 METAL5_410000_1165000 0.048
R_VDD3_10416 METAL5_410000_1165000 METAL4_410000_1165000 0.1
R_VDD3_10417 METAL4_410000_1165000 METAL4_410000_1177000 0.096
R_VDD3_10418 METAL4_410000_1177000 METAL4_410000_1189000 0.096
R_VDD3_10419 METAL4_410000_1189000 METAL5_410000_1189000 0.1
R_VDD3_10420 METAL5_410000_1189000 METAL5_410000_1201000 0.048
R_VDD3_10421 METAL5_410000_1201000 METAL5_410000_1241000 0.16
R_VDD3_10422 METAL5_410000_1241000 METAL5_410000_1253000 0.048
R_VDD3_10423 METAL5_410000_1253000 METAL5_412000_1253000 0.008
R_VDD3_10424 METAL5_412000_1253000 METAL5_414000_1253000 0.008
R_VDD3_10425 METAL5_414000_1253000 METAL5_422000_1253000 0.032
R_VDD3_10426 METAL5_422000_1253000 METAL5_424000_1253000 0.008
R_VDD3_10427 METAL5_424000_1253000 METAL5_426000_1253000 0.008
R_VDD3_10428 METAL5_426000_1253000 METAL5_434000_1253000 0.032
R_VDD3_10429 METAL5_434000_1253000 METAL5_434000_1265000 0.048
R_VDD3_10430 METAL5_434000_1265000 METAL5_434000_1277000 0.048
R_VDD3_10431 METAL5_434000_1277000 METAL5_434000_1289000 0.048
R_VDD3_10432 METAL5_434000_1289000 METAL5_434000_1369000 0.32
R_VDD3_10433 METAL5_434000_1369000 METAL4_434000_1369000 0.1
R_VDD3_10434 METAL4_434000_1369000 METAL4_434000_1381000 0.096
R_VDD3_10435 METAL4_434000_1381000 METAL4_434000_1393000 0.096
R_VDD3_10436 METAL4_434000_1393000 METAL5_434000_1393000 0.1
R_VDD3_10437 METAL5_434000_1393000 METAL5_434000_1405000 0.048
R_VDD3_10438 METAL5_434000_1405000 METAL5_434000_1407000 0.008
R_VDD3_10439 METAL5_434000_1407000 METAL5_434000_1417000 0.04
R_VDD3_10440 METAL5_434000_1417000 METAL5_434000_1529000 0.448
R_VDD3_10441 METAL5_434000_1529000 METAL5_434000_1541000 0.048
R_VDD3_10442 METAL5_434000_1541000 METAL5_434000_1553000 0.048
R_VDD3_10443 METAL5_434000_1553000 METAL5_434000_1565000 0.048
R_VDD3_10444 METAL5_434000_1565000 METAL5_434000_1577000 0.048
R_VDD3_10445 METAL5_434000_1577000 METAL5_434000_1629000 0.208
R_VDD3_10446 METAL5_434000_1629000 METAL5_434000_1641000 0.048
R_VDD3_10447 METAL5_434000_1641000 METAL5_434000_1653000 0.048
R_VDD3_10448 METAL5_434000_1653000 METAL5_434000_1665000 0.048
R_VDD3_10449 METAL5_434000_1665000 METAL5_434000_1677000 0.048
R_VDD3_10450 METAL5_434000_1677000 METAL5_434000_1689000 0.048
R_VDD3_10451 METAL5_434000_1689000 METAL5_434000_1753000 0.256
R_VDD3_10452 METAL5_434000_1753000 METAL5_434000_1765000 0.048
R_VDD3_10453 METAL5_434000_1765000 METAL5_434000_1777000 0.048
R_VDD3_10454 METAL5_434000_1777000 METAL5_434000_1789000 0.048
R_VDD3_10455 METAL5_434000_1789000 METAL5_434000_1817000 0.112
R_VDD3_10456 METAL5_434000_1817000 METAL5_434000_1829000 0.048
R_VDD3_10457 METAL5_434000_1829000 METAL5_434000_1841000 0.048
R_VDD3_10458 METAL5_434000_1841000 METAL5_434000_1853000 0.048
R_VDD3_10459 METAL5_434000_1853000 METAL5_434000_1865000 0.048
R_VDD3_10460 METAL5_434000_1865000 METAL5_434000_1877000 0.048
R_VDD3_10461 METAL5_434000_1877000 METAL5_434000_1917000 0.16
R_VDD3_10462 METAL5_434000_1917000 METAL5_434000_1929000 0.048
R_VDD3_10463 METAL5_434000_1929000 METAL4_434000_1929000 0.1
R_VDD3_10464 METAL4_434000_1929000 METAL4_434000_1941000 0.096
R_VDD3_10465 METAL4_434000_1941000 METAL4_434000_1953000 0.096
R_VDD3_10466 METAL4_434000_1953000 METAL4_434000_1965000 0.096
R_VDD3_10467 METAL4_434000_1965000 METAL4_434000_1977000 0.096
R_VDD3_10468 METAL4_434000_1977000 METAL4_434000_1989000 0.096
R_VDD3_10469 METAL4_434000_1989000 METAL5_434000_1989000 0.1
R_VDD3_10470 METAL5_434000_1989000 METAL5_434000_2001000 0.048
R_VDD3_10471 METAL5_434000_2001000 METAL5_434000_2013000 0.048
R_VDD3_10472 METAL5_434000_2013000 METAL5_434000_2093000 0.32
R_VDD3_10473 METAL5_434000_2093000 METAL5_434000_2107000 0.056
R_VDD3_10474 METAL5_434000_2107000 METAL5_434000_2217000 0.44
R_VDD3_10475 METAL5_434000_2217000 METAL5_434000_2229000 0.048
R_VDD3_10476 METAL5_434000_2229000 METAL5_434000_2241000 0.048
R_VDD3_10477 METAL5_434000_2241000 METAL5_434000_2253000 0.048
R_VDD3_10478 METAL5_434000_2253000 METAL5_434000_2265000 0.048
R_VDD3_10479 METAL5_434000_2265000 METAL5_434000_2277000 0.048
R_VDD3_10480 METAL5_434000_2277000 METAL5_434000_2341000 0.256
R_VDD3_10481 METAL5_434000_2341000 METAL5_434000_2353000 0.048
R_VDD3_10482 METAL5_434000_2353000 METAL5_434000_2365000 0.048
R_VDD3_10483 METAL5_434000_2365000 METAL5_434000_2377000 0.048
R_VDD3_10484 METAL5_434000_2377000 METAL5_434000_2453000 0.304
R_VDD3_10485 METAL5_434000_2453000 METAL5_434000_2465000 0.048
R_VDD3_10486 METAL5_434000_2465000 METAL5_434000_2477000 0.048
R_VDD3_10487 METAL5_434000_2477000 METAL5_434000_2489000 0.048
R_VDD3_10488 METAL5_434000_2489000 METAL5_434000_2553000 0.256
R_VDD3_10489 METAL5_434000_2553000 METAL5_434000_2565000 0.048
R_VDD3_10490 METAL5_434000_2565000 METAL5_434000_2577000 0.048
R_VDD3_10491 METAL5_434000_2577000 METAL5_434000_2605000 0.112
R_VDD3_10492 METAL5_434000_2605000 METAL5_434000_2617000 0.048
R_VDD3_10493 METAL5_434000_2617000 METAL5_434000_2629000 0.048
R_VDD3_10494 METAL5_434000_2629000 METAL5_434000_2641000 0.048
R_VDD3_10495 METAL5_434000_2641000 METAL5_434000_2653000 0.048
R_VDD3_10496 METAL5_434000_2653000 METAL5_434000_2665000 0.048
R_VDD3_10497 METAL5_434000_2665000 METAL4_434000_2665000 0.1
R_VDD3_10498 METAL4_434000_2665000 METAL4_434000_2677000 0.096
R_VDD3_10499 METAL4_434000_2677000 METAL4_434000_2689000 0.096
R_VDD3_10500 METAL4_434000_2689000 METAL4_434000_2701000 0.096
R_VDD3_10501 METAL4_434000_2701000 METAL5_434000_2701000 0.1
R_VDD3_10502 METAL5_434000_2701000 METAL5_434000_2769000 0.272
R_VDD3_10503 METAL5_434000_2769000 METAL5_434000_2781000 0.048
R_VDD3_10504 METAL5_434000_2781000 METAL5_434000_2793000 0.048
R_VDD3_10505 METAL5_434000_2793000 METAL5_434000_2805000 0.048
R_VDD3_10506 METAL5_434000_2805000 METAL5_436000_2805000 0.008
R_VDD3_10507 METAL5_436000_2805000 METAL5_438000_2805000 0.008
R_VDD3_10508 METAL5_438000_2805000 METAL5_440000_2805000 0.008
R_VDD3_10509 METAL5_440000_2805000 METAL5_446000_2805000 0.024
R_VDD3_10510 METAL5_446000_2805000 METAL5_446000_2807000 0.008
R_VDD3_10511 METAL5_446000_2807000 METAL5_446000_2817000 0.04
R_VDD3_10512 METAL5_446000_2817000 METAL5_446000_2941000 0.496
R_VDD3_10513 METAL5_446000_2941000 METAL5_446000_2953000 0.048
R_VDD3_10514 METAL5_446000_2953000 METAL5_446000_2965000 0.048
R_VDD3_10515 METAL5_446000_2965000 METAL5_446000_2977000 0.048
R_VDD3_10516 METAL5_446000_2977000 METAL5_446000_2989000 0.048
R_VDD3_10517 METAL5_446000_2989000 METAL5_446000_3001000 0.048
R_VDD3_10518 METAL5_446000_3001000 METAL5_446000_3053000 0.208
R_VDD3_10519 METAL5_446000_3053000 METAL5_446000_3065000 0.048
R_VDD3_10520 METAL5_446000_3065000 METAL5_446000_3077000 0.048
R_VDD3_10521 METAL5_446000_3077000 METAL5_448000_3077000 0.008
R_VDD3_10522 METAL5_448000_3077000 METAL5_450000_3077000 0.008
R_VDD3_10523 METAL5_450000_3077000 METAL5_452000_3077000 0.008
R_VDD3_10524 METAL5_452000_3077000 METAL5_460000_3077000 0.032
R_VDD3_10525 METAL5_460000_3077000 METAL5_462000_3077000 0.008
R_VDD3_10526 METAL5_462000_3077000 METAL5_464000_3077000 0.008
R_VDD3_10527 METAL5_464000_3077000 METAL5_472000_3077000 0.032
R_VDD3_10528 METAL5_472000_3077000 METAL5_474000_3077000 0.008
R_VDD3_10529 METAL5_474000_3077000 METAL5_476000_3077000 0.008
R_VDD3_10530 METAL5_476000_3077000 METAL5_484000_3077000 0.032
R_VDD3_10531 METAL5_484000_3077000 METAL5_486000_3077000 0.008
R_VDD3_10532 METAL5_486000_3077000 METAL5_488000_3077000 0.008
R_VDD3_10533 METAL5_488000_3077000 METAL5_500000_3077000 0.048
R_VDD3_10534 METAL5_500000_3077000 METAL5_507000_3077000 0.028
R_VDD3_10535 METAL5_507000_3077000 METAL5_512000_3077000 0.02
R_VDD3_10536 METAL5_512000_3077000 METAL5_519000_3077000 0.028
R_VDD3_10537 METAL5_519000_3077000 METAL4_519000_3077000 0.1
R_VDD3_10538 METAL4_519000_3077000 METAL4_524000_3077000 0.04
R_VDD3_10539 METAL4_524000_3077000 METAL4_531000_3077000 0.056
R_VDD3_10540 METAL4_531000_3077000 METAL4_543000_3077000 0.096
R_VDD3_10541 METAL4_543000_3077000 METAL5_543000_3077000 0.1
R_VDD3_10542 METAL5_543000_3077000 METAL6_543000_3077000 0.1
R_VDD3_10543 METAL6_543000_3077000 METAL6_543000_3089000 0.024
R_VDD3_10544 METAL6_543000_3089000 METAL6_543000_3153000 0.128
R_VDD3_10545 METAL6_543000_3153000 METAL6_543000_3165000 0.024
R_VDD3_10546 METAL6_245000_2465000 METAL6_257000_2465000 0.024
R_VDD3_10547 METAL5_400000_8000 METAL5_400000_20000 0.048
R_VDD3_10548 METAL5_400000_20000 METAL5_398000_20000 0.008
R_VDD3_10549 METAL5_398000_20000 METAL5_390000_20000 0.032
R_VDD3_10550 METAL5_390000_20000 METAL5_388000_20000 0.008
R_VDD3_10551 METAL5_388000_20000 METAL5_386000_20000 0.008
R_VDD3_10552 METAL5_386000_20000 METAL5_384000_20000 0.008
R_VDD3_10553 METAL5_384000_20000 METAL5_378000_20000 0.024
R_VDD3_10554 METAL5_378000_20000 METAL5_376000_20000 0.008
R_VDD3_10555 METAL5_376000_20000 METAL5_374000_20000 0.008
R_VDD3_10556 METAL5_374000_20000 METAL5_372000_20000 0.008
R_VDD3_10557 METAL5_372000_20000 METAL5_366000_20000 0.024
R_VDD3_10558 METAL5_366000_20000 METAL5_364000_20000 0.008
R_VDD3_10559 METAL5_364000_20000 METAL6_364000_20000 0.1
R_VDD3_10560 METAL6_364000_20000 METAL6_364000_32000 0.024
R_VDD3_10561 METAL6_364000_32000 METAL6_364000_81000 0.098
R_VDD3_10562 METAL6_364000_81000 METAL6_362000_81000 0.004
R_VDD3_10563 METAL6_362000_81000 METAL6_360000_81000 0.004
R_VDD3_10564 METAL6_360000_81000 METAL6_354000_81000 0.012
R_VDD3_10565 METAL6_354000_81000 METAL6_354000_93000 0.024
R_VDD3_10566 METAL6_354000_93000 METAL6_354000_105000 0.024
R_VDD3_10567 METAL6_354000_105000 METAL6_354000_117000 0.024
R_VDD3_10568 METAL6_354000_117000 METAL6_354000_129000 0.024
R_VDD3_10569 METAL6_354000_129000 METAL6_354000_141000 0.024
R_VDD3_10570 METAL6_354000_141000 METAL6_354000_145000 0.008
R_VDD3_10571 METAL6_354000_145000 METAL6_354000_153000 0.016
R_VDD3_10572 METAL6_354000_153000 METAL6_354000_157000 0.008
R_VDD3_10573 METAL6_354000_157000 METAL6_352000_157000 0.004
R_VDD3_10574 METAL6_352000_157000 METAL6_350000_157000 0.004
R_VDD3_10575 METAL6_350000_157000 METAL6_348000_157000 0.004
R_VDD3_10576 METAL6_348000_157000 METAL6_342000_157000 0.012
R_VDD3_10577 METAL6_342000_157000 METAL6_342000_165000 0.016
R_VDD3_10578 METAL6_342000_165000 METAL6_342000_169000 0.008
R_VDD3_10579 METAL6_342000_169000 METAL6_340000_169000 0.004
R_VDD3_10580 METAL6_340000_169000 METAL6_338000_169000 0.004
R_VDD3_10581 METAL6_338000_169000 METAL6_336000_169000 0.004
R_VDD3_10582 METAL6_336000_169000 METAL6_330000_169000 0.012
R_VDD3_10583 METAL6_330000_169000 METAL6_330000_177000 0.016
R_VDD3_10584 METAL6_330000_177000 METAL6_330000_181000 0.008
R_VDD3_10585 METAL6_330000_181000 METAL6_328000_181000 0.004
R_VDD3_10586 METAL6_328000_181000 METAL6_326000_181000 0.004
R_VDD3_10587 METAL6_326000_181000 METAL6_324000_181000 0.004
R_VDD3_10588 METAL6_324000_181000 METAL6_318000_181000 0.012
R_VDD3_10589 METAL6_318000_181000 METAL6_318000_193000 0.024
R_VDD3_10590 METAL6_318000_193000 METAL6_318000_205000 0.024
R_VDD3_10591 METAL6_318000_205000 METAL6_318000_217000 0.024
R_VDD3_10592 METAL6_318000_217000 METAL6_318000_229000 0.024
R_VDD3_10593 METAL6_318000_229000 METAL6_318000_233000 0.008
R_VDD3_10594 METAL6_318000_233000 METAL6_318000_241000 0.016
R_VDD3_10595 METAL6_318000_241000 METAL6_314000_241000 0.008
R_VDD3_10596 METAL6_314000_241000 METAL6_314000_245000 0.008
R_VDD3_10597 METAL6_314000_245000 METAL6_314000_253000 0.016
R_VDD3_10598 METAL6_314000_253000 METAL6_314000_257000 0.008
R_VDD3_10599 METAL6_314000_257000 METAL6_314000_265000 0.016
R_VDD3_10600 METAL6_314000_265000 METAL6_314000_269000 0.008
R_VDD3_10601 METAL6_314000_269000 METAL6_314000_277000 0.016
R_VDD3_10602 METAL6_314000_277000 METAL6_314000_281000 0.008
R_VDD3_10603 METAL6_314000_281000 METAL6_314000_289000 0.016
R_VDD3_10604 METAL6_314000_289000 METAL6_314000_293000 0.008
R_VDD3_10605 METAL6_314000_293000 METAL6_312000_293000 0.004
R_VDD3_10606 METAL6_312000_293000 METAL6_305000_293000 0.014
R_VDD3_10607 METAL6_305000_293000 METAL6_302000_293000 0.006
R_VDD3_10608 METAL6_302000_293000 METAL6_302000_301000 0.016
R_VDD3_10609 METAL6_302000_301000 METAL6_302000_305000 0.008
R_VDD3_10610 METAL6_302000_305000 METAL6_302000_313000 0.016
R_VDD3_10611 METAL6_302000_313000 METAL6_302000_317000 0.008
R_VDD3_10612 METAL6_302000_317000 METAL6_300000_317000 0.004
R_VDD3_10613 METAL6_300000_317000 METAL6_293000_317000 0.014
R_VDD3_10614 METAL6_293000_317000 METAL6_288000_317000 0.01
R_VDD3_10615 METAL6_288000_317000 METAL6_281000_317000 0.014
R_VDD3_10616 METAL6_281000_317000 METAL6_276000_317000 0.01
R_VDD3_10617 METAL6_276000_317000 METAL5_276000_317000 0.1
R_VDD3_10618 METAL5_276000_317000 METAL5_276000_329000 0.048
R_VDD3_10619 METAL5_276000_329000 METAL5_276000_341000 0.048
R_VDD3_10620 METAL5_276000_341000 METAL5_276000_353000 0.048
R_VDD3_10621 METAL5_276000_353000 METAL5_276000_365000 0.048
R_VDD3_10622 METAL5_276000_365000 METAL5_276000_377000 0.048
R_VDD3_10623 METAL5_276000_377000 METAL5_276000_389000 0.048
R_VDD3_10624 METAL5_276000_389000 METAL5_276000_429000 0.16
R_VDD3_10625 METAL5_276000_429000 METAL5_276000_441000 0.048
R_VDD3_10626 METAL5_276000_441000 METAL5_276000_453000 0.048
R_VDD3_10627 METAL5_276000_453000 METAL5_276000_465000 0.048
R_VDD3_10628 METAL5_276000_465000 METAL5_276000_469000 0.016
R_VDD3_10629 METAL5_276000_469000 METAL5_276000_477000 0.032
R_VDD3_10630 METAL5_276000_477000 METAL5_281000_477000 0.02
R_VDD3_10631 METAL5_281000_477000 METAL5_288000_477000 0.028
R_VDD3_10632 METAL5_288000_477000 METAL5_293000_477000 0.02
R_VDD3_10633 METAL5_293000_477000 METAL5_300000_477000 0.028
R_VDD3_10634 METAL5_300000_477000 METAL5_300000_481000 0.016
R_VDD3_10635 METAL5_300000_481000 METAL5_300000_489000 0.032
R_VDD3_10636 METAL5_300000_489000 METAL5_300000_493000 0.016
R_VDD3_10637 METAL5_300000_493000 METAL5_300000_501000 0.032
R_VDD3_10638 METAL5_300000_501000 METAL5_300000_505000 0.016
R_VDD3_10639 METAL5_300000_505000 METAL5_300000_517000 0.048
R_VDD3_10640 METAL5_300000_517000 METAL5_300000_529000 0.048
R_VDD3_10641 METAL5_300000_529000 METAL5_300000_541000 0.048
R_VDD3_10642 METAL5_300000_541000 METAL5_300000_553000 0.048
R_VDD3_10643 METAL5_300000_553000 METAL5_300000_565000 0.048
R_VDD3_10644 METAL5_300000_565000 METAL5_300000_577000 0.048
R_VDD3_10645 METAL5_300000_577000 METAL4_300000_577000 0.1
R_VDD3_10646 METAL4_300000_577000 METAL4_300000_589000 0.096
R_VDD3_10647 METAL4_300000_589000 METAL4_300000_601000 0.096
R_VDD3_10648 METAL4_300000_601000 METAL5_300000_601000 0.1
R_VDD3_10649 METAL5_300000_601000 METAL5_300000_613000 0.048
R_VDD3_10650 METAL5_300000_613000 METAL5_300000_681000 0.272
R_VDD3_10651 METAL5_300000_681000 METAL5_300000_693000 0.048
R_VDD3_10652 METAL5_300000_693000 METAL5_300000_705000 0.048
R_VDD3_10653 METAL5_300000_705000 METAL5_300000_707000 0.008
R_VDD3_10654 METAL5_300000_707000 METAL5_300000_717000 0.04
R_VDD3_10655 METAL5_300000_717000 METAL5_300000_793000 0.304
R_VDD3_10656 METAL5_300000_793000 METAL5_300000_805000 0.048
R_VDD3_10657 METAL5_300000_805000 METAL5_300000_817000 0.048
R_VDD3_10658 METAL5_300000_817000 METAL5_300000_829000 0.048
R_VDD3_10659 METAL5_300000_829000 METAL5_300000_841000 0.048
R_VDD3_10660 METAL5_300000_841000 METAL5_300000_853000 0.048
R_VDD3_10661 METAL5_300000_853000 METAL5_300000_865000 0.048
R_VDD3_10662 METAL5_300000_865000 METAL4_300000_865000 0.1
R_VDD3_10663 METAL4_300000_865000 METAL4_300000_877000 0.096
R_VDD3_10664 METAL4_300000_877000 METAL4_300000_881000 0.032
R_VDD3_10665 METAL4_300000_881000 METAL4_300000_889000 0.064
R_VDD3_10666 METAL4_300000_889000 METAL4_300000_893000 0.032
R_VDD3_10667 METAL4_300000_893000 METAL4_300000_901000 0.064
R_VDD3_10668 METAL4_300000_901000 METAL4_300000_905000 0.032
R_VDD3_10669 METAL4_300000_905000 METAL4_300000_917000 0.096
R_VDD3_10670 METAL4_300000_917000 METAL4_300000_929000 0.096
R_VDD3_10671 METAL4_300000_929000 METAL4_300000_941000 0.096
R_VDD3_10672 METAL4_300000_941000 METAL4_300000_953000 0.096
R_VDD3_10673 METAL4_300000_953000 METAL4_300000_965000 0.096
R_VDD3_10674 METAL4_300000_965000 METAL4_300000_977000 0.096
R_VDD3_10675 METAL4_300000_977000 METAL4_300000_989000 0.096
R_VDD3_10676 METAL4_300000_989000 METAL4_300000_1001000 0.096
R_VDD3_10677 METAL4_300000_1001000 METAL4_300000_1013000 0.096
R_VDD3_10678 METAL4_300000_1013000 METAL4_300000_1025000 0.096
R_VDD3_10679 METAL4_300000_1025000 METAL4_300000_1041000 0.128
R_VDD3_10680 METAL4_300000_1041000 METAL4_300000_1053000 0.096
R_VDD3_10681 METAL4_300000_1053000 METAL4_300000_1065000 0.096
R_VDD3_10682 METAL4_300000_1065000 METAL4_300000_1077000 0.096
R_VDD3_10683 METAL4_300000_1077000 METAL4_300000_1089000 0.096
R_VDD3_10684 METAL4_300000_1089000 METAL5_300000_1089000 0.1
R_VDD3_10685 METAL5_300000_1089000 METAL5_300000_1101000 0.048
R_VDD3_10686 METAL5_300000_1101000 METAL5_300000_1153000 0.208
R_VDD3_10687 METAL5_300000_1153000 METAL5_300000_1165000 0.048
R_VDD3_10688 METAL5_300000_1165000 METAL5_300000_1177000 0.048
R_VDD3_10689 METAL5_300000_1177000 METAL5_300000_1189000 0.048
R_VDD3_10690 METAL5_300000_1189000 METAL5_300000_1201000 0.048
R_VDD3_10691 METAL5_300000_1201000 METAL5_300000_1241000 0.16
R_VDD3_10692 METAL5_300000_1241000 METAL5_302000_1241000 0.008
R_VDD3_10693 METAL5_302000_1241000 METAL5_305000_1241000 0.012
R_VDD3_10694 METAL5_305000_1241000 METAL5_312000_1241000 0.028
R_VDD3_10695 METAL5_312000_1241000 METAL5_314000_1241000 0.008
R_VDD3_10696 METAL5_314000_1241000 METAL5_318000_1241000 0.016
R_VDD3_10697 METAL5_318000_1241000 METAL5_324000_1241000 0.024
R_VDD3_10698 METAL5_324000_1241000 METAL5_324000_1253000 0.048
R_VDD3_10699 METAL5_324000_1253000 METAL5_324000_1265000 0.048
R_VDD3_10700 METAL5_324000_1265000 METAL5_324000_1277000 0.048
R_VDD3_10701 METAL5_324000_1277000 METAL6_324000_1277000 0.1
R_VDD3_10702 METAL6_324000_1277000 METAL6_324000_1289000 0.024
R_VDD3_10703 METAL6_324000_1289000 METAL6_324000_1357000 0.136
R_VDD3_10704 METAL6_324000_1357000 METAL6_324000_1369000 0.024
R_VDD3_10705 METAL6_324000_1369000 METAL6_324000_1381000 0.024
R_VDD3_10706 METAL6_324000_1381000 METAL6_326000_1381000 0.004
R_VDD3_10707 METAL6_326000_1381000 METAL5_326000_1381000 0.1
R_VDD3_10708 METAL5_326000_1381000 METAL4_326000_1381000 0.1
R_VDD3_10709 METAL4_326000_1381000 METAL4_326000_1393000 0.096
R_VDD3_10710 METAL4_326000_1393000 METAL4_326000_1405000 0.096
R_VDD3_10711 METAL4_326000_1405000 METAL5_326000_1405000 0.1
R_VDD3_10712 METAL5_326000_1405000 METAL5_326000_1407000 0.008
R_VDD3_10713 METAL5_326000_1407000 METAL5_326000_1417000 0.04
R_VDD3_10714 METAL5_326000_1417000 METAL5_326000_1529000 0.448
R_VDD3_10715 METAL5_326000_1529000 METAL5_326000_1541000 0.048
R_VDD3_10716 METAL5_326000_1541000 METAL4_326000_1541000 0.1
R_VDD3_10717 METAL4_326000_1541000 METAL4_326000_1553000 0.096
R_VDD3_10718 METAL4_326000_1553000 METAL4_326000_1565000 0.096
R_VDD3_10719 METAL4_326000_1565000 METAL5_326000_1565000 0.1
R_VDD3_10720 METAL5_326000_1565000 METAL5_326000_1577000 0.048
R_VDD3_10721 METAL5_326000_1577000 METAL5_326000_1629000 0.208
R_VDD3_10722 METAL5_326000_1629000 METAL5_326000_1641000 0.048
R_VDD3_10723 METAL5_326000_1641000 METAL5_326000_1653000 0.048
R_VDD3_10724 METAL5_326000_1653000 METAL4_326000_1653000 0.1
R_VDD3_10725 METAL4_326000_1653000 METAL4_326000_1665000 0.096
R_VDD3_10726 METAL4_326000_1665000 METAL4_326000_1677000 0.096
R_VDD3_10727 METAL4_326000_1677000 METAL5_326000_1677000 0.1
R_VDD3_10728 METAL5_326000_1677000 METAL5_326000_1689000 0.048
R_VDD3_10729 METAL5_326000_1689000 METAL5_326000_1753000 0.256
R_VDD3_10730 METAL5_326000_1753000 METAL5_326000_1765000 0.048
R_VDD3_10731 METAL5_326000_1765000 METAL5_326000_1777000 0.048
R_VDD3_10732 METAL5_326000_1777000 METAL5_326000_1789000 0.048
R_VDD3_10733 METAL5_326000_1789000 METAL5_326000_1817000 0.112
R_VDD3_10734 METAL5_326000_1817000 METAL5_326000_1829000 0.048
R_VDD3_10735 METAL5_326000_1829000 METAL5_326000_1841000 0.048
R_VDD3_10736 METAL5_326000_1841000 METAL5_326000_1853000 0.048
R_VDD3_10737 METAL5_326000_1853000 METAL5_326000_1865000 0.048
R_VDD3_10738 METAL5_326000_1865000 METAL5_326000_1877000 0.048
R_VDD3_10739 METAL5_326000_1877000 METAL5_326000_1917000 0.16
R_VDD3_10740 METAL5_326000_1917000 METAL5_326000_1929000 0.048
R_VDD3_10741 METAL5_326000_1929000 METAL5_328000_1929000 0.008
R_VDD3_10742 METAL5_328000_1929000 METAL5_330000_1929000 0.008
R_VDD3_10743 METAL5_330000_1929000 METAL4_330000_1929000 0.1
R_VDD3_10744 METAL4_330000_1929000 METAL4_336000_1929000 0.048
R_VDD3_10745 METAL4_336000_1929000 METAL4_336000_1941000 0.096
R_VDD3_10746 METAL4_336000_1941000 METAL4_336000_1953000 0.096
R_VDD3_10747 METAL4_336000_1953000 METAL4_336000_1965000 0.096
R_VDD3_10748 METAL4_336000_1965000 METAL4_336000_1977000 0.096
R_VDD3_10749 METAL4_336000_1977000 METAL4_336000_1989000 0.096
R_VDD3_10750 METAL4_336000_1989000 METAL5_336000_1989000 0.1
R_VDD3_10751 METAL5_336000_1989000 METAL5_336000_2001000 0.048
R_VDD3_10752 METAL5_336000_2001000 METAL5_336000_2013000 0.048
R_VDD3_10753 METAL5_336000_2013000 METAL5_336000_2093000 0.32
R_VDD3_10754 METAL5_336000_2093000 METAL5_336000_2107000 0.056
R_VDD3_10755 METAL5_336000_2107000 METAL5_336000_2217000 0.44
R_VDD3_10756 METAL5_336000_2217000 METAL5_336000_2229000 0.048
R_VDD3_10757 METAL5_336000_2229000 METAL5_336000_2241000 0.048
R_VDD3_10758 METAL5_336000_2241000 METAL5_336000_2253000 0.048
R_VDD3_10759 METAL5_336000_2253000 METAL5_336000_2265000 0.048
R_VDD3_10760 METAL5_336000_2265000 METAL5_336000_2277000 0.048
R_VDD3_10761 METAL5_336000_2277000 METAL5_336000_2341000 0.256
R_VDD3_10762 METAL5_336000_2341000 METAL5_336000_2353000 0.048
R_VDD3_10763 METAL5_336000_2353000 METAL5_336000_2365000 0.048
R_VDD3_10764 METAL5_336000_2365000 METAL5_336000_2377000 0.048
R_VDD3_10765 METAL5_336000_2377000 METAL4_336000_2377000 0.1
R_VDD3_10766 METAL4_336000_2377000 METAL4_330000_2377000 0.048
R_VDD3_10767 METAL4_330000_2377000 METAL4_328000_2377000 0.016
R_VDD3_10768 METAL4_328000_2377000 METAL4_326000_2377000 0.016
R_VDD3_10769 METAL4_326000_2377000 METAL4_324000_2377000 0.016
R_VDD3_10770 METAL4_324000_2377000 METAL4_318000_2377000 0.048
R_VDD3_10771 METAL4_318000_2377000 METAL4_314000_2377000 0.032
R_VDD3_10772 METAL4_314000_2377000 METAL4_312000_2377000 0.016
R_VDD3_10773 METAL4_312000_2377000 METAL4_305000_2377000 0.056
R_VDD3_10774 METAL4_305000_2377000 METAL4_302000_2377000 0.024
R_VDD3_10775 METAL4_302000_2377000 METAL4_300000_2377000 0.016
R_VDD3_10776 METAL4_300000_2377000 METAL4_293000_2377000 0.056
R_VDD3_10777 METAL4_293000_2377000 METAL4_288000_2377000 0.04
R_VDD3_10778 METAL4_288000_2377000 METAL4_281000_2377000 0.056
R_VDD3_10779 METAL4_281000_2377000 METAL4_276000_2377000 0.04
R_VDD3_10780 METAL4_276000_2377000 METAL4_269000_2377000 0.056
R_VDD3_10781 METAL4_269000_2377000 METAL4_264000_2377000 0.04
R_VDD3_10782 METAL4_264000_2377000 METAL4_257000_2377000 0.056
R_VDD3_10783 METAL4_257000_2377000 METAL5_257000_2377000 0.1
R_VDD3_10784 METAL5_257000_2377000 METAL6_257000_2377000 0.1
R_VDD3_10785 METAL6_257000_2377000 METAL6_257000_2453000 0.152
R_VDD3_10786 METAL6_257000_2453000 METAL6_257000_2465000 0.024
R_VDD3_10787 METAL6_555000_2465000 METAL6_543000_2465000 0.024
R_VDD3_10788 METAL6_378000_153000 METAL5_378000_153000 0.1
R_VDD3_10789 METAL5_378000_153000 METAL5_384000_153000 0.024
R_VDD3_10790 METAL5_384000_153000 METAL5_384000_157000 0.016
R_VDD3_10791 METAL5_384000_157000 METAL5_384000_165000 0.032
R_VDD3_10792 METAL5_384000_165000 METAL5_384000_169000 0.016
R_VDD3_10793 METAL5_384000_169000 METAL5_384000_177000 0.032
R_VDD3_10794 METAL5_384000_177000 METAL5_384000_181000 0.016
R_VDD3_10795 METAL5_384000_181000 METAL5_384000_193000 0.048
R_VDD3_10796 METAL5_384000_193000 METAL5_384000_205000 0.048
R_VDD3_10797 METAL5_384000_205000 METAL5_384000_217000 0.048
R_VDD3_10798 METAL5_384000_217000 METAL5_384000_229000 0.048
R_VDD3_10799 METAL5_384000_229000 METAL5_384000_233000 0.016
R_VDD3_10800 METAL5_384000_233000 METAL5_384000_241000 0.032
R_VDD3_10801 METAL5_384000_241000 METAL5_384000_245000 0.016
R_VDD3_10802 METAL5_384000_245000 METAL5_384000_253000 0.032
R_VDD3_10803 METAL5_384000_253000 METAL5_384000_257000 0.016
R_VDD3_10804 METAL5_384000_257000 METAL5_384000_265000 0.032
R_VDD3_10805 METAL5_384000_265000 METAL5_384000_269000 0.016
R_VDD3_10806 METAL5_384000_269000 METAL5_384000_277000 0.032
R_VDD3_10807 METAL5_384000_277000 METAL5_384000_281000 0.016
R_VDD3_10808 METAL5_384000_281000 METAL5_384000_289000 0.032
R_VDD3_10809 METAL5_384000_289000 METAL5_384000_293000 0.016
R_VDD3_10810 METAL5_384000_293000 METAL5_384000_301000 0.032
R_VDD3_10811 METAL5_384000_301000 METAL5_384000_305000 0.016
R_VDD3_10812 METAL5_384000_305000 METAL5_384000_313000 0.032
R_VDD3_10813 METAL5_384000_313000 METAL5_384000_317000 0.016
R_VDD3_10814 METAL5_384000_317000 METAL4_384000_317000 0.1
R_VDD3_10815 METAL4_384000_317000 METAL4_384000_329000 0.096
R_VDD3_10816 METAL4_384000_329000 METAL4_384000_341000 0.096
R_VDD3_10817 METAL4_384000_341000 METAL4_384000_353000 0.096
R_VDD3_10818 METAL4_384000_353000 METAL4_384000_365000 0.096
R_VDD3_10819 METAL4_384000_365000 METAL4_384000_377000 0.096
R_VDD3_10820 METAL4_384000_377000 METAL5_384000_377000 0.1
R_VDD3_10821 METAL5_384000_377000 METAL5_384000_389000 0.048
R_VDD3_10822 METAL5_384000_389000 METAL5_384000_429000 0.16
R_VDD3_10823 METAL5_384000_429000 METAL5_384000_441000 0.048
R_VDD3_10824 METAL5_384000_441000 METAL5_384000_453000 0.048
R_VDD3_10825 METAL5_384000_453000 METAL5_386000_453000 0.008
R_VDD3_10826 METAL5_386000_453000 METAL5_388000_453000 0.008
R_VDD3_10827 METAL5_388000_453000 METAL5_390000_453000 0.008
R_VDD3_10828 METAL5_390000_453000 METAL5_398000_453000 0.032
R_VDD3_10829 METAL5_398000_453000 METAL5_400000_453000 0.008
R_VDD3_10830 METAL5_400000_453000 METAL5_402000_453000 0.008
R_VDD3_10831 METAL5_402000_453000 METAL5_410000_453000 0.032
R_VDD3_10832 METAL5_410000_453000 METAL5_412000_453000 0.008
R_VDD3_10833 METAL5_412000_453000 METAL5_414000_453000 0.008
R_VDD3_10834 METAL5_414000_453000 METAL5_422000_453000 0.032
R_VDD3_10835 METAL5_422000_453000 METAL5_424000_453000 0.008
R_VDD3_10836 METAL5_424000_453000 METAL5_426000_453000 0.008
R_VDD3_10837 METAL5_426000_453000 METAL5_434000_453000 0.032
R_VDD3_10838 METAL5_434000_453000 METAL5_436000_453000 0.008
R_VDD3_10839 METAL5_436000_453000 METAL5_438000_453000 0.008
R_VDD3_10840 METAL5_438000_453000 METAL5_440000_453000 0.008
R_VDD3_10841 METAL5_440000_453000 METAL5_446000_453000 0.024
R_VDD3_10842 METAL5_446000_453000 METAL5_448000_453000 0.008
R_VDD3_10843 METAL5_448000_453000 METAL5_450000_453000 0.008
R_VDD3_10844 METAL5_450000_453000 METAL5_450000_465000 0.048
R_VDD3_10845 METAL5_450000_465000 METAL5_450000_469000 0.016
R_VDD3_10846 METAL5_450000_469000 METAL5_450000_477000 0.032
R_VDD3_10847 METAL5_450000_477000 METAL5_450000_481000 0.016
R_VDD3_10848 METAL5_450000_481000 METAL5_450000_489000 0.032
R_VDD3_10849 METAL5_450000_489000 METAL5_450000_493000 0.016
R_VDD3_10850 METAL5_450000_493000 METAL5_450000_501000 0.032
R_VDD3_10851 METAL5_450000_501000 METAL5_450000_505000 0.016
R_VDD3_10852 METAL5_450000_505000 METAL5_450000_517000 0.048
R_VDD3_10853 METAL5_450000_517000 METAL5_450000_529000 0.048
R_VDD3_10854 METAL5_450000_529000 METAL5_450000_541000 0.048
R_VDD3_10855 METAL5_450000_541000 METAL5_450000_553000 0.048
R_VDD3_10856 METAL5_450000_553000 METAL5_450000_565000 0.048
R_VDD3_10857 METAL5_450000_565000 METAL4_450000_565000 0.1
R_VDD3_10858 METAL4_450000_565000 METAL4_450000_577000 0.096
R_VDD3_10859 METAL4_450000_577000 METAL4_450000_589000 0.096
R_VDD3_10860 METAL4_450000_589000 METAL4_450000_601000 0.096
R_VDD3_10861 METAL4_450000_601000 METAL4_450000_613000 0.096
R_VDD3_10862 METAL4_450000_613000 METAL5_450000_613000 0.1
R_VDD3_10863 METAL5_450000_613000 METAL5_450000_681000 0.272
R_VDD3_10864 METAL5_450000_681000 METAL5_450000_693000 0.048
R_VDD3_10865 METAL5_450000_693000 METAL5_450000_705000 0.048
R_VDD3_10866 METAL5_450000_705000 METAL5_450000_707000 0.008
R_VDD3_10867 METAL5_450000_707000 METAL5_450000_717000 0.04
R_VDD3_10868 METAL5_450000_717000 METAL5_450000_793000 0.304
R_VDD3_10869 METAL5_450000_793000 METAL5_452000_793000 0.008
R_VDD3_10870 METAL5_452000_793000 METAL5_458000_793000 0.024
R_VDD3_10871 METAL5_458000_793000 METAL5_460000_793000 0.008
R_VDD3_10872 METAL5_460000_793000 METAL5_462000_793000 0.008
R_VDD3_10873 METAL5_462000_793000 METAL5_464000_793000 0.008
R_VDD3_10874 METAL5_464000_793000 METAL5_472000_793000 0.032
R_VDD3_10875 METAL5_472000_793000 METAL5_474000_793000 0.008
R_VDD3_10876 METAL5_474000_793000 METAL5_476000_793000 0.008
R_VDD3_10877 METAL5_476000_793000 METAL5_484000_793000 0.032
R_VDD3_10878 METAL5_484000_793000 METAL5_484000_805000 0.048
R_VDD3_10879 METAL5_484000_805000 METAL5_484000_817000 0.048
R_VDD3_10880 METAL5_484000_817000 METAL5_484000_829000 0.048
R_VDD3_10881 METAL5_484000_829000 METAL5_484000_841000 0.048
R_VDD3_10882 METAL5_484000_841000 METAL5_484000_853000 0.048
R_VDD3_10883 METAL5_484000_853000 METAL5_484000_865000 0.048
R_VDD3_10884 METAL5_484000_865000 METAL4_484000_865000 0.1
R_VDD3_10885 METAL4_484000_865000 METAL4_484000_877000 0.096
R_VDD3_10886 METAL4_484000_877000 METAL4_484000_881000 0.032
R_VDD3_10887 METAL4_484000_881000 METAL4_484000_889000 0.064
R_VDD3_10888 METAL4_484000_889000 METAL5_484000_889000 0.1
R_VDD3_10889 METAL5_484000_889000 METAL5_484000_893000 0.016
R_VDD3_10890 METAL5_484000_893000 METAL5_484000_901000 0.032
R_VDD3_10891 METAL5_484000_901000 METAL5_484000_905000 0.016
R_VDD3_10892 METAL5_484000_905000 METAL5_484000_917000 0.048
R_VDD3_10893 METAL5_484000_917000 METAL5_484000_929000 0.048
R_VDD3_10894 METAL5_484000_929000 METAL5_484000_941000 0.048
R_VDD3_10895 METAL5_484000_941000 METAL5_484000_953000 0.048
R_VDD3_10896 METAL5_484000_953000 METAL5_484000_965000 0.048
R_VDD3_10897 METAL5_484000_965000 METAL5_484000_977000 0.048
R_VDD3_10898 METAL5_484000_977000 METAL5_484000_989000 0.048
R_VDD3_10899 METAL5_484000_989000 METAL5_484000_1001000 0.048
R_VDD3_10900 METAL5_484000_1001000 METAL5_484000_1013000 0.048
R_VDD3_10901 METAL5_484000_1013000 METAL5_484000_1025000 0.048
R_VDD3_10902 METAL5_484000_1025000 METAL5_484000_1041000 0.064
R_VDD3_10903 METAL5_484000_1041000 METAL5_484000_1053000 0.048
R_VDD3_10904 METAL5_484000_1053000 METAL5_484000_1065000 0.048
R_VDD3_10905 METAL5_484000_1065000 METAL4_484000_1065000 0.1
R_VDD3_10906 METAL4_484000_1065000 METAL4_484000_1077000 0.096
R_VDD3_10907 METAL4_484000_1077000 METAL4_484000_1089000 0.096
R_VDD3_10908 METAL4_484000_1089000 METAL5_484000_1089000 0.1
R_VDD3_10909 METAL5_484000_1089000 METAL5_484000_1101000 0.048
R_VDD3_10910 METAL5_484000_1101000 METAL5_484000_1153000 0.208
R_VDD3_10911 METAL5_484000_1153000 METAL5_484000_1165000 0.048
R_VDD3_10912 METAL5_484000_1165000 METAL4_484000_1165000 0.1
R_VDD3_10913 METAL4_484000_1165000 METAL4_484000_1177000 0.096
R_VDD3_10914 METAL4_484000_1177000 METAL4_484000_1189000 0.096
R_VDD3_10915 METAL4_484000_1189000 METAL5_484000_1189000 0.1
R_VDD3_10916 METAL5_484000_1189000 METAL5_484000_1201000 0.048
R_VDD3_10917 METAL5_484000_1201000 METAL5_484000_1229000 0.112
R_VDD3_10918 METAL5_484000_1229000 METAL5_484000_1241000 0.048
R_VDD3_10919 METAL5_484000_1241000 METAL5_484000_1253000 0.048
R_VDD3_10920 METAL5_484000_1253000 METAL5_484000_1265000 0.048
R_VDD3_10921 METAL5_484000_1265000 METAL5_484000_1277000 0.048
R_VDD3_10922 METAL5_484000_1277000 METAL5_484000_1289000 0.048
R_VDD3_10923 METAL5_484000_1289000 METAL5_484000_1357000 0.272
R_VDD3_10924 METAL5_484000_1357000 METAL5_484000_1369000 0.048
R_VDD3_10925 METAL5_484000_1369000 METAL4_484000_1369000 0.1
R_VDD3_10926 METAL4_484000_1369000 METAL4_484000_1381000 0.096
R_VDD3_10927 METAL4_484000_1381000 METAL4_484000_1393000 0.096
R_VDD3_10928 METAL4_484000_1393000 METAL5_484000_1393000 0.1
R_VDD3_10929 METAL5_484000_1393000 METAL5_484000_1405000 0.048
R_VDD3_10930 METAL5_484000_1405000 METAL5_484000_1407000 0.008
R_VDD3_10931 METAL5_484000_1407000 METAL5_484000_1417000 0.04
R_VDD3_10932 METAL5_484000_1417000 METAL5_484000_1529000 0.448
R_VDD3_10933 METAL5_484000_1529000 METAL5_484000_1541000 0.048
R_VDD3_10934 METAL5_484000_1541000 METAL5_484000_1553000 0.048
R_VDD3_10935 METAL5_484000_1553000 METAL5_484000_1565000 0.048
R_VDD3_10936 METAL5_484000_1565000 METAL5_484000_1577000 0.048
R_VDD3_10937 METAL5_484000_1577000 METAL5_484000_1629000 0.208
R_VDD3_10938 METAL5_484000_1629000 METAL5_484000_1641000 0.048
R_VDD3_10939 METAL5_484000_1641000 METAL5_484000_1653000 0.048
R_VDD3_10940 METAL5_484000_1653000 METAL5_484000_1665000 0.048
R_VDD3_10941 METAL5_484000_1665000 METAL5_484000_1677000 0.048
R_VDD3_10942 METAL5_484000_1677000 METAL5_484000_1689000 0.048
R_VDD3_10943 METAL5_484000_1689000 METAL5_484000_1753000 0.256
R_VDD3_10944 METAL5_484000_1753000 METAL5_484000_1765000 0.048
R_VDD3_10945 METAL5_484000_1765000 METAL5_484000_1777000 0.048
R_VDD3_10946 METAL5_484000_1777000 METAL5_484000_1789000 0.048
R_VDD3_10947 METAL5_484000_1789000 METAL5_484000_1817000 0.112
R_VDD3_10948 METAL5_484000_1817000 METAL5_484000_1829000 0.048
R_VDD3_10949 METAL5_484000_1829000 METAL5_484000_1841000 0.048
R_VDD3_10950 METAL5_484000_1841000 METAL5_484000_1853000 0.048
R_VDD3_10951 METAL5_484000_1853000 METAL5_484000_1865000 0.048
R_VDD3_10952 METAL5_484000_1865000 METAL5_484000_1877000 0.048
R_VDD3_10953 METAL5_484000_1877000 METAL5_484000_1917000 0.16
R_VDD3_10954 METAL5_484000_1917000 METAL5_484000_1929000 0.048
R_VDD3_10955 METAL5_484000_1929000 METAL4_484000_1929000 0.1
R_VDD3_10956 METAL4_484000_1929000 METAL4_484000_1941000 0.096
R_VDD3_10957 METAL4_484000_1941000 METAL4_484000_1953000 0.096
R_VDD3_10958 METAL4_484000_1953000 METAL4_484000_1965000 0.096
R_VDD3_10959 METAL4_484000_1965000 METAL4_484000_1977000 0.096
R_VDD3_10960 METAL4_484000_1977000 METAL4_484000_1989000 0.096
R_VDD3_10961 METAL4_484000_1989000 METAL5_484000_1989000 0.1
R_VDD3_10962 METAL5_484000_1989000 METAL5_484000_2001000 0.048
R_VDD3_10963 METAL5_484000_2001000 METAL5_484000_2013000 0.048
R_VDD3_10964 METAL5_484000_2013000 METAL5_484000_2093000 0.32
R_VDD3_10965 METAL5_484000_2093000 METAL5_484000_2107000 0.056
R_VDD3_10966 METAL5_484000_2107000 METAL5_484000_2217000 0.44
R_VDD3_10967 METAL5_484000_2217000 METAL5_484000_2229000 0.048
R_VDD3_10968 METAL5_484000_2229000 METAL5_484000_2241000 0.048
R_VDD3_10969 METAL5_484000_2241000 METAL5_484000_2253000 0.048
R_VDD3_10970 METAL5_484000_2253000 METAL5_484000_2265000 0.048
R_VDD3_10971 METAL5_484000_2265000 METAL5_484000_2277000 0.048
R_VDD3_10972 METAL5_484000_2277000 METAL5_484000_2341000 0.256
R_VDD3_10973 METAL5_484000_2341000 METAL5_484000_2353000 0.048
R_VDD3_10974 METAL5_484000_2353000 METAL5_484000_2365000 0.048
R_VDD3_10975 METAL5_484000_2365000 METAL5_484000_2377000 0.048
R_VDD3_10976 METAL5_484000_2377000 METAL5_486000_2377000 0.008
R_VDD3_10977 METAL5_486000_2377000 METAL5_488000_2377000 0.008
R_VDD3_10978 METAL5_488000_2377000 METAL5_500000_2377000 0.048
R_VDD3_10979 METAL5_500000_2377000 METAL5_507000_2377000 0.028
R_VDD3_10980 METAL5_507000_2377000 METAL5_512000_2377000 0.02
R_VDD3_10981 METAL5_512000_2377000 METAL5_519000_2377000 0.028
R_VDD3_10982 METAL5_519000_2377000 METAL4_519000_2377000 0.1
R_VDD3_10983 METAL4_519000_2377000 METAL4_524000_2377000 0.04
R_VDD3_10984 METAL4_524000_2377000 METAL4_531000_2377000 0.056
R_VDD3_10985 METAL4_531000_2377000 METAL4_543000_2377000 0.096
R_VDD3_10986 METAL4_543000_2377000 METAL5_543000_2377000 0.1
R_VDD3_10987 METAL5_543000_2377000 METAL6_543000_2377000 0.1
R_VDD3_10988 METAL6_543000_2377000 METAL6_543000_2389000 0.024
R_VDD3_10989 METAL6_543000_2389000 METAL6_543000_2453000 0.128
R_VDD3_10990 METAL6_543000_2453000 METAL6_543000_2465000 0.024
R_VDD3_10991 METAL6_555000_1765000 METAL6_543000_1765000 0.024
R_VDD3_10992 METAL5_400000_8000 METAL4_400000_8000 0.1
R_VDD3_10993 METAL4_400000_8000 METAL4_400000_20000 0.096
R_VDD3_10994 METAL4_400000_20000 METAL4_400000_32000 0.096
R_VDD3_10995 METAL4_400000_32000 METAL5_400000_32000 0.1
R_VDD3_10996 METAL5_400000_32000 METAL5_400000_69000 0.148
R_VDD3_10997 METAL5_400000_69000 METAL5_400000_81000 0.048
R_VDD3_10998 METAL5_400000_81000 METAL5_400000_93000 0.048
R_VDD3_10999 METAL5_400000_93000 METAL5_400000_105000 0.048
R_VDD3_11000 METAL5_400000_105000 METAL5_400000_117000 0.048
R_VDD3_11001 METAL5_400000_117000 METAL5_398000_117000 0.008
R_VDD3_11002 METAL5_398000_117000 METAL5_396000_117000 0.008
R_VDD3_11003 METAL5_396000_117000 METAL5_390000_117000 0.024
R_VDD3_11004 METAL5_390000_117000 METAL5_390000_129000 0.048
R_VDD3_11005 METAL5_390000_129000 METAL5_390000_141000 0.048
R_VDD3_11006 METAL5_390000_141000 METAL5_396000_141000 0.024
R_VDD3_11007 METAL5_396000_141000 METAL5_396000_145000 0.016
R_VDD3_11008 METAL5_396000_145000 METAL5_396000_153000 0.032
R_VDD3_11009 METAL5_396000_153000 METAL5_396000_157000 0.016
R_VDD3_11010 METAL5_396000_157000 METAL5_396000_165000 0.032
R_VDD3_11011 METAL5_396000_165000 METAL5_396000_169000 0.016
R_VDD3_11012 METAL5_396000_169000 METAL5_396000_177000 0.032
R_VDD3_11013 METAL5_396000_177000 METAL5_396000_181000 0.016
R_VDD3_11014 METAL5_396000_181000 METAL5_396000_193000 0.048
R_VDD3_11015 METAL5_396000_193000 METAL5_396000_205000 0.048
R_VDD3_11016 METAL5_396000_205000 METAL5_396000_217000 0.048
R_VDD3_11017 METAL5_396000_217000 METAL5_396000_229000 0.048
R_VDD3_11018 METAL5_396000_229000 METAL5_396000_233000 0.016
R_VDD3_11019 METAL5_396000_233000 METAL5_396000_241000 0.032
R_VDD3_11020 METAL5_396000_241000 METAL5_396000_245000 0.016
R_VDD3_11021 METAL5_396000_245000 METAL5_396000_253000 0.032
R_VDD3_11022 METAL5_396000_253000 METAL5_396000_257000 0.016
R_VDD3_11023 METAL5_396000_257000 METAL5_396000_265000 0.032
R_VDD3_11024 METAL5_396000_265000 METAL5_396000_269000 0.016
R_VDD3_11025 METAL5_396000_269000 METAL5_396000_277000 0.032
R_VDD3_11026 METAL5_396000_277000 METAL5_396000_281000 0.016
R_VDD3_11027 METAL5_396000_281000 METAL5_396000_289000 0.032
R_VDD3_11028 METAL5_396000_289000 METAL5_396000_293000 0.016
R_VDD3_11029 METAL5_396000_293000 METAL5_396000_301000 0.032
R_VDD3_11030 METAL5_396000_301000 METAL5_396000_305000 0.016
R_VDD3_11031 METAL5_396000_305000 METAL5_396000_313000 0.032
R_VDD3_11032 METAL5_396000_313000 METAL5_396000_317000 0.016
R_VDD3_11033 METAL5_396000_317000 METAL4_396000_317000 0.1
R_VDD3_11034 METAL4_396000_317000 METAL4_396000_329000 0.096
R_VDD3_11035 METAL4_396000_329000 METAL4_396000_341000 0.096
R_VDD3_11036 METAL4_396000_341000 METAL4_396000_353000 0.096
R_VDD3_11037 METAL4_396000_353000 METAL4_396000_365000 0.096
R_VDD3_11038 METAL4_396000_365000 METAL4_396000_377000 0.096
R_VDD3_11039 METAL4_396000_377000 METAL5_396000_377000 0.1
R_VDD3_11040 METAL5_396000_377000 METAL5_396000_389000 0.048
R_VDD3_11041 METAL5_396000_389000 METAL5_396000_429000 0.16
R_VDD3_11042 METAL5_396000_429000 METAL5_396000_441000 0.048
R_VDD3_11043 METAL5_396000_441000 METAL5_398000_441000 0.008
R_VDD3_11044 METAL5_398000_441000 METAL5_400000_441000 0.008
R_VDD3_11045 METAL5_400000_441000 METAL5_402000_441000 0.008
R_VDD3_11046 METAL5_402000_441000 METAL5_410000_441000 0.032
R_VDD3_11047 METAL5_410000_441000 METAL5_412000_441000 0.008
R_VDD3_11048 METAL5_412000_441000 METAL5_414000_441000 0.008
R_VDD3_11049 METAL5_414000_441000 METAL5_422000_441000 0.032
R_VDD3_11050 METAL5_422000_441000 METAL5_424000_441000 0.008
R_VDD3_11051 METAL5_424000_441000 METAL5_426000_441000 0.008
R_VDD3_11052 METAL5_426000_441000 METAL5_434000_441000 0.032
R_VDD3_11053 METAL5_434000_441000 METAL5_436000_441000 0.008
R_VDD3_11054 METAL5_436000_441000 METAL5_438000_441000 0.008
R_VDD3_11055 METAL5_438000_441000 METAL5_440000_441000 0.008
R_VDD3_11056 METAL5_440000_441000 METAL5_446000_441000 0.024
R_VDD3_11057 METAL5_446000_441000 METAL5_448000_441000 0.008
R_VDD3_11058 METAL5_448000_441000 METAL5_450000_441000 0.008
R_VDD3_11059 METAL5_450000_441000 METAL5_452000_441000 0.008
R_VDD3_11060 METAL5_452000_441000 METAL5_458000_441000 0.024
R_VDD3_11061 METAL5_458000_441000 METAL5_460000_441000 0.008
R_VDD3_11062 METAL5_460000_441000 METAL5_462000_441000 0.008
R_VDD3_11063 METAL5_462000_441000 METAL5_462000_453000 0.048
R_VDD3_11064 METAL5_462000_453000 METAL5_462000_465000 0.048
R_VDD3_11065 METAL5_462000_465000 METAL5_462000_469000 0.016
R_VDD3_11066 METAL5_462000_469000 METAL5_462000_477000 0.032
R_VDD3_11067 METAL5_462000_477000 METAL5_462000_481000 0.016
R_VDD3_11068 METAL5_462000_481000 METAL5_462000_489000 0.032
R_VDD3_11069 METAL5_462000_489000 METAL5_462000_493000 0.016
R_VDD3_11070 METAL5_462000_493000 METAL5_462000_501000 0.032
R_VDD3_11071 METAL5_462000_501000 METAL5_462000_505000 0.016
R_VDD3_11072 METAL5_462000_505000 METAL5_462000_517000 0.048
R_VDD3_11073 METAL5_462000_517000 METAL5_462000_529000 0.048
R_VDD3_11074 METAL5_462000_529000 METAL5_462000_541000 0.048
R_VDD3_11075 METAL5_462000_541000 METAL5_464000_541000 0.008
R_VDD3_11076 METAL5_464000_541000 METAL5_472000_541000 0.032
R_VDD3_11077 METAL5_472000_541000 METAL5_474000_541000 0.008
R_VDD3_11078 METAL5_474000_541000 METAL5_476000_541000 0.008
R_VDD3_11079 METAL5_476000_541000 METAL5_484000_541000 0.032
R_VDD3_11080 METAL5_484000_541000 METAL5_486000_541000 0.008
R_VDD3_11081 METAL5_486000_541000 METAL5_488000_541000 0.008
R_VDD3_11082 METAL5_488000_541000 METAL5_496000_541000 0.032
R_VDD3_11083 METAL5_496000_541000 METAL5_500000_541000 0.016
R_VDD3_11084 METAL5_500000_541000 METAL5_507000_541000 0.028
R_VDD3_11085 METAL5_507000_541000 METAL5_512000_541000 0.02
R_VDD3_11086 METAL5_512000_541000 METAL5_512000_553000 0.048
R_VDD3_11087 METAL5_512000_553000 METAL4_512000_553000 0.1
R_VDD3_11088 METAL4_512000_553000 METAL4_512000_565000 0.096
R_VDD3_11089 METAL4_512000_565000 METAL4_512000_577000 0.096
R_VDD3_11090 METAL4_512000_577000 METAL4_512000_589000 0.096
R_VDD3_11091 METAL4_512000_589000 METAL4_512000_601000 0.096
R_VDD3_11092 METAL4_512000_601000 METAL4_512000_613000 0.096
R_VDD3_11093 METAL4_512000_613000 METAL5_512000_613000 0.1
R_VDD3_11094 METAL5_512000_613000 METAL5_512000_625000 0.048
R_VDD3_11095 METAL5_512000_625000 METAL5_512000_681000 0.224
R_VDD3_11096 METAL5_512000_681000 METAL5_512000_693000 0.048
R_VDD3_11097 METAL5_512000_693000 METAL5_512000_705000 0.048
R_VDD3_11098 METAL5_512000_705000 METAL5_519000_705000 0.028
R_VDD3_11099 METAL5_519000_705000 METAL5_519000_707000 0.008
R_VDD3_11100 METAL5_519000_707000 METAL5_519000_717000 0.04
R_VDD3_11101 METAL5_519000_717000 METAL5_519000_781000 0.256
R_VDD3_11102 METAL5_519000_781000 METAL5_519000_793000 0.048
R_VDD3_11103 METAL5_519000_793000 METAL5_519000_805000 0.048
R_VDD3_11104 METAL5_519000_805000 METAL5_519000_817000 0.048
R_VDD3_11105 METAL5_519000_817000 METAL5_519000_829000 0.048
R_VDD3_11106 METAL5_519000_829000 METAL5_519000_841000 0.048
R_VDD3_11107 METAL5_519000_841000 METAL5_519000_853000 0.048
R_VDD3_11108 METAL5_519000_853000 METAL5_519000_865000 0.048
R_VDD3_11109 METAL5_519000_865000 METAL4_519000_865000 0.1
R_VDD3_11110 METAL4_519000_865000 METAL4_519000_877000 0.096
R_VDD3_11111 METAL4_519000_877000 METAL4_519000_881000 0.032
R_VDD3_11112 METAL4_519000_881000 METAL4_519000_889000 0.064
R_VDD3_11113 METAL4_519000_889000 METAL5_519000_889000 0.1
R_VDD3_11114 METAL5_519000_889000 METAL5_519000_893000 0.016
R_VDD3_11115 METAL5_519000_893000 METAL5_519000_901000 0.032
R_VDD3_11116 METAL5_519000_901000 METAL5_519000_905000 0.016
R_VDD3_11117 METAL5_519000_905000 METAL5_519000_917000 0.048
R_VDD3_11118 METAL5_519000_917000 METAL5_519000_929000 0.048
R_VDD3_11119 METAL5_519000_929000 METAL5_519000_941000 0.048
R_VDD3_11120 METAL5_519000_941000 METAL5_519000_953000 0.048
R_VDD3_11121 METAL5_519000_953000 METAL5_519000_965000 0.048
R_VDD3_11122 METAL5_519000_965000 METAL5_519000_977000 0.048
R_VDD3_11123 METAL5_519000_977000 METAL5_519000_989000 0.048
R_VDD3_11124 METAL5_519000_989000 METAL5_519000_1001000 0.048
R_VDD3_11125 METAL5_519000_1001000 METAL5_519000_1013000 0.048
R_VDD3_11126 METAL5_519000_1013000 METAL5_519000_1025000 0.048
R_VDD3_11127 METAL5_519000_1025000 METAL5_519000_1041000 0.064
R_VDD3_11128 METAL5_519000_1041000 METAL5_519000_1053000 0.048
R_VDD3_11129 METAL5_519000_1053000 METAL5_519000_1065000 0.048
R_VDD3_11130 METAL5_519000_1065000 METAL4_519000_1065000 0.1
R_VDD3_11131 METAL4_519000_1065000 METAL4_519000_1077000 0.096
R_VDD3_11132 METAL4_519000_1077000 METAL4_519000_1089000 0.096
R_VDD3_11133 METAL4_519000_1089000 METAL5_519000_1089000 0.1
R_VDD3_11134 METAL5_519000_1089000 METAL5_519000_1101000 0.048
R_VDD3_11135 METAL5_519000_1101000 METAL5_519000_1153000 0.208
R_VDD3_11136 METAL5_519000_1153000 METAL5_519000_1165000 0.048
R_VDD3_11137 METAL5_519000_1165000 METAL4_519000_1165000 0.1
R_VDD3_11138 METAL4_519000_1165000 METAL4_519000_1177000 0.096
R_VDD3_11139 METAL4_519000_1177000 METAL4_519000_1189000 0.096
R_VDD3_11140 METAL4_519000_1189000 METAL5_519000_1189000 0.1
R_VDD3_11141 METAL5_519000_1189000 METAL5_519000_1201000 0.048
R_VDD3_11142 METAL5_519000_1201000 METAL5_519000_1229000 0.112
R_VDD3_11143 METAL5_519000_1229000 METAL5_519000_1241000 0.048
R_VDD3_11144 METAL5_519000_1241000 METAL5_519000_1253000 0.048
R_VDD3_11145 METAL5_519000_1253000 METAL5_519000_1265000 0.048
R_VDD3_11146 METAL5_519000_1265000 METAL5_519000_1277000 0.048
R_VDD3_11147 METAL5_519000_1277000 METAL5_519000_1289000 0.048
R_VDD3_11148 METAL5_519000_1289000 METAL5_519000_1357000 0.272
R_VDD3_11149 METAL5_519000_1357000 METAL5_519000_1369000 0.048
R_VDD3_11150 METAL5_519000_1369000 METAL4_519000_1369000 0.1
R_VDD3_11151 METAL4_519000_1369000 METAL4_519000_1381000 0.096
R_VDD3_11152 METAL4_519000_1381000 METAL4_519000_1393000 0.096
R_VDD3_11153 METAL4_519000_1393000 METAL5_519000_1393000 0.1
R_VDD3_11154 METAL5_519000_1393000 METAL5_519000_1405000 0.048
R_VDD3_11155 METAL5_519000_1405000 METAL5_519000_1407000 0.008
R_VDD3_11156 METAL5_519000_1407000 METAL5_519000_1417000 0.04
R_VDD3_11157 METAL5_519000_1417000 METAL5_519000_1529000 0.448
R_VDD3_11158 METAL5_519000_1529000 METAL5_519000_1541000 0.048
R_VDD3_11159 METAL5_519000_1541000 METAL5_519000_1553000 0.048
R_VDD3_11160 METAL5_519000_1553000 METAL5_519000_1565000 0.048
R_VDD3_11161 METAL5_519000_1565000 METAL5_519000_1577000 0.048
R_VDD3_11162 METAL5_519000_1577000 METAL5_519000_1629000 0.208
R_VDD3_11163 METAL5_519000_1629000 METAL5_519000_1641000 0.048
R_VDD3_11164 METAL5_519000_1641000 METAL5_519000_1653000 0.048
R_VDD3_11165 METAL5_519000_1653000 METAL5_519000_1665000 0.048
R_VDD3_11166 METAL5_519000_1665000 METAL5_519000_1677000 0.048
R_VDD3_11167 METAL5_519000_1677000 METAL4_519000_1677000 0.1
R_VDD3_11168 METAL4_519000_1677000 METAL4_524000_1677000 0.04
R_VDD3_11169 METAL4_524000_1677000 METAL4_531000_1677000 0.056
R_VDD3_11170 METAL4_531000_1677000 METAL4_543000_1677000 0.096
R_VDD3_11171 METAL4_543000_1677000 METAL5_543000_1677000 0.1
R_VDD3_11172 METAL5_543000_1677000 METAL6_543000_1677000 0.1
R_VDD3_11173 METAL6_543000_1677000 METAL6_543000_1689000 0.024
R_VDD3_11174 METAL6_543000_1689000 METAL6_543000_1753000 0.128
R_VDD3_11175 METAL6_543000_1753000 METAL6_543000_1765000 0.024
R_VDD3_11176 METAL6_245000_1765000 METAL6_257000_1765000 0.024
R_VDD3_11177 METAL4_400000_8000 METAL4_398000_8000 0.016
R_VDD3_11178 METAL4_398000_8000 METAL4_396000_8000 0.016
R_VDD3_11179 METAL4_396000_8000 METAL4_390000_8000 0.048
R_VDD3_11180 METAL4_390000_8000 METAL4_388000_8000 0.016
R_VDD3_11181 METAL4_388000_8000 METAL4_388000_20000 0.096
R_VDD3_11182 METAL4_388000_20000 METAL4_388000_32000 0.096
R_VDD3_11183 METAL4_388000_32000 METAL5_388000_32000 0.1
R_VDD3_11184 METAL5_388000_32000 METAL5_386000_32000 0.008
R_VDD3_11185 METAL5_386000_32000 METAL5_384000_32000 0.008
R_VDD3_11186 METAL5_384000_32000 METAL5_378000_32000 0.024
R_VDD3_11187 METAL5_378000_32000 METAL5_376000_32000 0.008
R_VDD3_11188 METAL5_376000_32000 METAL5_374000_32000 0.008
R_VDD3_11189 METAL5_374000_32000 METAL5_372000_32000 0.008
R_VDD3_11190 METAL5_372000_32000 METAL5_366000_32000 0.024
R_VDD3_11191 METAL5_366000_32000 METAL5_364000_32000 0.008
R_VDD3_11192 METAL5_364000_32000 METAL5_362000_32000 0.008
R_VDD3_11193 METAL5_362000_32000 METAL5_360000_32000 0.008
R_VDD3_11194 METAL5_360000_32000 METAL5_354000_32000 0.024
R_VDD3_11195 METAL5_354000_32000 METAL5_352000_32000 0.008
R_VDD3_11196 METAL5_352000_32000 METAL6_352000_32000 0.1
R_VDD3_11197 METAL6_352000_32000 METAL6_352000_44000 0.024
R_VDD3_11198 METAL6_352000_44000 METAL6_352000_69000 0.05
R_VDD3_11199 METAL6_352000_69000 METAL6_350000_69000 0.004
R_VDD3_11200 METAL6_350000_69000 METAL6_348000_69000 0.004
R_VDD3_11201 METAL6_348000_69000 METAL6_342000_69000 0.012
R_VDD3_11202 METAL6_342000_69000 METAL6_342000_81000 0.024
R_VDD3_11203 METAL6_342000_81000 METAL6_342000_93000 0.024
R_VDD3_11204 METAL6_342000_93000 METAL6_342000_105000 0.024
R_VDD3_11205 METAL6_342000_105000 METAL6_342000_117000 0.024
R_VDD3_11206 METAL6_342000_117000 METAL6_342000_129000 0.024
R_VDD3_11207 METAL6_342000_129000 METAL6_342000_141000 0.024
R_VDD3_11208 METAL6_342000_141000 METAL6_342000_145000 0.008
R_VDD3_11209 METAL6_342000_145000 METAL6_340000_145000 0.004
R_VDD3_11210 METAL6_340000_145000 METAL6_338000_145000 0.004
R_VDD3_11211 METAL6_338000_145000 METAL6_336000_145000 0.004
R_VDD3_11212 METAL6_336000_145000 METAL6_330000_145000 0.012
R_VDD3_11213 METAL6_330000_145000 METAL6_330000_153000 0.016
R_VDD3_11214 METAL6_330000_153000 METAL6_330000_157000 0.008
R_VDD3_11215 METAL6_330000_157000 METAL6_328000_157000 0.004
R_VDD3_11216 METAL6_328000_157000 METAL6_326000_157000 0.004
R_VDD3_11217 METAL6_326000_157000 METAL6_324000_157000 0.004
R_VDD3_11218 METAL6_324000_157000 METAL6_318000_157000 0.012
R_VDD3_11219 METAL6_318000_157000 METAL6_318000_165000 0.016
R_VDD3_11220 METAL6_318000_165000 METAL6_318000_169000 0.008
R_VDD3_11221 METAL6_318000_169000 METAL6_314000_169000 0.008
R_VDD3_11222 METAL6_314000_169000 METAL6_312000_169000 0.004
R_VDD3_11223 METAL6_312000_169000 METAL6_306000_169000 0.012
R_VDD3_11224 METAL6_306000_169000 METAL6_306000_177000 0.016
R_VDD3_11225 METAL6_306000_177000 METAL6_306000_181000 0.008
R_VDD3_11226 METAL6_306000_181000 METAL6_306000_193000 0.024
R_VDD3_11227 METAL6_306000_193000 METAL6_306000_205000 0.024
R_VDD3_11228 METAL6_306000_205000 METAL6_306000_217000 0.024
R_VDD3_11229 METAL6_306000_217000 METAL6_306000_229000 0.024
R_VDD3_11230 METAL6_306000_229000 METAL6_305000_229000 0.002
R_VDD3_11231 METAL6_305000_229000 METAL6_302000_229000 0.006
R_VDD3_11232 METAL6_302000_229000 METAL6_302000_233000 0.008
R_VDD3_11233 METAL6_302000_233000 METAL6_302000_241000 0.016
R_VDD3_11234 METAL6_302000_241000 METAL6_302000_245000 0.008
R_VDD3_11235 METAL6_302000_245000 METAL6_302000_253000 0.016
R_VDD3_11236 METAL6_302000_253000 METAL6_302000_257000 0.008
R_VDD3_11237 METAL6_302000_257000 METAL6_302000_265000 0.016
R_VDD3_11238 METAL6_302000_265000 METAL6_302000_269000 0.008
R_VDD3_11239 METAL6_302000_269000 METAL6_302000_277000 0.016
R_VDD3_11240 METAL6_302000_277000 METAL6_302000_281000 0.008
R_VDD3_11241 METAL6_302000_281000 METAL6_300000_281000 0.004
R_VDD3_11242 METAL6_300000_281000 METAL6_293000_281000 0.014
R_VDD3_11243 METAL6_293000_281000 METAL6_290000_281000 0.006
R_VDD3_11244 METAL6_290000_281000 METAL6_290000_289000 0.016
R_VDD3_11245 METAL6_290000_289000 METAL6_290000_293000 0.008
R_VDD3_11246 METAL6_290000_293000 METAL6_290000_301000 0.016
R_VDD3_11247 METAL6_290000_301000 METAL6_290000_305000 0.008
R_VDD3_11248 METAL6_290000_305000 METAL6_288000_305000 0.004
R_VDD3_11249 METAL6_288000_305000 METAL5_288000_305000 0.1
R_VDD3_11250 METAL5_288000_305000 METAL5_288000_313000 0.032
R_VDD3_11251 METAL5_288000_313000 METAL5_288000_317000 0.016
R_VDD3_11252 METAL5_288000_317000 METAL5_288000_329000 0.048
R_VDD3_11253 METAL5_288000_329000 METAL5_288000_341000 0.048
R_VDD3_11254 METAL5_288000_341000 METAL5_288000_353000 0.048
R_VDD3_11255 METAL5_288000_353000 METAL5_288000_365000 0.048
R_VDD3_11256 METAL5_288000_365000 METAL5_288000_377000 0.048
R_VDD3_11257 METAL5_288000_377000 METAL5_288000_389000 0.048
R_VDD3_11258 METAL5_288000_389000 METAL5_288000_429000 0.16
R_VDD3_11259 METAL5_288000_429000 METAL5_288000_441000 0.048
R_VDD3_11260 METAL5_288000_441000 METAL5_288000_453000 0.048
R_VDD3_11261 METAL5_288000_453000 METAL4_288000_453000 0.1
R_VDD3_11262 METAL4_288000_453000 METAL4_288000_465000 0.096
R_VDD3_11263 METAL4_288000_465000 METAL4_288000_469000 0.032
R_VDD3_11264 METAL4_288000_469000 METAL4_288000_477000 0.064
R_VDD3_11265 METAL4_288000_477000 METAL4_288000_481000 0.032
R_VDD3_11266 METAL4_288000_481000 METAL4_288000_489000 0.064
R_VDD3_11267 METAL4_288000_489000 METAL5_288000_489000 0.1
R_VDD3_11268 METAL5_288000_489000 METAL5_288000_493000 0.016
R_VDD3_11269 METAL5_288000_493000 METAL5_288000_501000 0.032
R_VDD3_11270 METAL5_288000_501000 METAL5_288000_505000 0.016
R_VDD3_11271 METAL5_288000_505000 METAL5_288000_517000 0.048
R_VDD3_11272 METAL5_288000_517000 METAL5_288000_529000 0.048
R_VDD3_11273 METAL5_288000_529000 METAL5_288000_541000 0.048
R_VDD3_11274 METAL5_288000_541000 METAL5_288000_553000 0.048
R_VDD3_11275 METAL5_288000_553000 METAL5_288000_565000 0.048
R_VDD3_11276 METAL5_288000_565000 METAL5_288000_577000 0.048
R_VDD3_11277 METAL5_288000_577000 METAL4_288000_577000 0.1
R_VDD3_11278 METAL4_288000_577000 METAL4_288000_589000 0.096
R_VDD3_11279 METAL4_288000_589000 METAL4_288000_601000 0.096
R_VDD3_11280 METAL4_288000_601000 METAL5_288000_601000 0.1
R_VDD3_11281 METAL5_288000_601000 METAL5_288000_613000 0.048
R_VDD3_11282 METAL5_288000_613000 METAL5_288000_625000 0.048
R_VDD3_11283 METAL5_288000_625000 METAL5_288000_681000 0.224
R_VDD3_11284 METAL5_288000_681000 METAL5_288000_693000 0.048
R_VDD3_11285 METAL5_288000_693000 METAL5_288000_705000 0.048
R_VDD3_11286 METAL5_288000_705000 METAL5_288000_707000 0.008
R_VDD3_11287 METAL5_288000_707000 METAL5_288000_717000 0.04
R_VDD3_11288 METAL5_288000_717000 METAL5_288000_781000 0.256
R_VDD3_11289 METAL5_288000_781000 METAL5_288000_793000 0.048
R_VDD3_11290 METAL5_288000_793000 METAL5_288000_805000 0.048
R_VDD3_11291 METAL5_288000_805000 METAL5_288000_817000 0.048
R_VDD3_11292 METAL5_288000_817000 METAL5_288000_829000 0.048
R_VDD3_11293 METAL5_288000_829000 METAL5_288000_841000 0.048
R_VDD3_11294 METAL5_288000_841000 METAL5_288000_853000 0.048
R_VDD3_11295 METAL5_288000_853000 METAL4_288000_853000 0.1
R_VDD3_11296 METAL4_288000_853000 METAL4_290000_853000 0.016
R_VDD3_11297 METAL4_290000_853000 METAL4_293000_853000 0.024
R_VDD3_11298 METAL4_293000_853000 METAL4_300000_853000 0.056
R_VDD3_11299 METAL4_300000_853000 METAL4_302000_853000 0.016
R_VDD3_11300 METAL4_302000_853000 METAL4_305000_853000 0.024
R_VDD3_11301 METAL4_305000_853000 METAL4_306000_853000 0.008
R_VDD3_11302 METAL4_306000_853000 METAL4_312000_853000 0.048
R_VDD3_11303 METAL4_312000_853000 METAL4_312000_865000 0.096
R_VDD3_11304 METAL4_312000_865000 METAL4_312000_877000 0.096
R_VDD3_11305 METAL4_312000_877000 METAL4_312000_881000 0.032
R_VDD3_11306 METAL4_312000_881000 METAL4_314000_881000 0.016
R_VDD3_11307 METAL4_314000_881000 METAL4_318000_881000 0.032
R_VDD3_11308 METAL4_318000_881000 METAL4_324000_881000 0.048
R_VDD3_11309 METAL4_324000_881000 METAL4_326000_881000 0.016
R_VDD3_11310 METAL4_326000_881000 METAL4_326000_889000 0.064
R_VDD3_11311 METAL4_326000_889000 METAL4_326000_893000 0.032
R_VDD3_11312 METAL4_326000_893000 METAL4_326000_901000 0.064
R_VDD3_11313 METAL4_326000_901000 METAL4_326000_905000 0.032
R_VDD3_11314 METAL4_326000_905000 METAL4_326000_917000 0.096
R_VDD3_11315 METAL4_326000_917000 METAL4_326000_929000 0.096
R_VDD3_11316 METAL4_326000_929000 METAL4_326000_941000 0.096
R_VDD3_11317 METAL4_326000_941000 METAL4_326000_953000 0.096
R_VDD3_11318 METAL4_326000_953000 METAL4_326000_965000 0.096
R_VDD3_11319 METAL4_326000_965000 METAL4_326000_977000 0.096
R_VDD3_11320 METAL4_326000_977000 METAL4_326000_989000 0.096
R_VDD3_11321 METAL4_326000_989000 METAL4_326000_1001000 0.096
R_VDD3_11322 METAL4_326000_1001000 METAL4_326000_1013000 0.096
R_VDD3_11323 METAL4_326000_1013000 METAL5_326000_1013000 0.1
R_VDD3_11324 METAL5_326000_1013000 METAL5_326000_1025000 0.048
R_VDD3_11325 METAL5_326000_1025000 METAL5_326000_1041000 0.064
R_VDD3_11326 METAL5_326000_1041000 METAL5_326000_1053000 0.048
R_VDD3_11327 METAL5_326000_1053000 METAL5_326000_1065000 0.048
R_VDD3_11328 METAL5_326000_1065000 METAL4_326000_1065000 0.1
R_VDD3_11329 METAL4_326000_1065000 METAL4_326000_1077000 0.096
R_VDD3_11330 METAL4_326000_1077000 METAL4_326000_1089000 0.096
R_VDD3_11331 METAL4_326000_1089000 METAL5_326000_1089000 0.1
R_VDD3_11332 METAL5_326000_1089000 METAL5_326000_1101000 0.048
R_VDD3_11333 METAL5_326000_1101000 METAL5_326000_1153000 0.208
R_VDD3_11334 METAL5_326000_1153000 METAL5_326000_1165000 0.048
R_VDD3_11335 METAL5_326000_1165000 METAL5_326000_1177000 0.048
R_VDD3_11336 METAL5_326000_1177000 METAL5_326000_1189000 0.048
R_VDD3_11337 METAL5_326000_1189000 METAL5_326000_1201000 0.048
R_VDD3_11338 METAL5_326000_1201000 METAL5_326000_1229000 0.112
R_VDD3_11339 METAL5_326000_1229000 METAL5_328000_1229000 0.008
R_VDD3_11340 METAL5_328000_1229000 METAL5_330000_1229000 0.008
R_VDD3_11341 METAL5_330000_1229000 METAL5_336000_1229000 0.024
R_VDD3_11342 METAL5_336000_1229000 METAL5_336000_1241000 0.048
R_VDD3_11343 METAL5_336000_1241000 METAL5_336000_1253000 0.048
R_VDD3_11344 METAL5_336000_1253000 METAL5_336000_1265000 0.048
R_VDD3_11345 METAL5_336000_1265000 METAL5_336000_1277000 0.048
R_VDD3_11346 METAL5_336000_1277000 METAL5_336000_1289000 0.048
R_VDD3_11347 METAL5_336000_1289000 METAL5_336000_1357000 0.272
R_VDD3_11348 METAL5_336000_1357000 METAL5_336000_1369000 0.048
R_VDD3_11349 METAL5_336000_1369000 METAL5_330000_1369000 0.024
R_VDD3_11350 METAL5_330000_1369000 METAL5_328000_1369000 0.008
R_VDD3_11351 METAL5_328000_1369000 METAL5_326000_1369000 0.008
R_VDD3_11352 METAL5_326000_1369000 METAL5_324000_1369000 0.008
R_VDD3_11353 METAL5_324000_1369000 METAL5_318000_1369000 0.024
R_VDD3_11354 METAL5_318000_1369000 METAL5_314000_1369000 0.016
R_VDD3_11355 METAL5_314000_1369000 METAL5_314000_1381000 0.048
R_VDD3_11356 METAL5_314000_1381000 METAL5_312000_1381000 0.008
R_VDD3_11357 METAL5_312000_1381000 METAL5_306000_1381000 0.024
R_VDD3_11358 METAL5_306000_1381000 METAL5_305000_1381000 0.004
R_VDD3_11359 METAL5_305000_1381000 METAL5_302000_1381000 0.012
R_VDD3_11360 METAL5_302000_1381000 METAL5_300000_1381000 0.008
R_VDD3_11361 METAL5_300000_1381000 METAL5_293000_1381000 0.028
R_VDD3_11362 METAL5_293000_1381000 METAL5_290000_1381000 0.012
R_VDD3_11363 METAL5_290000_1381000 METAL5_288000_1381000 0.008
R_VDD3_11364 METAL5_288000_1381000 METAL5_281000_1381000 0.028
R_VDD3_11365 METAL5_281000_1381000 METAL5_276000_1381000 0.02
R_VDD3_11366 METAL5_276000_1381000 METAL5_276000_1393000 0.048
R_VDD3_11367 METAL5_276000_1393000 METAL5_276000_1405000 0.048
R_VDD3_11368 METAL5_276000_1405000 METAL5_281000_1405000 0.02
R_VDD3_11369 METAL5_281000_1405000 METAL6_281000_1405000 0.1
R_VDD3_11370 METAL6_281000_1405000 METAL6_281000_1407000 0.004
R_VDD3_11371 METAL6_281000_1407000 METAL6_281000_1417000 0.02
R_VDD3_11372 METAL6_281000_1417000 METAL6_281000_1529000 0.224
R_VDD3_11373 METAL6_281000_1529000 METAL6_281000_1541000 0.024
R_VDD3_11374 METAL6_281000_1541000 METAL5_281000_1541000 0.1
R_VDD3_11375 METAL5_281000_1541000 METAL4_281000_1541000 0.1
R_VDD3_11376 METAL4_281000_1541000 METAL4_281000_1553000 0.096
R_VDD3_11377 METAL4_281000_1553000 METAL4_281000_1565000 0.096
R_VDD3_11378 METAL4_281000_1565000 METAL5_281000_1565000 0.1
R_VDD3_11379 METAL5_281000_1565000 METAL5_281000_1577000 0.048
R_VDD3_11380 METAL5_281000_1577000 METAL5_281000_1629000 0.208
R_VDD3_11381 METAL5_281000_1629000 METAL4_281000_1629000 0.1
R_VDD3_11382 METAL4_281000_1629000 METAL4_281000_1641000 0.096
R_VDD3_11383 METAL4_281000_1641000 METAL4_281000_1653000 0.096
R_VDD3_11384 METAL4_281000_1653000 METAL4_281000_1665000 0.096
R_VDD3_11385 METAL4_281000_1665000 METAL4_281000_1677000 0.096
R_VDD3_11386 METAL4_281000_1677000 METAL4_276000_1677000 0.04
R_VDD3_11387 METAL4_276000_1677000 METAL4_269000_1677000 0.056
R_VDD3_11388 METAL4_269000_1677000 METAL4_264000_1677000 0.04
R_VDD3_11389 METAL4_264000_1677000 METAL5_264000_1677000 0.1
R_VDD3_11390 METAL5_264000_1677000 METAL5_257000_1677000 0.028
R_VDD3_11391 METAL5_257000_1677000 METAL6_257000_1677000 0.1
R_VDD3_11392 METAL6_257000_1677000 METAL6_257000_1689000 0.024
R_VDD3_11393 METAL6_257000_1689000 METAL6_257000_1753000 0.128
R_VDD3_11394 METAL6_257000_1753000 METAL6_257000_1765000 0.024
R_VDD3_11395 METAL6_555000_1065000 METAL6_543000_1065000 0.024
R_VDD3_11396 METAL5_519000_929000 METAL5_524000_929000 0.02
R_VDD3_11397 METAL5_524000_929000 METAL5_531000_929000 0.028
R_VDD3_11398 METAL5_531000_929000 METAL5_531000_941000 0.048
R_VDD3_11399 METAL5_531000_941000 METAL5_531000_953000 0.048
R_VDD3_11400 METAL5_531000_953000 METAL5_531000_965000 0.048
R_VDD3_11401 METAL5_531000_965000 METAL5_531000_977000 0.048
R_VDD3_11402 METAL5_531000_977000 METAL5_543000_977000 0.048
R_VDD3_11403 METAL5_543000_977000 METAL6_543000_977000 0.1
R_VDD3_11404 METAL6_543000_977000 METAL6_543000_989000 0.024
R_VDD3_11405 METAL6_543000_989000 METAL6_543000_1001000 0.024
R_VDD3_11406 METAL6_543000_1001000 METAL6_543000_1013000 0.024
R_VDD3_11407 METAL6_543000_1013000 METAL6_543000_1025000 0.024
R_VDD3_11408 METAL6_543000_1025000 METAL6_543000_1041000 0.032
R_VDD3_11409 METAL6_543000_1041000 METAL6_543000_1053000 0.024
R_VDD3_11410 METAL6_543000_1053000 METAL6_543000_1065000 0.024
R_VDD3_11411 METAL6_245000_1065000 METAL6_257000_1065000 0.024
R_VDD3_11412 METAL6_400000_8000 METAL6_402000_8000 0.004
R_VDD3_11413 METAL6_402000_8000 METAL6_408000_8000 0.012
R_VDD3_11414 METAL6_408000_8000 METAL6_410000_8000 0.004
R_VDD3_11415 METAL6_410000_8000 METAL6_412000_8000 0.004
R_VDD3_11416 METAL6_412000_8000 METAL5_412000_8000 0.1
R_VDD3_11417 METAL5_412000_8000 METAL4_412000_8000 0.1
R_VDD3_11418 METAL4_412000_8000 METAL4_412000_20000 0.096
R_VDD3_11419 METAL4_412000_20000 METAL4_412000_32000 0.096
R_VDD3_11420 METAL4_412000_32000 METAL4_412000_44000 0.096
R_VDD3_11421 METAL4_412000_44000 METAL4_410000_44000 0.016
R_VDD3_11422 METAL4_410000_44000 METAL4_408000_44000 0.016
R_VDD3_11423 METAL4_408000_44000 METAL4_402000_44000 0.048
R_VDD3_11424 METAL4_402000_44000 METAL4_400000_44000 0.016
R_VDD3_11425 METAL4_400000_44000 METAL4_398000_44000 0.016
R_VDD3_11426 METAL4_398000_44000 METAL4_396000_44000 0.016
R_VDD3_11427 METAL4_396000_44000 METAL4_390000_44000 0.048
R_VDD3_11428 METAL4_390000_44000 METAL4_388000_44000 0.016
R_VDD3_11429 METAL4_388000_44000 METAL5_388000_44000 0.1
R_VDD3_11430 METAL5_388000_44000 METAL5_386000_44000 0.008
R_VDD3_11431 METAL5_386000_44000 METAL5_384000_44000 0.008
R_VDD3_11432 METAL5_384000_44000 METAL5_378000_44000 0.024
R_VDD3_11433 METAL5_378000_44000 METAL5_376000_44000 0.008
R_VDD3_11434 METAL5_376000_44000 METAL5_374000_44000 0.008
R_VDD3_11435 METAL5_374000_44000 METAL5_372000_44000 0.008
R_VDD3_11436 METAL5_372000_44000 METAL5_366000_44000 0.024
R_VDD3_11437 METAL5_366000_44000 METAL5_364000_44000 0.008
R_VDD3_11438 METAL5_364000_44000 METAL5_362000_44000 0.008
R_VDD3_11439 METAL5_362000_44000 METAL5_360000_44000 0.008
R_VDD3_11440 METAL5_360000_44000 METAL5_354000_44000 0.024
R_VDD3_11441 METAL5_354000_44000 METAL5_352000_44000 0.008
R_VDD3_11442 METAL5_352000_44000 METAL5_350000_44000 0.008
R_VDD3_11443 METAL5_350000_44000 METAL5_348000_44000 0.008
R_VDD3_11444 METAL5_348000_44000 METAL5_342000_44000 0.024
R_VDD3_11445 METAL5_342000_44000 METAL5_340000_44000 0.008
R_VDD3_11446 METAL5_340000_44000 METAL6_340000_44000 0.1
R_VDD3_11447 METAL6_340000_44000 METAL6_340000_57000 0.026
R_VDD3_11448 METAL6_340000_57000 METAL6_338000_57000 0.004
R_VDD3_11449 METAL6_338000_57000 METAL6_336000_57000 0.004
R_VDD3_11450 METAL6_336000_57000 METAL6_330000_57000 0.012
R_VDD3_11451 METAL6_330000_57000 METAL6_330000_69000 0.024
R_VDD3_11452 METAL6_330000_69000 METAL6_330000_81000 0.024
R_VDD3_11453 METAL6_330000_81000 METAL6_330000_93000 0.024
R_VDD3_11454 METAL6_330000_93000 METAL6_330000_105000 0.024
R_VDD3_11455 METAL6_330000_105000 METAL6_330000_117000 0.024
R_VDD3_11456 METAL6_330000_117000 METAL6_330000_129000 0.024
R_VDD3_11457 METAL6_330000_129000 METAL6_330000_133000 0.008
R_VDD3_11458 METAL6_330000_133000 METAL6_328000_133000 0.004
R_VDD3_11459 METAL6_328000_133000 METAL6_326000_133000 0.004
R_VDD3_11460 METAL6_326000_133000 METAL6_324000_133000 0.004
R_VDD3_11461 METAL6_324000_133000 METAL6_318000_133000 0.012
R_VDD3_11462 METAL6_318000_133000 METAL6_318000_141000 0.016
R_VDD3_11463 METAL6_318000_141000 METAL6_314000_141000 0.008
R_VDD3_11464 METAL6_314000_141000 METAL6_314000_145000 0.008
R_VDD3_11465 METAL6_314000_145000 METAL6_312000_145000 0.004
R_VDD3_11466 METAL6_312000_145000 METAL6_306000_145000 0.012
R_VDD3_11467 METAL6_306000_145000 METAL6_306000_153000 0.016
R_VDD3_11468 METAL6_306000_153000 METAL6_306000_157000 0.008
R_VDD3_11469 METAL6_306000_157000 METAL6_305000_157000 0.002
R_VDD3_11470 METAL6_305000_157000 METAL6_302000_157000 0.006
R_VDD3_11471 METAL6_302000_157000 METAL6_300000_157000 0.004
R_VDD3_11472 METAL6_300000_157000 METAL6_294000_157000 0.012
R_VDD3_11473 METAL6_294000_157000 METAL6_294000_165000 0.016
R_VDD3_11474 METAL6_294000_165000 METAL6_294000_169000 0.008
R_VDD3_11475 METAL6_294000_169000 METAL6_294000_177000 0.016
R_VDD3_11476 METAL6_294000_177000 METAL6_294000_181000 0.008
R_VDD3_11477 METAL6_294000_181000 METAL6_294000_193000 0.024
R_VDD3_11478 METAL6_294000_193000 METAL6_294000_205000 0.024
R_VDD3_11479 METAL6_294000_205000 METAL6_294000_217000 0.024
R_VDD3_11480 METAL6_294000_217000 METAL6_293000_217000 0.002
R_VDD3_11481 METAL6_293000_217000 METAL6_290000_217000 0.006
R_VDD3_11482 METAL6_290000_217000 METAL6_290000_229000 0.024
R_VDD3_11483 METAL6_290000_229000 METAL6_290000_233000 0.008
R_VDD3_11484 METAL6_290000_233000 METAL6_290000_241000 0.016
R_VDD3_11485 METAL6_290000_241000 METAL6_290000_245000 0.008
R_VDD3_11486 METAL6_290000_245000 METAL6_290000_253000 0.016
R_VDD3_11487 METAL6_290000_253000 METAL6_290000_257000 0.008
R_VDD3_11488 METAL6_290000_257000 METAL6_290000_265000 0.016
R_VDD3_11489 METAL6_290000_265000 METAL6_290000_269000 0.008
R_VDD3_11490 METAL6_290000_269000 METAL5_290000_269000 0.1
R_VDD3_11491 METAL5_290000_269000 METAL5_290000_277000 0.032
R_VDD3_11492 METAL5_290000_277000 METAL5_290000_281000 0.016
R_VDD3_11493 METAL5_290000_281000 METAL5_290000_289000 0.032
R_VDD3_11494 METAL5_290000_289000 METAL5_290000_293000 0.016
R_VDD3_11495 METAL5_290000_293000 METAL5_293000_293000 0.012
R_VDD3_11496 METAL5_293000_293000 METAL5_294000_293000 0.004
R_VDD3_11497 METAL5_294000_293000 METAL5_300000_293000 0.024
R_VDD3_11498 METAL5_300000_293000 METAL5_300000_301000 0.032
R_VDD3_11499 METAL5_300000_301000 METAL5_300000_305000 0.016
R_VDD3_11500 METAL5_300000_305000 METAL5_300000_313000 0.032
R_VDD3_11501 METAL5_300000_313000 METAL5_300000_317000 0.016
R_VDD3_11502 METAL5_300000_317000 METAL5_300000_329000 0.048
R_VDD3_11503 METAL5_300000_329000 METAL5_300000_341000 0.048
R_VDD3_11504 METAL5_300000_341000 METAL5_300000_353000 0.048
R_VDD3_11505 METAL5_300000_353000 METAL5_300000_365000 0.048
R_VDD3_11506 METAL5_300000_365000 METAL5_300000_377000 0.048
R_VDD3_11507 METAL5_300000_377000 METAL5_300000_389000 0.048
R_VDD3_11508 METAL5_300000_389000 METAL5_300000_429000 0.16
R_VDD3_11509 METAL5_300000_429000 METAL5_300000_441000 0.048
R_VDD3_11510 METAL5_300000_441000 METAL5_300000_453000 0.048
R_VDD3_11511 METAL5_300000_453000 METAL5_302000_453000 0.008
R_VDD3_11512 METAL5_302000_453000 METAL5_305000_453000 0.012
R_VDD3_11513 METAL5_305000_453000 METAL5_306000_453000 0.004
R_VDD3_11514 METAL5_306000_453000 METAL5_312000_453000 0.024
R_VDD3_11515 METAL5_312000_453000 METAL4_312000_453000 0.1
R_VDD3_11516 METAL4_312000_453000 METAL4_312000_465000 0.096
R_VDD3_11517 METAL4_312000_465000 METAL4_312000_469000 0.032
R_VDD3_11518 METAL4_312000_469000 METAL4_312000_477000 0.064
R_VDD3_11519 METAL4_312000_477000 METAL5_312000_477000 0.1
R_VDD3_11520 METAL5_312000_477000 METAL5_312000_481000 0.016
R_VDD3_11521 METAL5_312000_481000 METAL5_312000_489000 0.032
R_VDD3_11522 METAL5_312000_489000 METAL5_312000_493000 0.016
R_VDD3_11523 METAL5_312000_493000 METAL5_312000_501000 0.032
R_VDD3_11524 METAL5_312000_501000 METAL5_312000_505000 0.016
R_VDD3_11525 METAL5_312000_505000 METAL5_312000_517000 0.048
R_VDD3_11526 METAL5_312000_517000 METAL5_312000_529000 0.048
R_VDD3_11527 METAL5_312000_529000 METAL5_312000_541000 0.048
R_VDD3_11528 METAL5_312000_541000 METAL5_312000_553000 0.048
R_VDD3_11529 METAL5_312000_553000 METAL5_312000_565000 0.048
R_VDD3_11530 METAL5_312000_565000 METAL4_312000_565000 0.1
R_VDD3_11531 METAL4_312000_565000 METAL4_306000_565000 0.048
R_VDD3_11532 METAL4_306000_565000 METAL4_305000_565000 0.008
R_VDD3_11533 METAL4_305000_565000 METAL4_302000_565000 0.024
R_VDD3_11534 METAL4_302000_565000 METAL4_300000_565000 0.016
R_VDD3_11535 METAL4_300000_565000 METAL4_294000_565000 0.048
R_VDD3_11536 METAL4_294000_565000 METAL4_293000_565000 0.008
R_VDD3_11537 METAL4_293000_565000 METAL4_290000_565000 0.024
R_VDD3_11538 METAL4_290000_565000 METAL4_288000_565000 0.016
R_VDD3_11539 METAL4_288000_565000 METAL4_281000_565000 0.056
R_VDD3_11540 METAL4_281000_565000 METAL4_278000_565000 0.024
R_VDD3_11541 METAL4_278000_565000 METAL4_276000_565000 0.016
R_VDD3_11542 METAL4_276000_565000 METAL4_276000_577000 0.096
R_VDD3_11543 METAL4_276000_577000 METAL4_276000_589000 0.096
R_VDD3_11544 METAL4_276000_589000 METAL4_276000_601000 0.096
R_VDD3_11545 METAL4_276000_601000 METAL5_276000_601000 0.1
R_VDD3_11546 METAL5_276000_601000 METAL5_276000_613000 0.048
R_VDD3_11547 METAL5_276000_613000 METAL5_276000_625000 0.048
R_VDD3_11548 METAL5_276000_625000 METAL5_276000_681000 0.224
R_VDD3_11549 METAL5_276000_681000 METAL5_276000_693000 0.048
R_VDD3_11550 METAL5_276000_693000 METAL5_276000_705000 0.048
R_VDD3_11551 METAL5_276000_705000 METAL5_269000_705000 0.028
R_VDD3_11552 METAL5_269000_705000 METAL5_269000_707000 0.008
R_VDD3_11553 METAL5_269000_707000 METAL5_269000_717000 0.04
R_VDD3_11554 METAL5_269000_717000 METAL5_269000_781000 0.256
R_VDD3_11555 METAL5_269000_781000 METAL5_269000_793000 0.048
R_VDD3_11556 METAL5_269000_793000 METAL5_269000_805000 0.048
R_VDD3_11557 METAL5_269000_805000 METAL5_269000_817000 0.048
R_VDD3_11558 METAL5_269000_817000 METAL5_269000_829000 0.048
R_VDD3_11559 METAL5_269000_829000 METAL5_269000_841000 0.048
R_VDD3_11560 METAL5_269000_841000 METAL4_269000_841000 0.1
R_VDD3_11561 METAL4_269000_841000 METAL4_269000_853000 0.096
R_VDD3_11562 METAL4_269000_853000 METAL4_269000_865000 0.096
R_VDD3_11563 METAL4_269000_865000 METAL4_269000_869000 0.032
R_VDD3_11564 METAL4_269000_869000 METAL4_269000_877000 0.064
R_VDD3_11565 METAL4_269000_877000 METAL4_269000_881000 0.032
R_VDD3_11566 METAL4_269000_881000 METAL4_269000_889000 0.064
R_VDD3_11567 METAL4_269000_889000 METAL4_269000_893000 0.032
R_VDD3_11568 METAL4_269000_893000 METAL4_269000_901000 0.064
R_VDD3_11569 METAL4_269000_901000 METAL4_269000_905000 0.032
R_VDD3_11570 METAL4_269000_905000 METAL4_269000_917000 0.096
R_VDD3_11571 METAL4_269000_917000 METAL4_269000_929000 0.096
R_VDD3_11572 METAL4_269000_929000 METAL4_269000_941000 0.096
R_VDD3_11573 METAL4_269000_941000 METAL4_269000_953000 0.096
R_VDD3_11574 METAL4_269000_953000 METAL4_269000_965000 0.096
R_VDD3_11575 METAL4_269000_965000 METAL4_269000_977000 0.096
R_VDD3_11576 METAL4_269000_977000 METAL4_264000_977000 0.04
R_VDD3_11577 METAL4_264000_977000 METAL4_257000_977000 0.056
R_VDD3_11578 METAL4_257000_977000 METAL5_257000_977000 0.1
R_VDD3_11579 METAL5_257000_977000 METAL6_257000_977000 0.1
R_VDD3_11580 METAL6_257000_977000 METAL6_257000_989000 0.024
R_VDD3_11581 METAL6_257000_989000 METAL6_257000_1001000 0.024
R_VDD3_11582 METAL6_257000_1001000 METAL6_257000_1013000 0.024
R_VDD3_11583 METAL6_257000_1013000 METAL6_257000_1025000 0.024
R_VDD3_11584 METAL6_257000_1025000 METAL6_257000_1041000 0.032
R_VDD3_11585 METAL6_257000_1041000 METAL6_257000_1053000 0.024
R_VDD3_11586 METAL6_257000_1053000 METAL6_257000_1065000 0.024
R_VDD3_11587 METAL6_555000_365000 METAL6_543000_365000 0.024
R_VDD3_11588 METAL6_366000_141000 METAL5_366000_141000 0.1
R_VDD3_11589 METAL5_366000_141000 METAL5_372000_141000 0.024
R_VDD3_11590 METAL5_372000_141000 METAL5_374000_141000 0.008
R_VDD3_11591 METAL5_374000_141000 METAL5_376000_141000 0.008
R_VDD3_11592 METAL5_376000_141000 METAL5_378000_141000 0.008
R_VDD3_11593 METAL5_378000_141000 METAL4_378000_141000 0.1
R_VDD3_11594 METAL4_378000_141000 METAL4_384000_141000 0.048
R_VDD3_11595 METAL4_384000_141000 METAL4_386000_141000 0.016
R_VDD3_11596 METAL4_386000_141000 METAL4_388000_141000 0.016
R_VDD3_11597 METAL4_388000_141000 METAL4_390000_141000 0.016
R_VDD3_11598 METAL4_390000_141000 METAL4_396000_141000 0.048
R_VDD3_11599 METAL4_396000_141000 METAL4_398000_141000 0.016
R_VDD3_11600 METAL4_398000_141000 METAL4_400000_141000 0.016
R_VDD3_11601 METAL4_400000_141000 METAL4_402000_141000 0.016
R_VDD3_11602 METAL4_402000_141000 METAL4_408000_141000 0.048
R_VDD3_11603 METAL4_408000_141000 METAL5_408000_141000 0.1
R_VDD3_11604 METAL5_408000_141000 METAL5_408000_145000 0.016
R_VDD3_11605 METAL5_408000_145000 METAL5_408000_153000 0.032
R_VDD3_11606 METAL5_408000_153000 METAL5_408000_157000 0.016
R_VDD3_11607 METAL5_408000_157000 METAL5_408000_165000 0.032
R_VDD3_11608 METAL5_408000_165000 METAL5_408000_169000 0.016
R_VDD3_11609 METAL5_408000_169000 METAL5_408000_177000 0.032
R_VDD3_11610 METAL5_408000_177000 METAL5_408000_181000 0.016
R_VDD3_11611 METAL5_408000_181000 METAL5_408000_193000 0.048
R_VDD3_11612 METAL5_408000_193000 METAL5_408000_205000 0.048
R_VDD3_11613 METAL5_408000_205000 METAL5_408000_217000 0.048
R_VDD3_11614 METAL5_408000_217000 METAL5_408000_229000 0.048
R_VDD3_11615 METAL5_408000_229000 METAL5_408000_233000 0.016
R_VDD3_11616 METAL5_408000_233000 METAL5_408000_241000 0.032
R_VDD3_11617 METAL5_408000_241000 METAL5_408000_245000 0.016
R_VDD3_11618 METAL5_408000_245000 METAL5_408000_253000 0.032
R_VDD3_11619 METAL5_408000_253000 METAL5_408000_257000 0.016
R_VDD3_11620 METAL5_408000_257000 METAL5_408000_265000 0.032
R_VDD3_11621 METAL5_408000_265000 METAL5_410000_265000 0.008
R_VDD3_11622 METAL5_410000_265000 METAL5_412000_265000 0.008
R_VDD3_11623 METAL5_412000_265000 METAL5_414000_265000 0.008
R_VDD3_11624 METAL5_414000_265000 METAL5_422000_265000 0.032
R_VDD3_11625 METAL5_422000_265000 METAL5_424000_265000 0.008
R_VDD3_11626 METAL5_424000_265000 METAL5_426000_265000 0.008
R_VDD3_11627 METAL5_426000_265000 METAL4_426000_265000 0.1
R_VDD3_11628 METAL4_426000_265000 METAL4_426000_269000 0.032
R_VDD3_11629 METAL4_426000_269000 METAL4_426000_277000 0.064
R_VDD3_11630 METAL4_426000_277000 METAL4_426000_281000 0.032
R_VDD3_11631 METAL4_426000_281000 METAL4_426000_289000 0.064
R_VDD3_11632 METAL4_426000_289000 METAL4_426000_293000 0.032
R_VDD3_11633 METAL4_426000_293000 METAL4_426000_301000 0.064
R_VDD3_11634 METAL4_426000_301000 METAL5_426000_301000 0.1
R_VDD3_11635 METAL5_426000_301000 METAL5_434000_301000 0.032
R_VDD3_11636 METAL5_434000_301000 METAL5_434000_305000 0.016
R_VDD3_11637 METAL5_434000_305000 METAL5_436000_305000 0.008
R_VDD3_11638 METAL5_436000_305000 METAL5_438000_305000 0.008
R_VDD3_11639 METAL5_438000_305000 METAL5_440000_305000 0.008
R_VDD3_11640 METAL5_440000_305000 METAL5_446000_305000 0.024
R_VDD3_11641 METAL5_446000_305000 METAL5_448000_305000 0.008
R_VDD3_11642 METAL5_448000_305000 METAL5_450000_305000 0.008
R_VDD3_11643 METAL5_450000_305000 METAL5_452000_305000 0.008
R_VDD3_11644 METAL5_452000_305000 METAL5_458000_305000 0.024
R_VDD3_11645 METAL5_458000_305000 METAL5_460000_305000 0.008
R_VDD3_11646 METAL5_460000_305000 METAL5_462000_305000 0.008
R_VDD3_11647 METAL5_462000_305000 METAL5_464000_305000 0.008
R_VDD3_11648 METAL5_464000_305000 METAL5_472000_305000 0.032
R_VDD3_11649 METAL5_472000_305000 METAL5_474000_305000 0.008
R_VDD3_11650 METAL5_474000_305000 METAL5_476000_305000 0.008
R_VDD3_11651 METAL5_476000_305000 METAL5_484000_305000 0.032
R_VDD3_11652 METAL5_484000_305000 METAL5_486000_305000 0.008
R_VDD3_11653 METAL5_486000_305000 METAL5_488000_305000 0.008
R_VDD3_11654 METAL5_488000_305000 METAL5_496000_305000 0.032
R_VDD3_11655 METAL5_496000_305000 METAL5_500000_305000 0.016
R_VDD3_11656 METAL5_500000_305000 METAL5_507000_305000 0.028
R_VDD3_11657 METAL5_507000_305000 METAL5_512000_305000 0.02
R_VDD3_11658 METAL5_512000_305000 METAL5_519000_305000 0.028
R_VDD3_11659 METAL5_519000_305000 METAL4_519000_305000 0.1
R_VDD3_11660 METAL4_519000_305000 METAL4_524000_305000 0.04
R_VDD3_11661 METAL4_524000_305000 METAL4_531000_305000 0.056
R_VDD3_11662 METAL4_531000_305000 METAL4_543000_305000 0.096
R_VDD3_11663 METAL4_543000_305000 METAL4_543000_313000 0.064
R_VDD3_11664 METAL4_543000_313000 METAL4_543000_317000 0.032
R_VDD3_11665 METAL4_543000_317000 METAL4_543000_329000 0.096
R_VDD3_11666 METAL4_543000_329000 METAL4_543000_341000 0.096
R_VDD3_11667 METAL4_543000_341000 METAL5_543000_341000 0.1
R_VDD3_11668 METAL5_543000_341000 METAL5_543000_353000 0.048
R_VDD3_11669 METAL5_543000_353000 METAL6_543000_353000 0.1
R_VDD3_11670 METAL6_543000_353000 METAL6_543000_365000 0.024
R_VDD3_11671 METAL6_245000_365000 METAL6_257000_365000 0.024
R_VDD3_11672 METAL5_376000_44000 METAL5_376000_45000 0.004
R_VDD3_11673 METAL5_376000_45000 METAL5_376000_56000 0.044
R_VDD3_11674 METAL5_376000_56000 METAL5_374000_56000 0.008
R_VDD3_11675 METAL5_374000_56000 METAL5_372000_56000 0.008
R_VDD3_11676 METAL5_372000_56000 METAL5_366000_56000 0.024
R_VDD3_11677 METAL5_366000_56000 METAL5_364000_56000 0.008
R_VDD3_11678 METAL5_364000_56000 METAL5_362000_56000 0.008
R_VDD3_11679 METAL5_362000_56000 METAL5_360000_56000 0.008
R_VDD3_11680 METAL5_360000_56000 METAL5_354000_56000 0.024
R_VDD3_11681 METAL5_354000_56000 METAL5_352000_56000 0.008
R_VDD3_11682 METAL5_352000_56000 METAL5_350000_56000 0.008
R_VDD3_11683 METAL5_350000_56000 METAL5_348000_56000 0.008
R_VDD3_11684 METAL5_348000_56000 METAL5_342000_56000 0.024
R_VDD3_11685 METAL5_342000_56000 METAL5_340000_56000 0.008
R_VDD3_11686 METAL5_340000_56000 METAL5_338000_56000 0.008
R_VDD3_11687 METAL5_338000_56000 METAL5_336000_56000 0.008
R_VDD3_11688 METAL5_336000_56000 METAL5_330000_56000 0.024
R_VDD3_11689 METAL5_330000_56000 METAL5_328000_56000 0.008
R_VDD3_11690 METAL5_328000_56000 METAL5_326000_56000 0.008
R_VDD3_11691 METAL5_326000_56000 METAL5_324000_56000 0.008
R_VDD3_11692 METAL5_324000_56000 METAL5_318000_56000 0.024
R_VDD3_11693 METAL5_318000_56000 METAL6_318000_56000 0.1
R_VDD3_11694 METAL6_318000_56000 METAL6_314000_56000 0.008
R_VDD3_11695 METAL6_314000_56000 METAL6_312000_56000 0.004
R_VDD3_11696 METAL6_312000_56000 METAL6_306000_56000 0.012
R_VDD3_11697 METAL6_306000_56000 METAL6_306000_57000 0.002
R_VDD3_11698 METAL6_306000_57000 METAL6_306000_69000 0.024
R_VDD3_11699 METAL6_306000_69000 METAL6_306000_81000 0.024
R_VDD3_11700 METAL6_306000_81000 METAL6_306000_93000 0.024
R_VDD3_11701 METAL6_306000_93000 METAL6_306000_105000 0.024
R_VDD3_11702 METAL6_306000_105000 METAL6_306000_117000 0.024
R_VDD3_11703 METAL6_306000_117000 METAL6_306000_121000 0.008
R_VDD3_11704 METAL6_306000_121000 METAL6_306000_129000 0.016
R_VDD3_11705 METAL6_306000_129000 METAL6_305000_129000 0.002
R_VDD3_11706 METAL6_305000_129000 METAL6_302000_129000 0.006
R_VDD3_11707 METAL6_302000_129000 METAL6_302000_133000 0.008
R_VDD3_11708 METAL6_302000_133000 METAL6_300000_133000 0.004
R_VDD3_11709 METAL6_300000_133000 METAL6_294000_133000 0.012
R_VDD3_11710 METAL6_294000_133000 METAL6_294000_141000 0.016
R_VDD3_11711 METAL6_294000_141000 METAL6_294000_145000 0.008
R_VDD3_11712 METAL6_294000_145000 METAL6_293000_145000 0.002
R_VDD3_11713 METAL6_293000_145000 METAL6_290000_145000 0.006
R_VDD3_11714 METAL6_290000_145000 METAL6_288000_145000 0.004
R_VDD3_11715 METAL6_288000_145000 METAL6_282000_145000 0.012
R_VDD3_11716 METAL6_282000_145000 METAL6_282000_153000 0.016
R_VDD3_11717 METAL6_282000_153000 METAL6_282000_157000 0.008
R_VDD3_11718 METAL6_282000_157000 METAL6_282000_165000 0.016
R_VDD3_11719 METAL6_282000_165000 METAL6_282000_169000 0.008
R_VDD3_11720 METAL6_282000_169000 METAL6_282000_177000 0.016
R_VDD3_11721 METAL6_282000_177000 METAL6_282000_181000 0.008
R_VDD3_11722 METAL6_282000_181000 METAL6_282000_193000 0.024
R_VDD3_11723 METAL6_282000_193000 METAL6_282000_205000 0.024
R_VDD3_11724 METAL6_282000_205000 METAL6_281000_205000 0.002
R_VDD3_11725 METAL6_281000_205000 METAL6_278000_205000 0.006
R_VDD3_11726 METAL6_278000_205000 METAL6_278000_217000 0.024
R_VDD3_11727 METAL6_278000_217000 METAL6_278000_229000 0.024
R_VDD3_11728 METAL6_278000_229000 METAL6_278000_233000 0.008
R_VDD3_11729 METAL6_278000_233000 METAL6_278000_241000 0.016
R_VDD3_11730 METAL6_278000_241000 METAL6_278000_245000 0.008
R_VDD3_11731 METAL6_278000_245000 METAL6_278000_253000 0.016
R_VDD3_11732 METAL6_278000_253000 METAL6_278000_257000 0.008
R_VDD3_11733 METAL6_278000_257000 METAL6_278000_265000 0.016
R_VDD3_11734 METAL6_278000_265000 METAL6_278000_269000 0.008
R_VDD3_11735 METAL6_278000_269000 METAL6_278000_277000 0.016
R_VDD3_11736 METAL6_278000_277000 METAL6_278000_281000 0.008
R_VDD3_11737 METAL6_278000_281000 METAL6_278000_289000 0.016
R_VDD3_11738 METAL6_278000_289000 METAL6_278000_293000 0.008
R_VDD3_11739 METAL6_278000_293000 METAL6_276000_293000 0.004
R_VDD3_11740 METAL6_276000_293000 METAL6_276000_301000 0.016
R_VDD3_11741 METAL6_276000_301000 METAL6_269000_301000 0.014
R_VDD3_11742 METAL6_269000_301000 METAL6_264000_301000 0.01
R_VDD3_11743 METAL6_264000_301000 METAL6_257000_301000 0.014
R_VDD3_11744 METAL6_257000_301000 METAL6_257000_305000 0.008
R_VDD3_11745 METAL6_257000_305000 METAL6_257000_313000 0.016
R_VDD3_11746 METAL6_257000_313000 METAL6_257000_317000 0.008
R_VDD3_11747 METAL6_257000_317000 METAL6_257000_329000 0.024
R_VDD3_11748 METAL6_257000_329000 METAL6_257000_341000 0.024
R_VDD3_11749 METAL6_257000_341000 METAL6_257000_353000 0.024
R_VDD3_11750 METAL6_257000_353000 METAL6_257000_365000 0.024
R_VDD3_11751 METAL6_543000_365000 METAL5_543000_365000 0.1
R_VDD3_11752 METAL5_543000_365000 METAL4_543000_365000 0.1
R_VDD3_11753 METAL4_543000_365000 METAL3_543000_365000 0.1
R_VDD3_11754 METAL3_543000_365000 METAL3_543000_353000 0.096
R_VDD3_11755 METAL3_543000_353000 METAL3_543000_341000 0.096
R_VDD3_11756 METAL3_543000_341000 METAL3_543000_329000 0.096
R_VDD3_11757 METAL3_543000_329000 METAL3_543000_317000 0.096
R_VDD3_11758 METAL3_543000_317000 METAL3_543000_313000 0.032
R_VDD3_11759 METAL3_543000_313000 METAL3_543000_305000 0.064
R_VDD3_11760 METAL3_543000_305000 METAL3_543000_301000 0.032
R_VDD3_11761 METAL3_543000_301000 METAL3_543000_293000 0.064
R_VDD3_11762 METAL3_543000_293000 METAL4_543000_293000 0.1
R_VDD3_11763 METAL4_543000_293000 METAL4_536000_293000 0.056
R_VDD3_11764 METAL4_536000_293000 METAL4_531000_293000 0.04
R_VDD3_11765 METAL4_531000_293000 METAL4_524000_293000 0.056
R_VDD3_11766 METAL4_524000_293000 METAL4_524000_289000 0.032
R_VDD3_11767 METAL4_524000_289000 METAL4_524000_281000 0.064
R_VDD3_11768 METAL4_524000_281000 METAL4_524000_277000 0.032
R_VDD3_11769 METAL4_524000_277000 METAL4_524000_269000 0.064
R_VDD3_11770 METAL4_524000_269000 METAL4_524000_265000 0.032
R_VDD3_11771 METAL4_524000_265000 METAL4_524000_257000 0.064
R_VDD3_11772 METAL4_524000_257000 METAL4_524000_253000 0.032
R_VDD3_11773 METAL4_524000_253000 METAL4_524000_245000 0.064
R_VDD3_11774 METAL4_524000_245000 METAL4_524000_241000 0.032
R_VDD3_11775 METAL4_524000_241000 METAL4_524000_233000 0.064
R_VDD3_11776 METAL4_524000_233000 METAL4_524000_229000 0.032
R_VDD3_11777 METAL4_524000_229000 METAL4_524000_221000 0.064
R_VDD3_11778 METAL4_524000_221000 METAL4_524000_217000 0.032
R_VDD3_11779 METAL4_524000_217000 METAL4_522000_217000 0.016
R_VDD3_11780 METAL4_522000_217000 METAL4_519000_217000 0.024
R_VDD3_11781 METAL4_519000_217000 METAL4_519000_205000 0.096
R_VDD3_11782 METAL4_519000_205000 METAL4_512000_205000 0.056
R_VDD3_11783 METAL4_512000_205000 METAL4_510000_205000 0.016
R_VDD3_11784 METAL4_510000_205000 METAL4_508000_205000 0.016
R_VDD3_11785 METAL4_508000_205000 METAL4_507000_205000 0.008
R_VDD3_11786 METAL4_507000_205000 METAL4_506000_205000 0.008
R_VDD3_11787 METAL4_506000_205000 METAL4_500000_205000 0.048
R_VDD3_11788 METAL4_500000_205000 METAL4_498000_205000 0.016
R_VDD3_11789 METAL4_498000_205000 METAL4_496000_205000 0.016
R_VDD3_11790 METAL4_496000_205000 METAL4_495000_205000 0.008
R_VDD3_11791 METAL4_495000_205000 METAL4_494000_205000 0.008
R_VDD3_11792 METAL4_494000_205000 METAL4_488000_205000 0.048
R_VDD3_11793 METAL4_488000_205000 METAL4_486000_205000 0.016
R_VDD3_11794 METAL4_486000_205000 METAL4_484000_205000 0.016
R_VDD3_11795 METAL4_484000_205000 METAL4_483000_205000 0.008
R_VDD3_11796 METAL4_483000_205000 METAL4_482000_205000 0.008
R_VDD3_11797 METAL4_482000_205000 METAL4_476000_205000 0.048
R_VDD3_11798 METAL4_476000_205000 METAL4_474000_205000 0.016
R_VDD3_11799 METAL4_474000_205000 METAL4_472000_205000 0.016
R_VDD3_11800 METAL4_472000_205000 METAL4_471000_205000 0.008
R_VDD3_11801 METAL4_471000_205000 METAL4_470000_205000 0.008
R_VDD3_11802 METAL4_470000_205000 METAL4_464000_205000 0.048
R_VDD3_11803 METAL4_464000_205000 METAL4_462000_205000 0.016
R_VDD3_11804 METAL4_462000_205000 METAL4_460000_205000 0.016
R_VDD3_11805 METAL4_460000_205000 METAL4_458000_205000 0.016
R_VDD3_11806 METAL4_458000_205000 METAL4_452000_205000 0.048
R_VDD3_11807 METAL4_452000_205000 METAL4_450000_205000 0.016
R_VDD3_11808 METAL4_450000_205000 METAL4_448000_205000 0.016
R_VDD3_11809 METAL4_448000_205000 METAL5_448000_205000 0.1
R_VDD3_11810 METAL5_448000_205000 METAL5_448000_193000 0.048
R_VDD3_11811 METAL5_448000_193000 METAL5_448000_189000 0.016
R_VDD3_11812 METAL5_448000_189000 METAL5_448000_181000 0.032
R_VDD3_11813 METAL5_448000_181000 METAL5_448000_177000 0.016
R_VDD3_11814 METAL5_448000_177000 METAL5_448000_169000 0.032
R_VDD3_11815 METAL5_448000_169000 METAL5_448000_165000 0.016
R_VDD3_11816 METAL5_448000_165000 METAL5_448000_157000 0.032
R_VDD3_11817 METAL5_448000_157000 METAL5_448000_153000 0.016
R_VDD3_11818 METAL5_448000_153000 METAL5_448000_145000 0.032
R_VDD3_11819 METAL5_448000_145000 METAL5_448000_141000 0.016
R_VDD3_11820 METAL5_448000_141000 METAL4_448000_141000 0.1
R_VDD3_11821 METAL4_448000_141000 METAL4_448000_133000 0.064
R_VDD3_11822 METAL4_448000_133000 METAL4_448000_129000 0.032
R_VDD3_11823 METAL4_448000_129000 METAL4_448000_121000 0.064
R_VDD3_11824 METAL4_448000_121000 METAL4_448000_117000 0.032
R_VDD3_11825 METAL4_448000_117000 METAL5_448000_117000 0.1
R_VDD3_11826 METAL5_448000_117000 METAL5_446000_117000 0.008
R_VDD3_11827 METAL5_446000_117000 METAL5_444000_117000 0.008
R_VDD3_11828 METAL5_444000_117000 METAL5_440000_117000 0.016
R_VDD3_11829 METAL5_440000_117000 METAL5_438000_117000 0.008
R_VDD3_11830 METAL5_438000_117000 METAL5_436000_117000 0.008
R_VDD3_11831 METAL5_436000_117000 METAL5_436000_116000 0.004
R_VDD3_11832 METAL5_436000_116000 METAL5_436000_109000 0.028
R_VDD3_11833 METAL5_436000_109000 METAL5_436000_105000 0.016
R_VDD3_11834 METAL5_436000_105000 METAL5_436000_104000 0.004
R_VDD3_11835 METAL5_436000_104000 METAL5_436000_97000 0.028
R_VDD3_11836 METAL5_436000_97000 METAL5_436000_93000 0.016
R_VDD3_11837 METAL5_436000_93000 METAL5_436000_92000 0.004
R_VDD3_11838 METAL5_436000_92000 METAL5_436000_81000 0.044
R_VDD3_11839 METAL5_436000_81000 METAL5_436000_80000 0.004
R_VDD3_11840 METAL5_436000_80000 METAL5_436000_69000 0.044
R_VDD3_11841 METAL5_436000_69000 METAL5_436000_68000 0.004
R_VDD3_11842 METAL5_436000_68000 METAL4_436000_68000 0.1
R_VDD3_11843 METAL4_436000_68000 METAL3_436000_68000 0.1
R_VDD3_11844 METAL3_436000_68000 METAL3_436000_57000 0.088
R_VDD3_11845 METAL3_436000_57000 METAL3_436000_56000 0.008
R_VDD3_11846 METAL3_436000_56000 METAL3_436000_45000 0.088
R_VDD3_11847 METAL3_436000_45000 METAL3_436000_44000 0.008
R_VDD3_11848 METAL3_436000_44000 METAL3_436000_33000 0.088
R_VDD3_11849 METAL3_436000_33000 METAL3_436000_32000 0.008
R_VDD3_11850 METAL3_436000_32000 METAL3_436000_20000 0.096
R_VDD3_11851 METAL3_436000_20000 METAL3_436000_8000 0.096
R_VDD3_11852 METAL3_436000_8000 METAL3_434000_8000 0.016
R_VDD3_11853 METAL3_434000_8000 METAL3_432000_8000 0.016
R_VDD3_11854 METAL3_432000_8000 METAL3_428000_8000 0.032
R_VDD3_11855 METAL3_428000_8000 METAL3_426000_8000 0.016
R_VDD3_11856 METAL3_426000_8000 METAL3_424000_8000 0.016
R_VDD3_11857 METAL3_424000_8000 METAL3_422000_8000 0.016
R_VDD3_11858 METAL3_422000_8000 METAL3_420000_8000 0.016
R_VDD3_11859 METAL3_420000_8000 METAL3_416000_8000 0.032
R_VDD3_11860 METAL3_416000_8000 METAL3_414000_8000 0.016
R_VDD3_11861 METAL3_414000_8000 METAL3_412000_8000 0.016
R_VDD3_11862 METAL3_412000_8000 METAL3_410000_8000 0.016
R_VDD3_11863 METAL3_410000_8000 METAL3_408000_8000 0.016
R_VDD3_11864 METAL3_408000_8000 METAL3_404000_8000 0.032
R_VDD3_11865 METAL3_404000_8000 METAL3_402000_8000 0.016
R_VDD3_11866 METAL3_402000_8000 METAL3_400000_8000 0.016
R_VDD3_11867 METAL3_400000_8000 METAL4_400000_8000 0.1
R_VDD3_11868 METAL4_400000_8000 METAL5_400000_8000 0.1
R_VDD3_11869 METAL5_400000_8000 METAL6_400000_8000 0.1
R_VDD3_11870 METAL4_300000_565000 METAL3_300000_565000 0.1
R_VDD3_11871 METAL3_300000_565000 METAL3_300000_577000 0.096
R_VDD3_11872 METAL3_300000_577000 METAL3_300000_589000 0.096
R_VDD3_11873 METAL3_300000_589000 METAL3_302000_589000 0.016
R_VDD3_11874 METAL3_302000_589000 METAL3_304000_589000 0.016
R_VDD3_11875 METAL3_304000_589000 METAL3_305000_589000 0.008
R_VDD3_11876 METAL3_305000_589000 METAL3_306000_589000 0.008
R_VDD3_11877 METAL3_306000_589000 METAL3_312000_589000 0.048
R_VDD3_11878 METAL3_312000_589000 METAL3_314000_589000 0.016
R_VDD3_11879 METAL3_314000_589000 METAL3_316000_589000 0.016
R_VDD3_11880 METAL3_316000_589000 METAL3_317000_589000 0.008
R_VDD3_11881 METAL3_317000_589000 METAL3_318000_589000 0.008
R_VDD3_11882 METAL3_318000_589000 METAL3_324000_589000 0.048
R_VDD3_11883 METAL3_324000_589000 METAL3_324000_601000 0.096
R_VDD3_11884 METAL3_324000_601000 METAL3_324000_613000 0.096
R_VDD3_11885 METAL3_324000_613000 METAL3_324000_625000 0.096
R_VDD3_11886 METAL3_324000_625000 METAL3_324000_657000 0.256
R_VDD3_11887 METAL3_324000_657000 METAL3_324000_669000 0.096
R_VDD3_11888 METAL3_324000_669000 METAL3_324000_681000 0.096
R_VDD3_11889 METAL3_324000_681000 METAL3_324000_693000 0.096
R_VDD3_11890 METAL3_324000_693000 METAL3_324000_705000 0.096
R_VDD3_11891 METAL3_324000_705000 METAL3_318000_705000 0.048
R_VDD3_11892 METAL3_318000_705000 METAL3_318000_707000 0.016
R_VDD3_11893 METAL3_318000_707000 METAL3_318000_717000 0.08
R_VDD3_11894 METAL3_318000_717000 METAL3_318000_729000 0.096
R_VDD3_11895 METAL3_318000_729000 METAL3_318000_757000 0.224
R_VDD3_11896 METAL3_318000_757000 METAL3_318000_769000 0.096
R_VDD3_11897 METAL3_318000_769000 METAL3_318000_781000 0.096
R_VDD3_11898 METAL3_318000_781000 METAL3_318000_793000 0.096
R_VDD3_11899 METAL3_318000_793000 METAL3_317000_793000 0.008
R_VDD3_11900 METAL3_317000_793000 METAL3_316000_793000 0.008
R_VDD3_11901 METAL3_316000_793000 METAL3_314000_793000 0.016
R_VDD3_11902 METAL3_314000_793000 METAL3_312000_793000 0.016
R_VDD3_11903 METAL3_312000_793000 METAL3_306000_793000 0.048
R_VDD3_11904 METAL3_306000_793000 METAL3_305000_793000 0.008
R_VDD3_11905 METAL3_305000_793000 METAL3_304000_793000 0.008
R_VDD3_11906 METAL3_304000_793000 METAL3_302000_793000 0.016
R_VDD3_11907 METAL3_302000_793000 METAL3_300000_793000 0.016
R_VDD3_11908 METAL3_300000_793000 METAL3_300000_805000 0.096
R_VDD3_11909 METAL3_300000_805000 METAL3_300000_817000 0.096
R_VDD3_11910 METAL3_300000_817000 METAL3_300000_829000 0.096
R_VDD3_11911 METAL3_300000_829000 METAL3_300000_841000 0.096
R_VDD3_11912 METAL3_300000_841000 METAL3_294000_841000 0.048
R_VDD3_11913 METAL3_294000_841000 METAL3_294000_845000 0.032
R_VDD3_11914 METAL3_294000_845000 METAL3_294000_853000 0.064
R_VDD3_11915 METAL3_294000_853000 METAL3_294000_857000 0.032
R_VDD3_11916 METAL3_294000_857000 METAL3_294000_865000 0.064
R_VDD3_11917 METAL3_294000_865000 METAL3_294000_869000 0.032
R_VDD3_11918 METAL3_294000_869000 METAL3_294000_877000 0.064
R_VDD3_11919 METAL3_294000_877000 METAL3_294000_881000 0.032
R_VDD3_11920 METAL3_294000_881000 METAL3_294000_889000 0.064
R_VDD3_11921 METAL3_294000_889000 METAL3_294000_893000 0.032
R_VDD3_11922 METAL3_294000_893000 METAL3_294000_901000 0.064
R_VDD3_11923 METAL3_294000_901000 METAL3_294000_905000 0.032
R_VDD3_11924 METAL3_294000_905000 METAL3_294000_913000 0.064
R_VDD3_11925 METAL3_294000_913000 METAL3_294000_917000 0.032
R_VDD3_11926 METAL3_294000_917000 METAL3_294000_929000 0.096
R_VDD3_11927 METAL3_294000_929000 METAL3_294000_941000 0.096
R_VDD3_11928 METAL3_294000_941000 METAL3_294000_953000 0.096
R_VDD3_11929 METAL3_294000_953000 METAL3_294000_965000 0.096
R_VDD3_11930 METAL3_294000_965000 METAL3_294000_977000 0.096
R_VDD3_11931 METAL3_294000_977000 METAL3_294000_989000 0.096
R_VDD3_11932 METAL3_294000_989000 METAL3_293000_989000 0.008
R_VDD3_11933 METAL3_293000_989000 METAL3_292000_989000 0.008
R_VDD3_11934 METAL3_292000_989000 METAL3_290000_989000 0.016
R_VDD3_11935 METAL3_290000_989000 METAL3_288000_989000 0.016
R_VDD3_11936 METAL3_288000_989000 METAL4_288000_989000 0.1
R_VDD3_11937 METAL4_288000_989000 METAL4_282000_989000 0.048
R_VDD3_11938 METAL4_282000_989000 METAL4_281000_989000 0.008
R_VDD3_11939 METAL4_281000_989000 METAL4_280000_989000 0.008
R_VDD3_11940 METAL4_280000_989000 METAL4_278000_989000 0.016
R_VDD3_11941 METAL4_278000_989000 METAL4_276000_989000 0.016
R_VDD3_11942 METAL4_276000_989000 METAL4_270000_989000 0.048
R_VDD3_11943 METAL4_270000_989000 METAL4_269000_989000 0.008
R_VDD3_11944 METAL4_269000_989000 METAL4_268000_989000 0.008
R_VDD3_11945 METAL4_268000_989000 METAL4_266000_989000 0.016
R_VDD3_11946 METAL4_266000_989000 METAL4_264000_989000 0.016
R_VDD3_11947 METAL4_264000_989000 METAL4_258000_989000 0.048
R_VDD3_11948 METAL4_258000_989000 METAL4_257000_989000 0.008
R_VDD3_11949 METAL4_257000_989000 METAL5_257000_989000 0.1
R_VDD3_11950 METAL5_257000_989000 METAL5_257000_1001000 0.048
R_VDD3_11951 METAL5_257000_1001000 METAL5_257000_1013000 0.048
R_VDD3_11952 METAL5_257000_1013000 METAL5_257000_1025000 0.048
R_VDD3_11953 METAL5_257000_1025000 METAL5_257000_1037000 0.048
R_VDD3_11954 METAL5_257000_1037000 METAL5_257000_1041000 0.016
R_VDD3_11955 METAL5_257000_1041000 METAL5_257000_1053000 0.048
R_VDD3_11956 METAL5_257000_1053000 METAL5_257000_1065000 0.048
R_VDD3_11957 METAL5_257000_1065000 METAL6_257000_1065000 0.1
R_VDD3_11958 METAL4_300000_565000 METAL4_300000_553000 0.096
R_VDD3_11959 METAL4_300000_553000 METAL3_300000_553000 0.1
R_VDD3_11960 METAL3_300000_553000 METAL3_302000_553000 0.016
R_VDD3_11961 METAL3_302000_553000 METAL3_304000_553000 0.016
R_VDD3_11962 METAL3_304000_553000 METAL3_305000_553000 0.008
R_VDD3_11963 METAL3_305000_553000 METAL3_306000_553000 0.008
R_VDD3_11964 METAL3_306000_553000 METAL3_312000_553000 0.048
R_VDD3_11965 METAL3_312000_553000 METAL3_312000_565000 0.096
R_VDD3_11966 METAL3_312000_565000 METAL3_312000_577000 0.096
R_VDD3_11967 METAL3_312000_577000 METAL3_314000_577000 0.016
R_VDD3_11968 METAL3_314000_577000 METAL3_316000_577000 0.016
R_VDD3_11969 METAL3_316000_577000 METAL3_317000_577000 0.008
R_VDD3_11970 METAL3_317000_577000 METAL2_317000_577000 0.1
R_VDD3_11971 METAL2_317000_577000 METAL1_317000_577000 0.1
R_VDD3_11972 METAL1_317000_577000 METAL1_317000_589000 0.096
R_VDD3_11973 METAL1_317000_589000 METAL1_317000_601000 0.096
R_VDD3_11974 METAL1_317000_601000 METAL1_317000_613000 0.096
R_VDD3_11975 METAL1_317000_613000 METAL1_317000_625000 0.096
R_VDD3_11976 METAL1_317000_625000 METAL1_317000_657000 0.256
R_VDD3_11977 METAL1_317000_657000 METAL1_317000_669000 0.096
R_VDD3_11978 METAL1_317000_669000 METAL1_317000_681000 0.096
R_VDD3_11979 METAL1_317000_681000 METAL1_317000_693000 0.096
R_VDD3_11980 METAL1_317000_693000 METAL1_317000_705000 0.096
R_VDD3_11981 METAL1_317000_705000 METAL1_317000_707000 0.016
R_VDD3_11982 METAL1_317000_707000 METAL1_317000_717000 0.08
R_VDD3_11983 METAL1_317000_717000 METAL1_317000_729000 0.096
R_VDD3_11984 METAL1_317000_729000 METAL1_317000_757000 0.224
R_VDD3_11985 METAL1_317000_757000 METAL1_317000_769000 0.096
R_VDD3_11986 METAL1_317000_769000 METAL1_317000_781000 0.096
R_VDD3_11987 METAL1_317000_781000 METAL1_317000_793000 0.096
R_VDD3_11988 METAL1_317000_793000 METAL1_317000_805000 0.096
R_VDD3_11989 METAL1_317000_805000 METAL1_317000_817000 0.096
R_VDD3_11990 METAL1_317000_817000 METAL1_317000_829000 0.096
R_VDD3_11991 METAL1_317000_829000 METAL1_317000_841000 0.096
R_VDD3_11992 METAL1_317000_841000 METAL1_317000_845000 0.032
R_VDD3_11993 METAL1_317000_845000 METAL1_317000_853000 0.064
R_VDD3_11994 METAL1_317000_853000 METAL1_317000_857000 0.032
R_VDD3_11995 METAL1_317000_857000 METAL1_317000_865000 0.064
R_VDD3_11996 METAL1_317000_865000 METAL1_317000_869000 0.032
R_VDD3_11997 METAL1_317000_869000 METAL1_317000_877000 0.064
R_VDD3_11998 METAL1_317000_877000 METAL1_317000_881000 0.032
R_VDD3_11999 METAL1_317000_881000 METAL1_317000_889000 0.064
R_VDD3_12000 METAL1_317000_889000 METAL1_317000_893000 0.032
R_VDD3_12001 METAL1_317000_893000 METAL1_317000_901000 0.064
R_VDD3_12002 METAL1_317000_901000 METAL1_317000_905000 0.032
R_VDD3_12003 METAL1_317000_905000 METAL1_317000_913000 0.064
R_VDD3_12004 METAL1_317000_913000 METAL1_317000_917000 0.032
R_VDD3_12005 METAL1_317000_917000 METAL1_317000_929000 0.096
R_VDD3_12006 METAL1_317000_929000 METAL1_317000_941000 0.096
R_VDD3_12007 METAL1_317000_941000 METAL1_317000_953000 0.096
R_VDD3_12008 METAL1_317000_953000 METAL1_317000_965000 0.096
R_VDD3_12009 METAL1_317000_965000 METAL1_317000_977000 0.096
R_VDD3_12010 METAL1_317000_977000 METAL1_317000_989000 0.096
R_VDD3_12011 METAL1_317000_989000 METAL1_317000_1001000 0.096
R_VDD3_12012 METAL1_317000_1001000 METAL1_317000_1013000 0.096
R_VDD3_12013 METAL1_317000_1013000 METAL1_317000_1025000 0.096
R_VDD3_12014 METAL1_317000_1025000 METAL1_317000_1037000 0.096
R_VDD3_12015 METAL1_317000_1037000 METAL1_317000_1041000 0.032
R_VDD3_12016 METAL1_317000_1041000 METAL1_317000_1053000 0.096
R_VDD3_12017 METAL1_317000_1053000 METAL1_317000_1065000 0.096
R_VDD3_12018 METAL1_317000_1065000 METAL1_316000_1065000 0.008
R_VDD3_12019 METAL1_316000_1065000 METAL1_314000_1065000 0.016
R_VDD3_12020 METAL1_314000_1065000 METAL1_312000_1065000 0.016
R_VDD3_12021 METAL1_312000_1065000 METAL1_306000_1065000 0.048
R_VDD3_12022 METAL1_306000_1065000 METAL1_305000_1065000 0.008
R_VDD3_12023 METAL1_305000_1065000 METAL1_304000_1065000 0.008
R_VDD3_12024 METAL1_304000_1065000 METAL1_302000_1065000 0.016
R_VDD3_12025 METAL1_302000_1065000 METAL1_300000_1065000 0.016
R_VDD3_12026 METAL1_300000_1065000 METAL1_294000_1065000 0.048
R_VDD3_12027 METAL1_294000_1065000 METAL1_293000_1065000 0.008
R_VDD3_12028 METAL1_293000_1065000 METAL1_292000_1065000 0.008
R_VDD3_12029 METAL1_292000_1065000 METAL1_290000_1065000 0.016
R_VDD3_12030 METAL1_290000_1065000 METAL1_288000_1065000 0.016
R_VDD3_12031 METAL1_288000_1065000 METAL1_282000_1065000 0.048
R_VDD3_12032 METAL1_282000_1065000 METAL1_281000_1065000 0.008
R_VDD3_12033 METAL1_281000_1065000 METAL1_280000_1065000 0.008
R_VDD3_12034 METAL1_280000_1065000 METAL1_278000_1065000 0.016
R_VDD3_12035 METAL1_278000_1065000 METAL1_276000_1065000 0.016
R_VDD3_12036 METAL1_276000_1065000 METAL1_270000_1065000 0.048
R_VDD3_12037 METAL1_270000_1065000 METAL1_269000_1065000 0.008
R_VDD3_12038 METAL1_269000_1065000 METAL1_268000_1065000 0.008
R_VDD3_12039 METAL1_268000_1065000 METAL1_266000_1065000 0.016
R_VDD3_12040 METAL1_266000_1065000 METAL1_264000_1065000 0.016
R_VDD3_12041 METAL1_264000_1065000 METAL1_258000_1065000 0.048
R_VDD3_12042 METAL1_258000_1065000 METAL1_257000_1065000 0.008
R_VDD3_12043 METAL1_257000_1065000 METAL2_257000_1065000 0.1
R_VDD3_12044 METAL2_257000_1065000 METAL3_257000_1065000 0.1
R_VDD3_12045 METAL3_257000_1065000 METAL4_257000_1065000 0.1
R_VDD3_12046 METAL4_257000_1065000 METAL5_257000_1065000 0.1
R_VDD3_12047 METAL4_276000_601000 METAL4_276000_613000 0.096
R_VDD3_12048 METAL4_276000_613000 METAL4_276000_625000 0.096
R_VDD3_12049 METAL4_276000_625000 METAL4_276000_657000 0.256
R_VDD3_12050 METAL4_276000_657000 METAL4_276000_669000 0.096
R_VDD3_12051 METAL4_276000_669000 METAL4_276000_681000 0.096
R_VDD3_12052 METAL4_276000_681000 METAL4_276000_693000 0.096
R_VDD3_12053 METAL4_276000_693000 METAL4_276000_705000 0.096
R_VDD3_12054 METAL4_276000_705000 METAL4_276000_707000 0.016
R_VDD3_12055 METAL4_276000_707000 METAL4_276000_717000 0.08
R_VDD3_12056 METAL4_276000_717000 METAL4_276000_729000 0.096
R_VDD3_12057 METAL4_276000_729000 METAL4_276000_757000 0.224
R_VDD3_12058 METAL4_276000_757000 METAL4_276000_769000 0.096
R_VDD3_12059 METAL4_276000_769000 METAL4_276000_781000 0.096
R_VDD3_12060 METAL4_276000_781000 METAL4_278000_781000 0.016
R_VDD3_12061 METAL4_278000_781000 METAL4_280000_781000 0.016
R_VDD3_12062 METAL4_280000_781000 METAL4_281000_781000 0.008
R_VDD3_12063 METAL4_281000_781000 METAL4_282000_781000 0.008
R_VDD3_12064 METAL4_282000_781000 METAL4_288000_781000 0.048
R_VDD3_12065 METAL4_288000_781000 METAL4_290000_781000 0.016
R_VDD3_12066 METAL4_290000_781000 METAL4_292000_781000 0.016
R_VDD3_12067 METAL4_292000_781000 METAL4_293000_781000 0.008
R_VDD3_12068 METAL4_293000_781000 METAL3_293000_781000 0.1
R_VDD3_12069 METAL3_293000_781000 METAL3_294000_781000 0.008
R_VDD3_12070 METAL3_294000_781000 METAL3_300000_781000 0.048
R_VDD3_12071 METAL3_300000_781000 METAL3_302000_781000 0.016
R_VDD3_12072 METAL3_302000_781000 METAL3_304000_781000 0.016
R_VDD3_12073 METAL3_304000_781000 METAL3_305000_781000 0.008
R_VDD3_12074 METAL3_305000_781000 METAL2_305000_781000 0.1
R_VDD3_12075 METAL2_305000_781000 METAL1_305000_781000 0.1
R_VDD3_12076 METAL1_305000_781000 METAL1_305000_793000 0.096
R_VDD3_12077 METAL1_305000_793000 METAL1_305000_805000 0.096
R_VDD3_12078 METAL1_305000_805000 METAL1_305000_817000 0.096
R_VDD3_12079 METAL1_305000_817000 METAL1_305000_829000 0.096
R_VDD3_12080 METAL1_305000_829000 METAL1_305000_841000 0.096
R_VDD3_12081 METAL1_305000_841000 METAL1_305000_845000 0.032
R_VDD3_12082 METAL1_305000_845000 METAL1_305000_853000 0.064
R_VDD3_12083 METAL1_305000_853000 METAL1_305000_857000 0.032
R_VDD3_12084 METAL1_305000_857000 METAL1_305000_865000 0.064
R_VDD3_12085 METAL1_305000_865000 METAL1_305000_869000 0.032
R_VDD3_12086 METAL1_305000_869000 METAL1_305000_877000 0.064
R_VDD3_12087 METAL1_305000_877000 METAL1_305000_881000 0.032
R_VDD3_12088 METAL1_305000_881000 METAL1_305000_889000 0.064
R_VDD3_12089 METAL1_305000_889000 METAL1_305000_893000 0.032
R_VDD3_12090 METAL1_305000_893000 METAL1_305000_901000 0.064
R_VDD3_12091 METAL1_305000_901000 METAL1_305000_905000 0.032
R_VDD3_12092 METAL1_305000_905000 METAL1_305000_913000 0.064
R_VDD3_12093 METAL1_305000_913000 METAL1_305000_917000 0.032
R_VDD3_12094 METAL1_305000_917000 METAL1_305000_929000 0.096
R_VDD3_12095 METAL1_305000_929000 METAL1_305000_941000 0.096
R_VDD3_12096 METAL1_305000_941000 METAL1_305000_953000 0.096
R_VDD3_12097 METAL1_305000_953000 METAL1_305000_965000 0.096
R_VDD3_12098 METAL1_305000_965000 METAL1_305000_977000 0.096
R_VDD3_12099 METAL1_305000_977000 METAL1_305000_989000 0.096
R_VDD3_12100 METAL1_305000_989000 METAL1_305000_1001000 0.096
R_VDD3_12101 METAL1_305000_1001000 METAL1_305000_1013000 0.096
R_VDD3_12102 METAL1_305000_1013000 METAL1_305000_1025000 0.096
R_VDD3_12103 METAL1_305000_1025000 METAL1_305000_1037000 0.096
R_VDD3_12104 METAL1_305000_1037000 METAL1_305000_1041000 0.032
R_VDD3_12105 METAL1_305000_1041000 METAL1_305000_1053000 0.096
R_VDD3_12106 METAL1_305000_1053000 METAL1_304000_1053000 0.008
R_VDD3_12107 METAL1_304000_1053000 METAL1_302000_1053000 0.016
R_VDD3_12108 METAL1_302000_1053000 METAL1_300000_1053000 0.016
R_VDD3_12109 METAL1_300000_1053000 METAL1_294000_1053000 0.048
R_VDD3_12110 METAL1_294000_1053000 METAL1_293000_1053000 0.008
R_VDD3_12111 METAL1_293000_1053000 METAL1_292000_1053000 0.008
R_VDD3_12112 METAL1_292000_1053000 METAL1_290000_1053000 0.016
R_VDD3_12113 METAL1_290000_1053000 METAL1_288000_1053000 0.016
R_VDD3_12114 METAL1_288000_1053000 METAL1_282000_1053000 0.048
R_VDD3_12115 METAL1_282000_1053000 METAL1_281000_1053000 0.008
R_VDD3_12116 METAL1_281000_1053000 METAL1_280000_1053000 0.008
R_VDD3_12117 METAL1_280000_1053000 METAL1_278000_1053000 0.016
R_VDD3_12118 METAL1_278000_1053000 METAL1_276000_1053000 0.016
R_VDD3_12119 METAL1_276000_1053000 METAL1_270000_1053000 0.048
R_VDD3_12120 METAL1_270000_1053000 METAL1_269000_1053000 0.008
R_VDD3_12121 METAL1_269000_1053000 METAL1_268000_1053000 0.008
R_VDD3_12122 METAL1_268000_1053000 METAL1_266000_1053000 0.016
R_VDD3_12123 METAL1_266000_1053000 METAL1_264000_1053000 0.016
R_VDD3_12124 METAL1_264000_1053000 METAL2_264000_1053000 0.1
R_VDD3_12125 METAL2_264000_1053000 METAL2_258000_1053000 0.048
R_VDD3_12126 METAL2_258000_1053000 METAL2_257000_1053000 0.008
R_VDD3_12127 METAL2_257000_1053000 METAL3_257000_1053000 0.1
R_VDD3_12128 METAL3_257000_1053000 METAL4_257000_1053000 0.1
R_VDD3_12129 METAL4_257000_1053000 METAL4_257000_1065000 0.096
R_VDD3_12130 METAL4_269000_953000 METAL4_268000_953000 0.008
R_VDD3_12131 METAL4_268000_953000 METAL4_266000_953000 0.016
R_VDD3_12132 METAL4_266000_953000 METAL4_264000_953000 0.016
R_VDD3_12133 METAL4_264000_953000 METAL4_258000_953000 0.048
R_VDD3_12134 METAL4_258000_953000 METAL4_257000_953000 0.008
R_VDD3_12135 METAL4_257000_953000 METAL3_257000_953000 0.1
R_VDD3_12136 METAL3_257000_953000 METAL2_257000_953000 0.1
R_VDD3_12137 METAL2_257000_953000 METAL1_257000_953000 0.1
R_VDD3_12138 METAL1_257000_953000 METAL1_258000_953000 0.008
R_VDD3_12139 METAL1_258000_953000 METAL1_264000_953000 0.048
R_VDD3_12140 METAL1_264000_953000 METAL1_266000_953000 0.016
R_VDD3_12141 METAL1_266000_953000 METAL1_268000_953000 0.016
R_VDD3_12142 METAL1_268000_953000 METAL1_269000_953000 0.008
R_VDD3_12143 METAL1_269000_953000 METAL1_269000_965000 0.096
R_VDD3_12144 METAL1_269000_965000 METAL1_269000_977000 0.096
R_VDD3_12145 METAL1_269000_977000 METAL1_269000_989000 0.096
R_VDD3_12146 METAL1_269000_989000 METAL1_269000_1001000 0.096
R_VDD3_12147 METAL1_269000_1001000 METAL1_269000_1013000 0.096
R_VDD3_12148 METAL1_269000_1013000 METAL1_269000_1025000 0.096
R_VDD3_12149 METAL1_269000_1025000 METAL1_269000_1037000 0.096
R_VDD3_12150 METAL1_269000_1037000 METAL1_269000_1041000 0.032
R_VDD3_12151 METAL1_269000_1041000 METAL1_268000_1041000 0.008
R_VDD3_12152 METAL1_268000_1041000 METAL1_266000_1041000 0.016
R_VDD3_12153 METAL1_266000_1041000 METAL1_264000_1041000 0.016
R_VDD3_12154 METAL1_264000_1041000 METAL2_264000_1041000 0.1
R_VDD3_12155 METAL2_264000_1041000 METAL2_258000_1041000 0.048
R_VDD3_12156 METAL2_258000_1041000 METAL2_257000_1041000 0.008
R_VDD3_12157 METAL2_257000_1041000 METAL3_257000_1041000 0.1
R_VDD3_12158 METAL3_257000_1041000 METAL4_257000_1041000 0.1
R_VDD3_12159 METAL4_257000_1041000 METAL4_258000_1041000 0.008
R_VDD3_12160 METAL4_258000_1041000 METAL4_264000_1041000 0.048
R_VDD3_12161 METAL4_264000_1041000 METAL4_266000_1041000 0.016
R_VDD3_12162 METAL4_266000_1041000 METAL4_268000_1041000 0.016
R_VDD3_12163 METAL4_268000_1041000 METAL4_269000_1041000 0.008
R_VDD3_12164 METAL4_269000_1041000 METAL4_269000_1053000 0.096
R_VDD3_12165 METAL4_269000_1053000 METAL4_269000_1065000 0.096
R_VDD3_12166 METAL4_269000_1065000 METAL4_268000_1065000 0.008
R_VDD3_12167 METAL4_268000_1065000 METAL4_266000_1065000 0.016
R_VDD3_12168 METAL4_266000_1065000 METAL4_264000_1065000 0.016
R_VDD3_12169 METAL4_264000_1065000 METAL4_258000_1065000 0.048
R_VDD3_12170 METAL4_258000_1065000 METAL4_257000_1065000 0.008
I_VDD3_41 METAL6_245000_6665000 gnd 0.01
I_VDD3_42 METAL6_555000_6665000 gnd 0.01
I_VDD3_43 METAL6_245000_5965000 gnd 0.01
I_VDD3_44 METAL6_555000_5965000 gnd 0.01
I_VDD3_45 METAL6_245000_5265000 gnd 0.01
I_VDD3_46 METAL6_555000_5265000 gnd 0.01
I_VDD3_47 METAL6_245000_4565000 gnd 0.01
I_VDD3_48 METAL6_555000_4565000 gnd 0.01
I_VDD3_49 METAL6_245000_3865000 gnd 0.01
I_VDD3_50 METAL6_555000_3865000 gnd 0.01
I_VDD3_51 METAL6_245000_3165000 gnd 0.01
I_VDD3_52 METAL6_555000_3165000 gnd 0.01
I_VDD3_53 METAL6_245000_2465000 gnd 0.01
I_VDD3_54 METAL6_555000_2465000 gnd 0.01
I_VDD3_55 METAL6_555000_1765000 gnd 0.01
I_VDD3_56 METAL6_245000_1765000 gnd 0.01
I_VDD3_57 METAL6_555000_1065000 gnd 0.01
I_VDD3_58 METAL6_245000_1065000 gnd 0.01
I_VDD3_59 METAL6_555000_365000 gnd 0.01
I_VDD3_60 METAL6_245000_365000 gnd 0.01

V_VDD4_4 METAL6_450000_0 gnd 1
R_VDD4_12171 METAL6_450000_0 METAL6_450000_8000 0.016
R_VDD4_12172 METAL6_450000_8000 METAL6_450000_20000 0.024
R_VDD4_12173 METAL6_450000_20000 METAL6_450000_32000 0.024
R_VDD4_12174 METAL6_450000_32000 METAL6_450000_129000 0.194
R_VDD4_12175 METAL6_450000_129000 METAL6_450000_141000 0.024
R_VDD4_12176 METAL6_450000_141000 METAL6_450000_153000 0.024
R_VDD4_12177 METAL6_450000_153000 METAL6_450000_165000 0.024
R_VDD4_12178 METAL6_450000_165000 METAL6_450000_177000 0.024
R_VDD4_12179 METAL6_450000_177000 METAL6_450000_241000 0.128
R_VDD4_12180 METAL6_450000_241000 METAL6_448000_241000 0.004
R_VDD4_12181 METAL6_448000_241000 METAL6_438000_241000 0.02
R_VDD4_12182 METAL6_438000_241000 METAL6_436000_241000 0.004
R_VDD4_12183 METAL6_436000_241000 METAL6_426000_241000 0.02
R_VDD4_12184 METAL6_426000_241000 METAL6_426000_253000 0.024
R_VDD4_12185 METAL6_426000_253000 METAL6_424000_253000 0.004
R_VDD4_12186 METAL6_424000_253000 METAL6_414000_253000 0.02
R_VDD4_12187 METAL6_414000_253000 METAL6_414000_265000 0.024
R_VDD4_12188 METAL6_414000_265000 METAL6_412000_265000 0.004
R_VDD4_12189 METAL6_412000_265000 METAL6_402000_265000 0.02
R_VDD4_12190 METAL6_402000_265000 METAL6_402000_277000 0.024
R_VDD4_12191 METAL6_402000_277000 METAL6_402000_289000 0.024
R_VDD4_12192 METAL6_402000_289000 METAL6_402000_301000 0.024
R_VDD4_12193 METAL6_402000_301000 METAL6_402000_317000 0.032
R_VDD4_12194 METAL6_402000_317000 METAL6_400000_317000 0.004
R_VDD4_12195 METAL6_400000_317000 METAL6_390000_317000 0.02
R_VDD4_12196 METAL6_390000_317000 METAL6_390000_329000 0.024
R_VDD4_12197 METAL6_390000_329000 METAL5_390000_329000 0.1
R_VDD4_12198 METAL5_390000_329000 METAL5_390000_341000 0.048
R_VDD4_12199 METAL5_390000_341000 METAL5_390000_353000 0.048
R_VDD4_12200 METAL5_390000_353000 METAL5_390000_365000 0.048
R_VDD4_12201 METAL5_390000_365000 METAL6_390000_365000 0.1
R_VDD4_12202 METAL6_390000_365000 METAL6_390000_377000 0.024
R_VDD4_12203 METAL6_390000_377000 METAL6_390000_441000 0.128
R_VDD4_12204 METAL6_390000_441000 METAL6_390000_453000 0.024
R_VDD4_12205 METAL6_390000_453000 METAL6_390000_465000 0.024
R_VDD4_12206 METAL6_390000_465000 METAL6_390000_477000 0.024
R_VDD4_12207 METAL6_390000_477000 METAL6_390000_505000 0.056
R_VDD4_12208 METAL6_390000_505000 METAL6_388000_505000 0.004
R_VDD4_12209 METAL6_388000_505000 METAL6_386000_505000 0.004
R_VDD4_12210 METAL6_386000_505000 METAL6_376000_505000 0.02
R_VDD4_12211 METAL6_376000_505000 METAL6_374000_505000 0.004
R_VDD4_12212 METAL6_374000_505000 METAL6_364000_505000 0.02
R_VDD4_12213 METAL6_364000_505000 METAL6_362000_505000 0.004
R_VDD4_12214 METAL6_362000_505000 METAL6_352000_505000 0.02
R_VDD4_12215 METAL6_352000_505000 METAL6_352000_517000 0.024
R_VDD4_12216 METAL6_352000_517000 METAL6_352000_529000 0.024
R_VDD4_12217 METAL6_352000_529000 METAL6_352000_541000 0.024
R_VDD4_12218 METAL6_352000_541000 METAL6_352000_553000 0.024
R_VDD4_12219 METAL6_352000_553000 METAL6_352000_565000 0.024
R_VDD4_12220 METAL6_352000_565000 METAL6_352000_577000 0.024
R_VDD4_12221 METAL6_352000_577000 METAL6_352000_589000 0.024
R_VDD4_12222 METAL6_352000_589000 METAL6_352000_601000 0.024
R_VDD4_12223 METAL6_352000_601000 METAL6_352000_613000 0.024
R_VDD4_12224 METAL6_352000_613000 METAL6_352000_681000 0.136
R_VDD4_12225 METAL6_352000_681000 METAL6_352000_693000 0.024
R_VDD4_12226 METAL6_352000_693000 METAL6_352000_705000 0.024
R_VDD4_12227 METAL6_352000_705000 METAL6_352000_707000 0.004
R_VDD4_12228 METAL6_352000_707000 METAL6_352000_717000 0.02
R_VDD4_12229 METAL6_352000_717000 METAL6_352000_793000 0.152
R_VDD4_12230 METAL6_352000_793000 METAL6_352000_805000 0.024
R_VDD4_12231 METAL6_352000_805000 METAL6_352000_817000 0.024
R_VDD4_12232 METAL6_352000_817000 METAL6_352000_829000 0.024
R_VDD4_12233 METAL6_352000_829000 METAL6_362000_829000 0.02
R_VDD4_12234 METAL6_362000_829000 METAL5_362000_829000 0.1
R_VDD4_12235 METAL5_362000_829000 METAL5_362000_841000 0.048
R_VDD4_12236 METAL5_362000_841000 METAL5_362000_853000 0.048
R_VDD4_12237 METAL5_362000_853000 METAL5_362000_865000 0.048
R_VDD4_12238 METAL5_362000_865000 METAL5_362000_877000 0.048
R_VDD4_12239 METAL5_362000_877000 METAL5_362000_889000 0.048
R_VDD4_12240 METAL5_362000_889000 METAL5_362000_905000 0.064
R_VDD4_12241 METAL5_362000_905000 METAL5_362000_917000 0.048
R_VDD4_12242 METAL5_362000_917000 METAL5_362000_929000 0.048
R_VDD4_12243 METAL5_362000_929000 METAL5_362000_941000 0.048
R_VDD4_12244 METAL5_362000_941000 METAL5_362000_953000 0.048
R_VDD4_12245 METAL5_362000_953000 METAL5_362000_965000 0.048
R_VDD4_12246 METAL5_362000_965000 METAL6_362000_965000 0.1
R_VDD4_12247 METAL6_362000_965000 METAL6_364000_965000 0.004
R_VDD4_12248 METAL6_364000_965000 METAL6_374000_965000 0.02
R_VDD4_12249 METAL6_374000_965000 METAL6_374000_977000 0.024
R_VDD4_12250 METAL6_374000_977000 METAL6_374000_989000 0.024
R_VDD4_12251 METAL6_374000_989000 METAL6_374000_1041000 0.104
R_VDD4_12252 METAL6_374000_1041000 METAL6_374000_1053000 0.024
R_VDD4_12253 METAL6_374000_1053000 METAL6_374000_1065000 0.024
R_VDD4_12254 METAL6_374000_1065000 METAL6_374000_1077000 0.024
R_VDD4_12255 METAL6_374000_1077000 METAL6_374000_1153000 0.152
R_VDD4_12256 METAL6_374000_1153000 METAL6_374000_1165000 0.024
R_VDD4_12257 METAL6_374000_1165000 METAL6_374000_1177000 0.024
R_VDD4_12258 METAL6_374000_1177000 METAL6_374000_1189000 0.024
R_VDD4_12259 METAL6_374000_1189000 METAL6_374000_1253000 0.128
R_VDD4_12260 METAL6_374000_1253000 METAL6_374000_1265000 0.024
R_VDD4_12261 METAL6_374000_1265000 METAL6_374000_1277000 0.024
R_VDD4_12262 METAL6_374000_1277000 METAL6_374000_1381000 0.208
R_VDD4_12263 METAL6_374000_1381000 METAL6_374000_1393000 0.024
R_VDD4_12264 METAL6_374000_1393000 METAL6_374000_1405000 0.024
R_VDD4_12265 METAL6_374000_1405000 METAL6_374000_1407000 0.004
R_VDD4_12266 METAL6_374000_1407000 METAL6_374000_1553000 0.292
R_VDD4_12267 METAL6_374000_1553000 METAL6_374000_1565000 0.024
R_VDD4_12268 METAL6_374000_1565000 METAL6_374000_1577000 0.024
R_VDD4_12269 METAL6_374000_1577000 METAL6_374000_1653000 0.152
R_VDD4_12270 METAL6_374000_1653000 METAL6_374000_1665000 0.024
R_VDD4_12271 METAL6_374000_1665000 METAL6_374000_1677000 0.024
R_VDD4_12272 METAL6_374000_1677000 METAL6_374000_1753000 0.152
R_VDD4_12273 METAL6_374000_1753000 METAL6_374000_1765000 0.024
R_VDD4_12274 METAL6_374000_1765000 METAL6_374000_1777000 0.024
R_VDD4_12275 METAL6_374000_1777000 METAL6_374000_1841000 0.128
R_VDD4_12276 METAL6_374000_1841000 METAL6_374000_1853000 0.024
R_VDD4_12277 METAL6_374000_1853000 METAL6_374000_1865000 0.024
R_VDD4_12278 METAL6_374000_1865000 METAL6_374000_1877000 0.024
R_VDD4_12279 METAL6_374000_1877000 METAL6_374000_1929000 0.104
R_VDD4_12280 METAL6_374000_1929000 METAL6_374000_1941000 0.024
R_VDD4_12281 METAL6_374000_1941000 METAL6_374000_1953000 0.024
R_VDD4_12282 METAL6_374000_1953000 METAL6_374000_1965000 0.024
R_VDD4_12283 METAL6_374000_1965000 METAL6_374000_1977000 0.024
R_VDD4_12284 METAL6_374000_1977000 METAL6_374000_2093000 0.232
R_VDD4_12285 METAL6_374000_2093000 METAL6_374000_2107000 0.028
R_VDD4_12286 METAL6_374000_2107000 METAL6_374000_2241000 0.268
R_VDD4_12287 METAL6_374000_2241000 METAL6_374000_2253000 0.024
R_VDD4_12288 METAL6_374000_2253000 METAL6_374000_2265000 0.024
R_VDD4_12289 METAL6_374000_2265000 METAL6_374000_2277000 0.024
R_VDD4_12290 METAL6_374000_2277000 METAL6_374000_2353000 0.152
R_VDD4_12291 METAL6_374000_2353000 METAL6_374000_2365000 0.024
R_VDD4_12292 METAL6_374000_2365000 METAL6_374000_2377000 0.024
R_VDD4_12293 METAL6_374000_2377000 METAL6_374000_2453000 0.152
R_VDD4_12294 METAL6_374000_2453000 METAL6_374000_2465000 0.024
R_VDD4_12295 METAL6_374000_2465000 METAL6_374000_2477000 0.024
R_VDD4_12296 METAL6_374000_2477000 METAL6_374000_2553000 0.152
R_VDD4_12297 METAL6_374000_2553000 METAL6_374000_2565000 0.024
R_VDD4_12298 METAL6_374000_2565000 METAL6_374000_2577000 0.024
R_VDD4_12299 METAL6_374000_2577000 METAL6_374000_2629000 0.104
R_VDD4_12300 METAL6_374000_2629000 METAL6_374000_2641000 0.024
R_VDD4_12301 METAL6_374000_2641000 METAL6_374000_2653000 0.024
R_VDD4_12302 METAL6_374000_2653000 METAL6_374000_2665000 0.024
R_VDD4_12303 METAL6_374000_2665000 METAL6_374000_2677000 0.024
R_VDD4_12304 METAL6_374000_2677000 METAL6_374000_2793000 0.232
R_VDD4_12305 METAL6_374000_2793000 METAL6_374000_2807000 0.028
R_VDD4_12306 METAL6_374000_2807000 METAL6_374000_2953000 0.292
R_VDD4_12307 METAL6_374000_2953000 METAL6_374000_2965000 0.024
R_VDD4_12308 METAL6_374000_2965000 METAL6_374000_2977000 0.024
R_VDD4_12309 METAL6_374000_2977000 METAL6_374000_3053000 0.152
R_VDD4_12310 METAL6_374000_3053000 METAL6_374000_3065000 0.024
R_VDD4_12311 METAL6_374000_3065000 METAL6_374000_3077000 0.024
R_VDD4_12312 METAL6_374000_3077000 METAL6_374000_3153000 0.152
R_VDD4_12313 METAL6_374000_3153000 METAL6_374000_3165000 0.024
R_VDD4_12314 METAL6_374000_3165000 METAL6_374000_3177000 0.024
R_VDD4_12315 METAL6_374000_3177000 METAL6_374000_3253000 0.152
R_VDD4_12316 METAL6_374000_3253000 METAL6_374000_3265000 0.024
R_VDD4_12317 METAL6_374000_3265000 METAL6_374000_3277000 0.024
R_VDD4_12318 METAL6_374000_3277000 METAL6_374000_3341000 0.128
R_VDD4_12319 METAL6_374000_3341000 METAL6_374000_3353000 0.024
R_VDD4_12320 METAL6_374000_3353000 METAL6_374000_3365000 0.024
R_VDD4_12321 METAL6_374000_3365000 METAL6_374000_3377000 0.024
R_VDD4_12322 METAL6_374000_3377000 METAL6_374000_3493000 0.232
R_VDD4_12323 METAL6_374000_3493000 METAL6_374000_3507000 0.028
R_VDD4_12324 METAL6_374000_3507000 METAL6_374000_3653000 0.292
R_VDD4_12325 METAL6_374000_3653000 METAL6_374000_3665000 0.024
R_VDD4_12326 METAL6_374000_3665000 METAL6_374000_3677000 0.024
R_VDD4_12327 METAL6_374000_3677000 METAL6_374000_3753000 0.152
R_VDD4_12328 METAL6_374000_3753000 METAL6_374000_3765000 0.024
R_VDD4_12329 METAL6_374000_3765000 METAL6_374000_3777000 0.024
R_VDD4_12330 METAL6_374000_3777000 METAL6_374000_3853000 0.152
R_VDD4_12331 METAL6_374000_3853000 METAL6_374000_3865000 0.024
R_VDD4_12332 METAL6_374000_3865000 METAL6_374000_3877000 0.024
R_VDD4_12333 METAL6_374000_3877000 METAL6_374000_3953000 0.152
R_VDD4_12334 METAL6_374000_3953000 METAL6_374000_3965000 0.024
R_VDD4_12335 METAL6_374000_3965000 METAL6_374000_3977000 0.024
R_VDD4_12336 METAL6_374000_3977000 METAL6_374000_4053000 0.152
R_VDD4_12337 METAL6_374000_4053000 METAL6_374000_4065000 0.024
R_VDD4_12338 METAL6_374000_4065000 METAL6_374000_4077000 0.024
R_VDD4_12339 METAL6_374000_4077000 METAL6_374000_4193000 0.232
R_VDD4_12340 METAL6_374000_4193000 METAL6_374000_4207000 0.028
R_VDD4_12341 METAL6_374000_4207000 METAL6_374000_4353000 0.292
R_VDD4_12342 METAL6_374000_4353000 METAL6_374000_4365000 0.024
R_VDD4_12343 METAL6_374000_4365000 METAL6_374000_4377000 0.024
R_VDD4_12344 METAL6_374000_4377000 METAL6_374000_4453000 0.152
R_VDD4_12345 METAL6_374000_4453000 METAL6_374000_4465000 0.024
R_VDD4_12346 METAL6_374000_4465000 METAL6_374000_4477000 0.024
R_VDD4_12347 METAL6_374000_4477000 METAL6_374000_4553000 0.152
R_VDD4_12348 METAL6_374000_4553000 METAL6_374000_4565000 0.024
R_VDD4_12349 METAL6_374000_4565000 METAL6_374000_4577000 0.024
R_VDD4_12350 METAL6_374000_4577000 METAL6_374000_4653000 0.152
R_VDD4_12351 METAL6_374000_4653000 METAL6_374000_4665000 0.024
R_VDD4_12352 METAL6_374000_4665000 METAL6_374000_4677000 0.024
R_VDD4_12353 METAL6_374000_4677000 METAL6_374000_4729000 0.104
R_VDD4_12354 METAL6_374000_4729000 METAL6_374000_4741000 0.024
R_VDD4_12355 METAL6_374000_4741000 METAL6_374000_4753000 0.024
R_VDD4_12356 METAL6_374000_4753000 METAL6_374000_4765000 0.024
R_VDD4_12357 METAL6_374000_4765000 METAL6_374000_4777000 0.024
R_VDD4_12358 METAL6_374000_4777000 METAL6_374000_4893000 0.232
R_VDD4_12359 METAL6_374000_4893000 METAL6_374000_4907000 0.028
R_VDD4_12360 METAL6_374000_4907000 METAL6_374000_5053000 0.292
R_VDD4_12361 METAL6_374000_5053000 METAL6_374000_5065000 0.024
R_VDD4_12362 METAL6_374000_5065000 METAL6_374000_5077000 0.024
R_VDD4_12363 METAL6_374000_5077000 METAL6_374000_5153000 0.152
R_VDD4_12364 METAL6_374000_5153000 METAL6_374000_5165000 0.024
R_VDD4_12365 METAL6_374000_5165000 METAL6_374000_5177000 0.024
R_VDD4_12366 METAL6_374000_5177000 METAL6_374000_5253000 0.152
R_VDD4_12367 METAL6_374000_5253000 METAL6_374000_5265000 0.024
R_VDD4_12368 METAL6_374000_5265000 METAL6_374000_5277000 0.024
R_VDD4_12369 METAL6_374000_5277000 METAL6_374000_5353000 0.152
R_VDD4_12370 METAL6_374000_5353000 METAL6_374000_5365000 0.024
R_VDD4_12371 METAL6_374000_5365000 METAL6_374000_5377000 0.024
R_VDD4_12372 METAL6_374000_5377000 METAL6_374000_5441000 0.128
R_VDD4_12373 METAL6_374000_5441000 METAL6_374000_5453000 0.024
R_VDD4_12374 METAL6_374000_5453000 METAL5_374000_5453000 0.1
R_VDD4_12375 METAL5_374000_5453000 METAL5_374000_5465000 0.048
R_VDD4_12376 METAL5_374000_5465000 METAL5_374000_5477000 0.048
R_VDD4_12377 METAL5_374000_5477000 METAL6_374000_5477000 0.1
R_VDD4_12378 METAL6_374000_5477000 METAL6_374000_5593000 0.232
R_VDD4_12379 METAL6_374000_5593000 METAL6_374000_5607000 0.028
R_VDD4_12380 METAL6_374000_5607000 METAL6_374000_5753000 0.292
R_VDD4_12381 METAL6_374000_5753000 METAL6_374000_5765000 0.024
R_VDD4_12382 METAL6_374000_5765000 METAL6_374000_5777000 0.024
R_VDD4_12383 METAL6_374000_5777000 METAL6_374000_5853000 0.152
R_VDD4_12384 METAL6_374000_5853000 METAL6_374000_5865000 0.024
R_VDD4_12385 METAL6_374000_5865000 METAL6_374000_5877000 0.024
R_VDD4_12386 METAL6_374000_5877000 METAL6_374000_5953000 0.152
R_VDD4_12387 METAL6_374000_5953000 METAL6_374000_5965000 0.024
R_VDD4_12388 METAL6_374000_5965000 METAL6_374000_5977000 0.024
R_VDD4_12389 METAL6_374000_5977000 METAL6_374000_6053000 0.152
R_VDD4_12390 METAL6_374000_6053000 METAL6_374000_6065000 0.024
R_VDD4_12391 METAL6_374000_6065000 METAL6_374000_6077000 0.024
R_VDD4_12392 METAL6_374000_6077000 METAL6_374000_6153000 0.152
R_VDD4_12393 METAL6_374000_6153000 METAL6_374000_6165000 0.024
R_VDD4_12394 METAL6_374000_6165000 METAL6_374000_6177000 0.024
R_VDD4_12395 METAL6_374000_6177000 METAL6_374000_6293000 0.232
R_VDD4_12396 METAL6_374000_6293000 METAL6_374000_6307000 0.028
R_VDD4_12397 METAL6_374000_6307000 METAL6_374000_6453000 0.292
R_VDD4_12398 METAL6_374000_6453000 METAL6_374000_6465000 0.024
R_VDD4_12399 METAL6_374000_6465000 METAL6_374000_6477000 0.024
R_VDD4_12400 METAL6_374000_6477000 METAL6_374000_6553000 0.152
R_VDD4_12401 METAL6_374000_6553000 METAL6_374000_6565000 0.024
R_VDD4_12402 METAL6_374000_6565000 METAL6_374000_6577000 0.024
R_VDD4_12403 METAL6_374000_6577000 METAL6_374000_6653000 0.152
R_VDD4_12404 METAL6_374000_6653000 METAL6_374000_6665000 0.024
R_VDD4_12405 METAL6_374000_6665000 METAL6_374000_6677000 0.024
R_VDD4_12406 METAL6_374000_6677000 METAL6_374000_6753000 0.152
R_VDD4_12407 METAL6_374000_6753000 METAL6_374000_6765000 0.024
R_VDD4_12408 METAL6_374000_6765000 METAL6_364000_6765000 0.02
R_VDD4_12409 METAL6_364000_6765000 METAL6_362000_6765000 0.004
R_VDD4_12410 METAL6_362000_6765000 METAL6_352000_6765000 0.02
R_VDD4_12411 METAL6_352000_6765000 METAL6_350000_6765000 0.004
R_VDD4_12412 METAL6_350000_6765000 METAL6_338000_6765000 0.024
R_VDD4_12413 METAL6_338000_6765000 METAL6_336000_6765000 0.004
R_VDD4_12414 METAL6_336000_6765000 METAL6_326000_6765000 0.02
R_VDD4_12415 METAL6_326000_6765000 METAL6_324000_6765000 0.004
R_VDD4_12416 METAL6_324000_6765000 METAL6_314000_6765000 0.02
R_VDD4_12417 METAL6_314000_6765000 METAL6_312000_6765000 0.004
R_VDD4_12418 METAL6_312000_6765000 METAL6_302000_6765000 0.02
R_VDD4_12419 METAL6_302000_6765000 METAL6_300000_6765000 0.004
R_VDD4_12420 METAL6_300000_6765000 METAL6_293000_6765000 0.014
R_VDD4_12421 METAL6_293000_6765000 METAL6_288000_6765000 0.01
R_VDD4_12422 METAL6_288000_6765000 METAL6_281000_6765000 0.014
R_VDD4_12423 METAL6_281000_6765000 METAL5_281000_6765000 0.1
R_VDD4_12424 METAL5_281000_6765000 METAL5_276000_6765000 0.02
R_VDD4_12425 METAL5_276000_6765000 METAL5_269000_6765000 0.028
R_VDD4_12426 METAL5_269000_6765000 METAL5_264000_6765000 0.02
R_VDD4_12427 METAL5_264000_6765000 METAL5_257000_6765000 0.028
R_VDD4_12428 METAL5_257000_6765000 METAL6_257000_6765000 0.1
R_VDD4_12429 METAL6_245000_6765000 METAL6_257000_6765000 0.024
R_VDD4_12430 METAL6_555000_6765000 METAL6_543000_6765000 0.024
R_VDD4_12431 METAL6_450000_8000 METAL6_448000_8000 0.004
R_VDD4_12432 METAL6_448000_8000 METAL6_438000_8000 0.02
R_VDD4_12433 METAL6_438000_8000 METAL6_438000_20000 0.024
R_VDD4_12434 METAL6_438000_20000 METAL6_438000_32000 0.024
R_VDD4_12435 METAL6_438000_32000 METAL6_438000_129000 0.194
R_VDD4_12436 METAL6_438000_129000 METAL6_438000_141000 0.024
R_VDD4_12437 METAL6_438000_141000 METAL6_438000_153000 0.024
R_VDD4_12438 METAL6_438000_153000 METAL6_438000_165000 0.024
R_VDD4_12439 METAL6_438000_165000 METAL6_438000_177000 0.024
R_VDD4_12440 METAL6_438000_177000 METAL6_438000_229000 0.104
R_VDD4_12441 METAL6_438000_229000 METAL6_436000_229000 0.004
R_VDD4_12442 METAL6_436000_229000 METAL6_426000_229000 0.02
R_VDD4_12443 METAL6_426000_229000 METAL6_424000_229000 0.004
R_VDD4_12444 METAL6_424000_229000 METAL6_414000_229000 0.02
R_VDD4_12445 METAL6_414000_229000 METAL6_414000_241000 0.024
R_VDD4_12446 METAL6_414000_241000 METAL6_412000_241000 0.004
R_VDD4_12447 METAL6_412000_241000 METAL6_402000_241000 0.02
R_VDD4_12448 METAL6_402000_241000 METAL6_402000_253000 0.024
R_VDD4_12449 METAL6_402000_253000 METAL6_400000_253000 0.004
R_VDD4_12450 METAL6_400000_253000 METAL6_390000_253000 0.02
R_VDD4_12451 METAL6_390000_253000 METAL6_390000_265000 0.024
R_VDD4_12452 METAL6_390000_265000 METAL6_390000_277000 0.024
R_VDD4_12453 METAL6_390000_277000 METAL6_390000_289000 0.024
R_VDD4_12454 METAL6_390000_289000 METAL6_390000_301000 0.024
R_VDD4_12455 METAL6_390000_301000 METAL6_390000_305000 0.008
R_VDD4_12456 METAL6_390000_305000 METAL6_388000_305000 0.004
R_VDD4_12457 METAL6_388000_305000 METAL6_386000_305000 0.004
R_VDD4_12458 METAL6_386000_305000 METAL6_378000_305000 0.016
R_VDD4_12459 METAL6_378000_305000 METAL6_378000_317000 0.024
R_VDD4_12460 METAL6_378000_317000 METAL6_378000_329000 0.024
R_VDD4_12461 METAL6_378000_329000 METAL5_378000_329000 0.1
R_VDD4_12462 METAL5_378000_329000 METAL5_378000_341000 0.048
R_VDD4_12463 METAL5_378000_341000 METAL5_378000_353000 0.048
R_VDD4_12464 METAL5_378000_353000 METAL5_378000_365000 0.048
R_VDD4_12465 METAL5_378000_365000 METAL6_378000_365000 0.1
R_VDD4_12466 METAL6_378000_365000 METAL6_378000_377000 0.024
R_VDD4_12467 METAL6_378000_377000 METAL6_378000_441000 0.128
R_VDD4_12468 METAL6_378000_441000 METAL6_378000_453000 0.024
R_VDD4_12469 METAL6_378000_453000 METAL6_378000_465000 0.024
R_VDD4_12470 METAL6_378000_465000 METAL6_378000_477000 0.024
R_VDD4_12471 METAL6_378000_477000 METAL6_378000_493000 0.032
R_VDD4_12472 METAL6_378000_493000 METAL6_376000_493000 0.004
R_VDD4_12473 METAL6_376000_493000 METAL6_374000_493000 0.004
R_VDD4_12474 METAL6_374000_493000 METAL6_364000_493000 0.02
R_VDD4_12475 METAL6_364000_493000 METAL6_362000_493000 0.004
R_VDD4_12476 METAL6_362000_493000 METAL6_352000_493000 0.02
R_VDD4_12477 METAL6_352000_493000 METAL6_350000_493000 0.004
R_VDD4_12478 METAL6_350000_493000 METAL6_340000_493000 0.02
R_VDD4_12479 METAL6_340000_493000 METAL6_340000_505000 0.024
R_VDD4_12480 METAL6_340000_505000 METAL6_340000_517000 0.024
R_VDD4_12481 METAL6_340000_517000 METAL6_340000_529000 0.024
R_VDD4_12482 METAL6_340000_529000 METAL6_340000_541000 0.024
R_VDD4_12483 METAL6_340000_541000 METAL6_340000_553000 0.024
R_VDD4_12484 METAL6_340000_553000 METAL6_340000_565000 0.024
R_VDD4_12485 METAL6_340000_565000 METAL6_340000_577000 0.024
R_VDD4_12486 METAL6_340000_577000 METAL6_340000_589000 0.024
R_VDD4_12487 METAL6_340000_589000 METAL6_340000_601000 0.024
R_VDD4_12488 METAL6_340000_601000 METAL6_340000_613000 0.024
R_VDD4_12489 METAL6_340000_613000 METAL6_340000_681000 0.136
R_VDD4_12490 METAL6_340000_681000 METAL6_340000_693000 0.024
R_VDD4_12491 METAL6_340000_693000 METAL6_340000_705000 0.024
R_VDD4_12492 METAL6_340000_705000 METAL6_340000_707000 0.004
R_VDD4_12493 METAL6_340000_707000 METAL6_340000_717000 0.02
R_VDD4_12494 METAL6_340000_717000 METAL6_340000_793000 0.152
R_VDD4_12495 METAL6_340000_793000 METAL6_340000_805000 0.024
R_VDD4_12496 METAL6_340000_805000 METAL6_340000_817000 0.024
R_VDD4_12497 METAL6_340000_817000 METAL6_340000_829000 0.024
R_VDD4_12498 METAL6_340000_829000 METAL6_338000_829000 0.004
R_VDD4_12499 METAL6_338000_829000 METAL6_336000_829000 0.004
R_VDD4_12500 METAL6_336000_829000 METAL5_336000_829000 0.1
R_VDD4_12501 METAL5_336000_829000 METAL5_336000_841000 0.048
R_VDD4_12502 METAL5_336000_841000 METAL5_336000_853000 0.048
R_VDD4_12503 METAL5_336000_853000 METAL5_336000_865000 0.048
R_VDD4_12504 METAL5_336000_865000 METAL5_336000_877000 0.048
R_VDD4_12505 METAL5_336000_877000 METAL5_336000_889000 0.048
R_VDD4_12506 METAL5_336000_889000 METAL5_336000_905000 0.064
R_VDD4_12507 METAL5_336000_905000 METAL5_326000_905000 0.04
R_VDD4_12508 METAL5_326000_905000 METAL5_324000_905000 0.008
R_VDD4_12509 METAL5_324000_905000 METAL5_314000_905000 0.04
R_VDD4_12510 METAL5_314000_905000 METAL5_314000_917000 0.048
R_VDD4_12511 METAL5_314000_917000 METAL5_314000_929000 0.048
R_VDD4_12512 METAL5_314000_929000 METAL5_314000_941000 0.048
R_VDD4_12513 METAL5_314000_941000 METAL5_314000_953000 0.048
R_VDD4_12514 METAL5_314000_953000 METAL5_314000_965000 0.048
R_VDD4_12515 METAL5_314000_965000 METAL5_314000_977000 0.048
R_VDD4_12516 METAL5_314000_977000 METAL5_314000_989000 0.048
R_VDD4_12517 METAL5_314000_989000 METAL5_324000_989000 0.04
R_VDD4_12518 METAL5_324000_989000 METAL5_326000_989000 0.008
R_VDD4_12519 METAL5_326000_989000 METAL5_336000_989000 0.04
R_VDD4_12520 METAL5_336000_989000 METAL5_338000_989000 0.008
R_VDD4_12521 METAL5_338000_989000 METAL5_340000_989000 0.008
R_VDD4_12522 METAL5_340000_989000 METAL5_350000_989000 0.04
R_VDD4_12523 METAL5_350000_989000 METAL5_352000_989000 0.008
R_VDD4_12524 METAL5_352000_989000 METAL5_362000_989000 0.04
R_VDD4_12525 METAL5_362000_989000 METAL5_364000_989000 0.008
R_VDD4_12526 METAL5_364000_989000 METAL5_374000_989000 0.04
R_VDD4_12527 METAL5_374000_989000 METAL5_376000_989000 0.008
R_VDD4_12528 METAL5_376000_989000 METAL5_378000_989000 0.008
R_VDD4_12529 METAL5_378000_989000 METAL5_386000_989000 0.032
R_VDD4_12530 METAL5_386000_989000 METAL6_386000_989000 0.1
R_VDD4_12531 METAL6_386000_989000 METAL6_386000_1041000 0.104
R_VDD4_12532 METAL6_386000_1041000 METAL6_386000_1053000 0.024
R_VDD4_12533 METAL6_386000_1053000 METAL6_386000_1065000 0.024
R_VDD4_12534 METAL6_386000_1065000 METAL6_386000_1077000 0.024
R_VDD4_12535 METAL6_386000_1077000 METAL6_386000_1153000 0.152
R_VDD4_12536 METAL6_386000_1153000 METAL6_386000_1165000 0.024
R_VDD4_12537 METAL6_386000_1165000 METAL6_386000_1177000 0.024
R_VDD4_12538 METAL6_386000_1177000 METAL6_386000_1189000 0.024
R_VDD4_12539 METAL6_386000_1189000 METAL6_386000_1253000 0.128
R_VDD4_12540 METAL6_386000_1253000 METAL6_386000_1265000 0.024
R_VDD4_12541 METAL6_386000_1265000 METAL6_386000_1277000 0.024
R_VDD4_12542 METAL6_386000_1277000 METAL6_386000_1381000 0.208
R_VDD4_12543 METAL6_386000_1381000 METAL6_386000_1393000 0.024
R_VDD4_12544 METAL6_386000_1393000 METAL6_386000_1405000 0.024
R_VDD4_12545 METAL6_386000_1405000 METAL6_386000_1407000 0.004
R_VDD4_12546 METAL6_386000_1407000 METAL6_386000_1553000 0.292
R_VDD4_12547 METAL6_386000_1553000 METAL6_386000_1565000 0.024
R_VDD4_12548 METAL6_386000_1565000 METAL6_386000_1577000 0.024
R_VDD4_12549 METAL6_386000_1577000 METAL6_386000_1653000 0.152
R_VDD4_12550 METAL6_386000_1653000 METAL6_386000_1665000 0.024
R_VDD4_12551 METAL6_386000_1665000 METAL6_386000_1677000 0.024
R_VDD4_12552 METAL6_386000_1677000 METAL6_386000_1753000 0.152
R_VDD4_12553 METAL6_386000_1753000 METAL6_386000_1765000 0.024
R_VDD4_12554 METAL6_386000_1765000 METAL6_386000_1777000 0.024
R_VDD4_12555 METAL6_386000_1777000 METAL6_386000_1841000 0.128
R_VDD4_12556 METAL6_386000_1841000 METAL6_386000_1853000 0.024
R_VDD4_12557 METAL6_386000_1853000 METAL6_386000_1865000 0.024
R_VDD4_12558 METAL6_386000_1865000 METAL6_386000_1877000 0.024
R_VDD4_12559 METAL6_386000_1877000 METAL6_386000_1929000 0.104
R_VDD4_12560 METAL6_386000_1929000 METAL6_386000_1941000 0.024
R_VDD4_12561 METAL6_386000_1941000 METAL6_386000_1953000 0.024
R_VDD4_12562 METAL6_386000_1953000 METAL6_386000_1965000 0.024
R_VDD4_12563 METAL6_386000_1965000 METAL6_386000_1977000 0.024
R_VDD4_12564 METAL6_386000_1977000 METAL6_386000_2093000 0.232
R_VDD4_12565 METAL6_386000_2093000 METAL6_386000_2107000 0.028
R_VDD4_12566 METAL6_386000_2107000 METAL6_386000_2241000 0.268
R_VDD4_12567 METAL6_386000_2241000 METAL6_386000_2253000 0.024
R_VDD4_12568 METAL6_386000_2253000 METAL6_386000_2265000 0.024
R_VDD4_12569 METAL6_386000_2265000 METAL6_386000_2277000 0.024
R_VDD4_12570 METAL6_386000_2277000 METAL6_386000_2353000 0.152
R_VDD4_12571 METAL6_386000_2353000 METAL6_386000_2365000 0.024
R_VDD4_12572 METAL6_386000_2365000 METAL6_386000_2377000 0.024
R_VDD4_12573 METAL6_386000_2377000 METAL6_386000_2453000 0.152
R_VDD4_12574 METAL6_386000_2453000 METAL6_386000_2465000 0.024
R_VDD4_12575 METAL6_386000_2465000 METAL6_386000_2477000 0.024
R_VDD4_12576 METAL6_386000_2477000 METAL6_386000_2553000 0.152
R_VDD4_12577 METAL6_386000_2553000 METAL6_386000_2565000 0.024
R_VDD4_12578 METAL6_386000_2565000 METAL6_386000_2577000 0.024
R_VDD4_12579 METAL6_386000_2577000 METAL6_386000_2629000 0.104
R_VDD4_12580 METAL6_386000_2629000 METAL6_386000_2641000 0.024
R_VDD4_12581 METAL6_386000_2641000 METAL6_386000_2653000 0.024
R_VDD4_12582 METAL6_386000_2653000 METAL6_386000_2665000 0.024
R_VDD4_12583 METAL6_386000_2665000 METAL6_386000_2677000 0.024
R_VDD4_12584 METAL6_386000_2677000 METAL6_386000_2793000 0.232
R_VDD4_12585 METAL6_386000_2793000 METAL6_386000_2807000 0.028
R_VDD4_12586 METAL6_386000_2807000 METAL6_386000_2953000 0.292
R_VDD4_12587 METAL6_386000_2953000 METAL6_386000_2965000 0.024
R_VDD4_12588 METAL6_386000_2965000 METAL6_386000_2977000 0.024
R_VDD4_12589 METAL6_386000_2977000 METAL6_386000_3053000 0.152
R_VDD4_12590 METAL6_386000_3053000 METAL6_386000_3065000 0.024
R_VDD4_12591 METAL6_386000_3065000 METAL6_386000_3077000 0.024
R_VDD4_12592 METAL6_386000_3077000 METAL6_386000_3153000 0.152
R_VDD4_12593 METAL6_386000_3153000 METAL6_386000_3165000 0.024
R_VDD4_12594 METAL6_386000_3165000 METAL6_386000_3177000 0.024
R_VDD4_12595 METAL6_386000_3177000 METAL6_386000_3253000 0.152
R_VDD4_12596 METAL6_386000_3253000 METAL6_386000_3265000 0.024
R_VDD4_12597 METAL6_386000_3265000 METAL6_386000_3277000 0.024
R_VDD4_12598 METAL6_386000_3277000 METAL6_386000_3341000 0.128
R_VDD4_12599 METAL6_386000_3341000 METAL6_386000_3353000 0.024
R_VDD4_12600 METAL6_386000_3353000 METAL6_386000_3365000 0.024
R_VDD4_12601 METAL6_386000_3365000 METAL6_386000_3377000 0.024
R_VDD4_12602 METAL6_386000_3377000 METAL6_386000_3493000 0.232
R_VDD4_12603 METAL6_386000_3493000 METAL6_386000_3507000 0.028
R_VDD4_12604 METAL6_386000_3507000 METAL6_386000_3653000 0.292
R_VDD4_12605 METAL6_386000_3653000 METAL6_386000_3665000 0.024
R_VDD4_12606 METAL6_386000_3665000 METAL6_386000_3677000 0.024
R_VDD4_12607 METAL6_386000_3677000 METAL6_386000_3753000 0.152
R_VDD4_12608 METAL6_386000_3753000 METAL6_386000_3765000 0.024
R_VDD4_12609 METAL6_386000_3765000 METAL6_386000_3777000 0.024
R_VDD4_12610 METAL6_386000_3777000 METAL6_386000_3853000 0.152
R_VDD4_12611 METAL6_386000_3853000 METAL6_386000_3865000 0.024
R_VDD4_12612 METAL6_386000_3865000 METAL6_386000_3877000 0.024
R_VDD4_12613 METAL6_386000_3877000 METAL6_386000_3953000 0.152
R_VDD4_12614 METAL6_386000_3953000 METAL6_386000_3965000 0.024
R_VDD4_12615 METAL6_386000_3965000 METAL6_386000_3977000 0.024
R_VDD4_12616 METAL6_386000_3977000 METAL6_386000_4053000 0.152
R_VDD4_12617 METAL6_386000_4053000 METAL6_386000_4065000 0.024
R_VDD4_12618 METAL6_386000_4065000 METAL6_386000_4077000 0.024
R_VDD4_12619 METAL6_386000_4077000 METAL6_386000_4193000 0.232
R_VDD4_12620 METAL6_386000_4193000 METAL6_386000_4207000 0.028
R_VDD4_12621 METAL6_386000_4207000 METAL6_386000_4353000 0.292
R_VDD4_12622 METAL6_386000_4353000 METAL6_386000_4365000 0.024
R_VDD4_12623 METAL6_386000_4365000 METAL6_386000_4377000 0.024
R_VDD4_12624 METAL6_386000_4377000 METAL6_386000_4453000 0.152
R_VDD4_12625 METAL6_386000_4453000 METAL6_386000_4465000 0.024
R_VDD4_12626 METAL6_386000_4465000 METAL6_386000_4477000 0.024
R_VDD4_12627 METAL6_386000_4477000 METAL6_386000_4553000 0.152
R_VDD4_12628 METAL6_386000_4553000 METAL6_386000_4565000 0.024
R_VDD4_12629 METAL6_386000_4565000 METAL6_386000_4577000 0.024
R_VDD4_12630 METAL6_386000_4577000 METAL6_386000_4653000 0.152
R_VDD4_12631 METAL6_386000_4653000 METAL6_386000_4665000 0.024
R_VDD4_12632 METAL6_386000_4665000 METAL6_386000_4677000 0.024
R_VDD4_12633 METAL6_386000_4677000 METAL6_386000_4729000 0.104
R_VDD4_12634 METAL6_386000_4729000 METAL6_386000_4741000 0.024
R_VDD4_12635 METAL6_386000_4741000 METAL6_386000_4753000 0.024
R_VDD4_12636 METAL6_386000_4753000 METAL6_386000_4765000 0.024
R_VDD4_12637 METAL6_386000_4765000 METAL6_386000_4777000 0.024
R_VDD4_12638 METAL6_386000_4777000 METAL6_386000_4893000 0.232
R_VDD4_12639 METAL6_386000_4893000 METAL6_386000_4907000 0.028
R_VDD4_12640 METAL6_386000_4907000 METAL6_386000_5053000 0.292
R_VDD4_12641 METAL6_386000_5053000 METAL6_386000_5065000 0.024
R_VDD4_12642 METAL6_386000_5065000 METAL6_386000_5077000 0.024
R_VDD4_12643 METAL6_386000_5077000 METAL6_386000_5153000 0.152
R_VDD4_12644 METAL6_386000_5153000 METAL6_386000_5165000 0.024
R_VDD4_12645 METAL6_386000_5165000 METAL6_386000_5177000 0.024
R_VDD4_12646 METAL6_386000_5177000 METAL6_386000_5253000 0.152
R_VDD4_12647 METAL6_386000_5253000 METAL6_386000_5265000 0.024
R_VDD4_12648 METAL6_386000_5265000 METAL6_386000_5277000 0.024
R_VDD4_12649 METAL6_386000_5277000 METAL6_386000_5353000 0.152
R_VDD4_12650 METAL6_386000_5353000 METAL6_386000_5365000 0.024
R_VDD4_12651 METAL6_386000_5365000 METAL6_386000_5377000 0.024
R_VDD4_12652 METAL6_386000_5377000 METAL6_386000_5441000 0.128
R_VDD4_12653 METAL6_386000_5441000 METAL6_386000_5453000 0.024
R_VDD4_12654 METAL6_386000_5453000 METAL5_386000_5453000 0.1
R_VDD4_12655 METAL5_386000_5453000 METAL5_386000_5465000 0.048
R_VDD4_12656 METAL5_386000_5465000 METAL5_386000_5477000 0.048
R_VDD4_12657 METAL5_386000_5477000 METAL6_386000_5477000 0.1
R_VDD4_12658 METAL6_386000_5477000 METAL6_386000_5489000 0.024
R_VDD4_12659 METAL6_386000_5489000 METAL6_386000_5593000 0.208
R_VDD4_12660 METAL6_386000_5593000 METAL6_386000_5607000 0.028
R_VDD4_12661 METAL6_386000_5607000 METAL6_386000_5753000 0.292
R_VDD4_12662 METAL6_386000_5753000 METAL6_386000_5765000 0.024
R_VDD4_12663 METAL6_386000_5765000 METAL6_386000_5777000 0.024
R_VDD4_12664 METAL6_386000_5777000 METAL6_386000_5853000 0.152
R_VDD4_12665 METAL6_386000_5853000 METAL6_386000_5865000 0.024
R_VDD4_12666 METAL6_386000_5865000 METAL6_386000_5877000 0.024
R_VDD4_12667 METAL6_386000_5877000 METAL6_386000_5953000 0.152
R_VDD4_12668 METAL6_386000_5953000 METAL6_386000_5965000 0.024
R_VDD4_12669 METAL6_386000_5965000 METAL6_386000_5977000 0.024
R_VDD4_12670 METAL6_386000_5977000 METAL6_386000_6053000 0.152
R_VDD4_12671 METAL6_386000_6053000 METAL6_386000_6065000 0.024
R_VDD4_12672 METAL6_386000_6065000 METAL6_386000_6077000 0.024
R_VDD4_12673 METAL6_386000_6077000 METAL6_386000_6153000 0.152
R_VDD4_12674 METAL6_386000_6153000 METAL6_386000_6165000 0.024
R_VDD4_12675 METAL6_386000_6165000 METAL6_386000_6177000 0.024
R_VDD4_12676 METAL6_386000_6177000 METAL6_386000_6293000 0.232
R_VDD4_12677 METAL6_386000_6293000 METAL6_386000_6307000 0.028
R_VDD4_12678 METAL6_386000_6307000 METAL6_386000_6453000 0.292
R_VDD4_12679 METAL6_386000_6453000 METAL6_386000_6465000 0.024
R_VDD4_12680 METAL6_386000_6465000 METAL6_386000_6477000 0.024
R_VDD4_12681 METAL6_386000_6477000 METAL6_386000_6553000 0.152
R_VDD4_12682 METAL6_386000_6553000 METAL6_386000_6565000 0.024
R_VDD4_12683 METAL6_386000_6565000 METAL6_386000_6577000 0.024
R_VDD4_12684 METAL6_386000_6577000 METAL6_386000_6653000 0.152
R_VDD4_12685 METAL6_386000_6653000 METAL6_386000_6665000 0.024
R_VDD4_12686 METAL6_386000_6665000 METAL6_386000_6677000 0.024
R_VDD4_12687 METAL6_386000_6677000 METAL6_386000_6753000 0.152
R_VDD4_12688 METAL6_386000_6753000 METAL6_386000_6765000 0.024
R_VDD4_12689 METAL6_386000_6765000 METAL6_388000_6765000 0.004
R_VDD4_12690 METAL6_388000_6765000 METAL6_390000_6765000 0.004
R_VDD4_12691 METAL6_390000_6765000 METAL6_400000_6765000 0.02
R_VDD4_12692 METAL6_400000_6765000 METAL6_402000_6765000 0.004
R_VDD4_12693 METAL6_402000_6765000 METAL6_412000_6765000 0.02
R_VDD4_12694 METAL6_412000_6765000 METAL6_414000_6765000 0.004
R_VDD4_12695 METAL6_414000_6765000 METAL6_424000_6765000 0.02
R_VDD4_12696 METAL6_424000_6765000 METAL6_426000_6765000 0.004
R_VDD4_12697 METAL6_426000_6765000 METAL6_436000_6765000 0.02
R_VDD4_12698 METAL6_436000_6765000 METAL6_438000_6765000 0.004
R_VDD4_12699 METAL6_438000_6765000 METAL6_448000_6765000 0.02
R_VDD4_12700 METAL6_448000_6765000 METAL6_450000_6765000 0.004
R_VDD4_12701 METAL6_450000_6765000 METAL6_452000_6765000 0.004
R_VDD4_12702 METAL6_452000_6765000 METAL6_460000_6765000 0.016
R_VDD4_12703 METAL6_460000_6765000 METAL6_462000_6765000 0.004
R_VDD4_12704 METAL6_462000_6765000 METAL6_464000_6765000 0.004
R_VDD4_12705 METAL6_464000_6765000 METAL6_472000_6765000 0.016
R_VDD4_12706 METAL6_472000_6765000 METAL6_474000_6765000 0.004
R_VDD4_12707 METAL6_474000_6765000 METAL6_476000_6765000 0.004
R_VDD4_12708 METAL6_476000_6765000 METAL6_484000_6765000 0.016
R_VDD4_12709 METAL6_484000_6765000 METAL6_486000_6765000 0.004
R_VDD4_12710 METAL6_486000_6765000 METAL6_488000_6765000 0.004
R_VDD4_12711 METAL6_488000_6765000 METAL6_500000_6765000 0.024
R_VDD4_12712 METAL6_500000_6765000 METAL6_507000_6765000 0.014
R_VDD4_12713 METAL6_507000_6765000 METAL6_512000_6765000 0.01
R_VDD4_12714 METAL6_512000_6765000 METAL6_519000_6765000 0.014
R_VDD4_12715 METAL6_519000_6765000 METAL5_519000_6765000 0.1
R_VDD4_12716 METAL5_519000_6765000 METAL5_524000_6765000 0.02
R_VDD4_12717 METAL5_524000_6765000 METAL5_531000_6765000 0.028
R_VDD4_12718 METAL5_531000_6765000 METAL5_543000_6765000 0.048
R_VDD4_12719 METAL5_543000_6765000 METAL6_543000_6765000 0.1
R_VDD4_12720 METAL6_245000_6065000 METAL6_257000_6065000 0.024
R_VDD4_12721 METAL6_450000_8000 METAL5_450000_8000 0.1
R_VDD4_12722 METAL5_450000_8000 METAL5_448000_8000 0.008
R_VDD4_12723 METAL5_448000_8000 METAL5_438000_8000 0.04
R_VDD4_12724 METAL5_438000_8000 METAL5_436000_8000 0.008
R_VDD4_12725 METAL5_436000_8000 METAL5_426000_8000 0.04
R_VDD4_12726 METAL5_426000_8000 METAL6_426000_8000 0.1
R_VDD4_12727 METAL6_426000_8000 METAL6_426000_20000 0.024
R_VDD4_12728 METAL6_426000_20000 METAL6_426000_32000 0.024
R_VDD4_12729 METAL6_426000_32000 METAL6_426000_129000 0.194
R_VDD4_12730 METAL6_426000_129000 METAL6_426000_141000 0.024
R_VDD4_12731 METAL6_426000_141000 METAL6_426000_153000 0.024
R_VDD4_12732 METAL6_426000_153000 METAL6_426000_165000 0.024
R_VDD4_12733 METAL6_426000_165000 METAL6_426000_177000 0.024
R_VDD4_12734 METAL6_426000_177000 METAL6_426000_217000 0.08
R_VDD4_12735 METAL6_426000_217000 METAL6_424000_217000 0.004
R_VDD4_12736 METAL6_424000_217000 METAL6_414000_217000 0.02
R_VDD4_12737 METAL6_414000_217000 METAL6_412000_217000 0.004
R_VDD4_12738 METAL6_412000_217000 METAL6_402000_217000 0.02
R_VDD4_12739 METAL6_402000_217000 METAL6_402000_229000 0.024
R_VDD4_12740 METAL6_402000_229000 METAL6_400000_229000 0.004
R_VDD4_12741 METAL6_400000_229000 METAL6_398000_229000 0.004
R_VDD4_12742 METAL6_398000_229000 METAL6_390000_229000 0.016
R_VDD4_12743 METAL6_390000_229000 METAL6_390000_241000 0.024
R_VDD4_12744 METAL6_390000_241000 METAL6_388000_241000 0.004
R_VDD4_12745 METAL6_388000_241000 METAL6_386000_241000 0.004
R_VDD4_12746 METAL6_386000_241000 METAL6_378000_241000 0.016
R_VDD4_12747 METAL6_378000_241000 METAL6_378000_253000 0.024
R_VDD4_12748 METAL6_378000_253000 METAL6_378000_265000 0.024
R_VDD4_12749 METAL6_378000_265000 METAL6_378000_277000 0.024
R_VDD4_12750 METAL6_378000_277000 METAL6_378000_289000 0.024
R_VDD4_12751 METAL6_378000_289000 METAL6_378000_293000 0.008
R_VDD4_12752 METAL6_378000_293000 METAL6_376000_293000 0.004
R_VDD4_12753 METAL6_376000_293000 METAL6_374000_293000 0.004
R_VDD4_12754 METAL6_374000_293000 METAL6_366000_293000 0.016
R_VDD4_12755 METAL6_366000_293000 METAL6_366000_301000 0.016
R_VDD4_12756 METAL6_366000_301000 METAL6_366000_305000 0.008
R_VDD4_12757 METAL6_366000_305000 METAL6_366000_317000 0.024
R_VDD4_12758 METAL6_366000_317000 METAL6_366000_329000 0.024
R_VDD4_12759 METAL6_366000_329000 METAL6_364000_329000 0.004
R_VDD4_12760 METAL6_364000_329000 METAL6_362000_329000 0.004
R_VDD4_12761 METAL6_362000_329000 METAL6_352000_329000 0.02
R_VDD4_12762 METAL6_352000_329000 METAL6_350000_329000 0.004
R_VDD4_12763 METAL6_350000_329000 METAL6_348000_329000 0.004
R_VDD4_12764 METAL6_348000_329000 METAL6_340000_329000 0.016
R_VDD4_12765 METAL6_340000_329000 METAL6_338000_329000 0.004
R_VDD4_12766 METAL6_338000_329000 METAL6_338000_341000 0.024
R_VDD4_12767 METAL6_338000_341000 METAL6_336000_341000 0.004
R_VDD4_12768 METAL6_336000_341000 METAL6_328000_341000 0.016
R_VDD4_12769 METAL6_328000_341000 METAL6_326000_341000 0.004
R_VDD4_12770 METAL6_326000_341000 METAL6_324000_341000 0.004
R_VDD4_12771 METAL6_324000_341000 METAL6_314000_341000 0.02
R_VDD4_12772 METAL6_314000_341000 METAL6_312000_341000 0.004
R_VDD4_12773 METAL6_312000_341000 METAL6_302000_341000 0.02
R_VDD4_12774 METAL6_302000_341000 METAL6_300000_341000 0.004
R_VDD4_12775 METAL6_300000_341000 METAL6_293000_341000 0.014
R_VDD4_12776 METAL6_293000_341000 METAL6_288000_341000 0.01
R_VDD4_12777 METAL6_288000_341000 METAL6_288000_353000 0.024
R_VDD4_12778 METAL6_288000_353000 METAL6_288000_365000 0.024
R_VDD4_12779 METAL6_288000_365000 METAL6_288000_377000 0.024
R_VDD4_12780 METAL6_288000_377000 METAL6_288000_441000 0.128
R_VDD4_12781 METAL6_288000_441000 METAL6_288000_453000 0.024
R_VDD4_12782 METAL6_288000_453000 METAL6_281000_453000 0.014
R_VDD4_12783 METAL6_281000_453000 METAL6_276000_453000 0.01
R_VDD4_12784 METAL6_276000_453000 METAL6_276000_465000 0.024
R_VDD4_12785 METAL6_276000_465000 METAL6_276000_477000 0.024
R_VDD4_12786 METAL6_276000_477000 METAL6_269000_477000 0.014
R_VDD4_12787 METAL6_269000_477000 METAL6_264000_477000 0.01
R_VDD4_12788 METAL6_264000_477000 METAL6_264000_481000 0.008
R_VDD4_12789 METAL6_264000_481000 METAL6_264000_493000 0.024
R_VDD4_12790 METAL6_264000_493000 METAL6_264000_505000 0.024
R_VDD4_12791 METAL6_264000_505000 METAL6_264000_517000 0.024
R_VDD4_12792 METAL6_264000_517000 METAL6_264000_529000 0.024
R_VDD4_12793 METAL6_264000_529000 METAL6_264000_541000 0.024
R_VDD4_12794 METAL6_264000_541000 METAL6_264000_553000 0.024
R_VDD4_12795 METAL6_264000_553000 METAL5_264000_553000 0.1
R_VDD4_12796 METAL5_264000_553000 METAL5_269000_553000 0.02
R_VDD4_12797 METAL5_269000_553000 METAL5_269000_565000 0.048
R_VDD4_12798 METAL5_269000_565000 METAL5_269000_577000 0.048
R_VDD4_12799 METAL5_269000_577000 METAL6_269000_577000 0.1
R_VDD4_12800 METAL6_269000_577000 METAL6_264000_577000 0.01
R_VDD4_12801 METAL6_264000_577000 METAL6_264000_589000 0.024
R_VDD4_12802 METAL6_264000_589000 METAL6_264000_601000 0.024
R_VDD4_12803 METAL6_264000_601000 METAL6_264000_613000 0.024
R_VDD4_12804 METAL6_264000_613000 METAL6_264000_681000 0.136
R_VDD4_12805 METAL6_264000_681000 METAL6_264000_693000 0.024
R_VDD4_12806 METAL6_264000_693000 METAL6_257000_693000 0.014
R_VDD4_12807 METAL6_257000_693000 METAL6_257000_705000 0.024
R_VDD4_12808 METAL6_257000_705000 METAL6_257000_707000 0.004
R_VDD4_12809 METAL6_257000_707000 METAL6_257000_717000 0.02
R_VDD4_12810 METAL6_257000_717000 METAL6_257000_793000 0.152
R_VDD4_12811 METAL6_257000_793000 METAL6_257000_805000 0.024
R_VDD4_12812 METAL6_257000_805000 METAL6_257000_817000 0.024
R_VDD4_12813 METAL6_257000_817000 METAL6_257000_829000 0.024
R_VDD4_12814 METAL6_257000_829000 METAL6_257000_841000 0.024
R_VDD4_12815 METAL6_257000_841000 METAL6_257000_853000 0.024
R_VDD4_12816 METAL6_257000_853000 METAL5_257000_853000 0.1
R_VDD4_12817 METAL5_257000_853000 METAL5_264000_853000 0.028
R_VDD4_12818 METAL5_264000_853000 METAL5_269000_853000 0.02
R_VDD4_12819 METAL5_269000_853000 METAL5_269000_865000 0.048
R_VDD4_12820 METAL5_269000_865000 METAL5_269000_877000 0.048
R_VDD4_12821 METAL5_269000_877000 METAL5_269000_889000 0.048
R_VDD4_12822 METAL5_269000_889000 METAL5_276000_889000 0.028
R_VDD4_12823 METAL5_276000_889000 METAL5_281000_889000 0.02
R_VDD4_12824 METAL5_281000_889000 METAL5_288000_889000 0.028
R_VDD4_12825 METAL5_288000_889000 METAL5_293000_889000 0.02
R_VDD4_12826 METAL5_293000_889000 METAL5_300000_889000 0.028
R_VDD4_12827 METAL5_300000_889000 METAL5_300000_893000 0.016
R_VDD4_12828 METAL5_300000_893000 METAL5_300000_905000 0.048
R_VDD4_12829 METAL5_300000_905000 METAL5_300000_917000 0.048
R_VDD4_12830 METAL5_300000_917000 METAL5_300000_929000 0.048
R_VDD4_12831 METAL5_300000_929000 METAL5_300000_941000 0.048
R_VDD4_12832 METAL5_300000_941000 METAL5_300000_953000 0.048
R_VDD4_12833 METAL5_300000_953000 METAL5_300000_965000 0.048
R_VDD4_12834 METAL5_300000_965000 METAL5_300000_977000 0.048
R_VDD4_12835 METAL5_300000_977000 METAL5_300000_989000 0.048
R_VDD4_12836 METAL5_300000_989000 METAL5_300000_1001000 0.048
R_VDD4_12837 METAL5_300000_1001000 METAL5_302000_1001000 0.008
R_VDD4_12838 METAL5_302000_1001000 METAL5_312000_1001000 0.04
R_VDD4_12839 METAL5_312000_1001000 METAL5_314000_1001000 0.008
R_VDD4_12840 METAL5_314000_1001000 METAL5_324000_1001000 0.04
R_VDD4_12841 METAL5_324000_1001000 METAL5_326000_1001000 0.008
R_VDD4_12842 METAL5_326000_1001000 METAL5_328000_1001000 0.008
R_VDD4_12843 METAL5_328000_1001000 METAL5_336000_1001000 0.032
R_VDD4_12844 METAL5_336000_1001000 METAL5_338000_1001000 0.008
R_VDD4_12845 METAL5_338000_1001000 METAL5_340000_1001000 0.008
R_VDD4_12846 METAL5_340000_1001000 METAL5_348000_1001000 0.032
R_VDD4_12847 METAL5_348000_1001000 METAL5_350000_1001000 0.008
R_VDD4_12848 METAL5_350000_1001000 METAL5_352000_1001000 0.008
R_VDD4_12849 METAL5_352000_1001000 METAL5_362000_1001000 0.04
R_VDD4_12850 METAL5_362000_1001000 METAL5_364000_1001000 0.008
R_VDD4_12851 METAL5_364000_1001000 METAL5_366000_1001000 0.008
R_VDD4_12852 METAL5_366000_1001000 METAL5_374000_1001000 0.032
R_VDD4_12853 METAL5_374000_1001000 METAL5_376000_1001000 0.008
R_VDD4_12854 METAL5_376000_1001000 METAL5_378000_1001000 0.008
R_VDD4_12855 METAL5_378000_1001000 METAL5_386000_1001000 0.032
R_VDD4_12856 METAL5_386000_1001000 METAL5_388000_1001000 0.008
R_VDD4_12857 METAL5_388000_1001000 METAL5_390000_1001000 0.008
R_VDD4_12858 METAL5_390000_1001000 METAL5_398000_1001000 0.032
R_VDD4_12859 METAL5_398000_1001000 METAL6_398000_1001000 0.1
R_VDD4_12860 METAL6_398000_1001000 METAL6_398000_1041000 0.08
R_VDD4_12861 METAL6_398000_1041000 METAL6_398000_1053000 0.024
R_VDD4_12862 METAL6_398000_1053000 METAL6_398000_1065000 0.024
R_VDD4_12863 METAL6_398000_1065000 METAL6_398000_1077000 0.024
R_VDD4_12864 METAL6_398000_1077000 METAL6_398000_1153000 0.152
R_VDD4_12865 METAL6_398000_1153000 METAL6_398000_1165000 0.024
R_VDD4_12866 METAL6_398000_1165000 METAL6_398000_1177000 0.024
R_VDD4_12867 METAL6_398000_1177000 METAL6_398000_1189000 0.024
R_VDD4_12868 METAL6_398000_1189000 METAL6_398000_1253000 0.128
R_VDD4_12869 METAL6_398000_1253000 METAL6_398000_1265000 0.024
R_VDD4_12870 METAL6_398000_1265000 METAL6_398000_1277000 0.024
R_VDD4_12871 METAL6_398000_1277000 METAL6_398000_1381000 0.208
R_VDD4_12872 METAL6_398000_1381000 METAL6_398000_1393000 0.024
R_VDD4_12873 METAL6_398000_1393000 METAL6_398000_1405000 0.024
R_VDD4_12874 METAL6_398000_1405000 METAL6_398000_1407000 0.004
R_VDD4_12875 METAL6_398000_1407000 METAL6_398000_1553000 0.292
R_VDD4_12876 METAL6_398000_1553000 METAL6_398000_1565000 0.024
R_VDD4_12877 METAL6_398000_1565000 METAL6_398000_1577000 0.024
R_VDD4_12878 METAL6_398000_1577000 METAL6_398000_1653000 0.152
R_VDD4_12879 METAL6_398000_1653000 METAL6_398000_1665000 0.024
R_VDD4_12880 METAL6_398000_1665000 METAL6_398000_1677000 0.024
R_VDD4_12881 METAL6_398000_1677000 METAL6_398000_1753000 0.152
R_VDD4_12882 METAL6_398000_1753000 METAL6_398000_1765000 0.024
R_VDD4_12883 METAL6_398000_1765000 METAL6_398000_1777000 0.024
R_VDD4_12884 METAL6_398000_1777000 METAL6_398000_1841000 0.128
R_VDD4_12885 METAL6_398000_1841000 METAL6_398000_1853000 0.024
R_VDD4_12886 METAL6_398000_1853000 METAL6_398000_1865000 0.024
R_VDD4_12887 METAL6_398000_1865000 METAL6_398000_1877000 0.024
R_VDD4_12888 METAL6_398000_1877000 METAL6_398000_1929000 0.104
R_VDD4_12889 METAL6_398000_1929000 METAL6_398000_1941000 0.024
R_VDD4_12890 METAL6_398000_1941000 METAL6_398000_1953000 0.024
R_VDD4_12891 METAL6_398000_1953000 METAL6_398000_1965000 0.024
R_VDD4_12892 METAL6_398000_1965000 METAL6_398000_1977000 0.024
R_VDD4_12893 METAL6_398000_1977000 METAL6_398000_2093000 0.232
R_VDD4_12894 METAL6_398000_2093000 METAL6_398000_2107000 0.028
R_VDD4_12895 METAL6_398000_2107000 METAL6_398000_2241000 0.268
R_VDD4_12896 METAL6_398000_2241000 METAL6_398000_2253000 0.024
R_VDD4_12897 METAL6_398000_2253000 METAL6_398000_2265000 0.024
R_VDD4_12898 METAL6_398000_2265000 METAL6_398000_2277000 0.024
R_VDD4_12899 METAL6_398000_2277000 METAL6_398000_2353000 0.152
R_VDD4_12900 METAL6_398000_2353000 METAL6_398000_2365000 0.024
R_VDD4_12901 METAL6_398000_2365000 METAL6_398000_2377000 0.024
R_VDD4_12902 METAL6_398000_2377000 METAL6_398000_2453000 0.152
R_VDD4_12903 METAL6_398000_2453000 METAL6_398000_2465000 0.024
R_VDD4_12904 METAL6_398000_2465000 METAL6_398000_2477000 0.024
R_VDD4_12905 METAL6_398000_2477000 METAL6_398000_2553000 0.152
R_VDD4_12906 METAL6_398000_2553000 METAL6_398000_2565000 0.024
R_VDD4_12907 METAL6_398000_2565000 METAL6_398000_2577000 0.024
R_VDD4_12908 METAL6_398000_2577000 METAL6_398000_2629000 0.104
R_VDD4_12909 METAL6_398000_2629000 METAL6_398000_2641000 0.024
R_VDD4_12910 METAL6_398000_2641000 METAL6_398000_2653000 0.024
R_VDD4_12911 METAL6_398000_2653000 METAL6_398000_2665000 0.024
R_VDD4_12912 METAL6_398000_2665000 METAL6_398000_2677000 0.024
R_VDD4_12913 METAL6_398000_2677000 METAL6_398000_2793000 0.232
R_VDD4_12914 METAL6_398000_2793000 METAL6_398000_2807000 0.028
R_VDD4_12915 METAL6_398000_2807000 METAL6_398000_2953000 0.292
R_VDD4_12916 METAL6_398000_2953000 METAL6_398000_2965000 0.024
R_VDD4_12917 METAL6_398000_2965000 METAL6_398000_2977000 0.024
R_VDD4_12918 METAL6_398000_2977000 METAL6_398000_3053000 0.152
R_VDD4_12919 METAL6_398000_3053000 METAL6_398000_3065000 0.024
R_VDD4_12920 METAL6_398000_3065000 METAL6_398000_3077000 0.024
R_VDD4_12921 METAL6_398000_3077000 METAL6_398000_3153000 0.152
R_VDD4_12922 METAL6_398000_3153000 METAL6_398000_3165000 0.024
R_VDD4_12923 METAL6_398000_3165000 METAL6_398000_3177000 0.024
R_VDD4_12924 METAL6_398000_3177000 METAL6_398000_3253000 0.152
R_VDD4_12925 METAL6_398000_3253000 METAL6_398000_3265000 0.024
R_VDD4_12926 METAL6_398000_3265000 METAL6_398000_3277000 0.024
R_VDD4_12927 METAL6_398000_3277000 METAL6_398000_3341000 0.128
R_VDD4_12928 METAL6_398000_3341000 METAL6_398000_3353000 0.024
R_VDD4_12929 METAL6_398000_3353000 METAL6_398000_3365000 0.024
R_VDD4_12930 METAL6_398000_3365000 METAL6_398000_3377000 0.024
R_VDD4_12931 METAL6_398000_3377000 METAL6_398000_3493000 0.232
R_VDD4_12932 METAL6_398000_3493000 METAL6_398000_3507000 0.028
R_VDD4_12933 METAL6_398000_3507000 METAL6_398000_3653000 0.292
R_VDD4_12934 METAL6_398000_3653000 METAL6_398000_3665000 0.024
R_VDD4_12935 METAL6_398000_3665000 METAL6_398000_3677000 0.024
R_VDD4_12936 METAL6_398000_3677000 METAL6_398000_3753000 0.152
R_VDD4_12937 METAL6_398000_3753000 METAL6_398000_3765000 0.024
R_VDD4_12938 METAL6_398000_3765000 METAL6_398000_3777000 0.024
R_VDD4_12939 METAL6_398000_3777000 METAL6_398000_3853000 0.152
R_VDD4_12940 METAL6_398000_3853000 METAL6_398000_3865000 0.024
R_VDD4_12941 METAL6_398000_3865000 METAL6_398000_3877000 0.024
R_VDD4_12942 METAL6_398000_3877000 METAL6_398000_3953000 0.152
R_VDD4_12943 METAL6_398000_3953000 METAL6_398000_3965000 0.024
R_VDD4_12944 METAL6_398000_3965000 METAL6_398000_3977000 0.024
R_VDD4_12945 METAL6_398000_3977000 METAL6_398000_4053000 0.152
R_VDD4_12946 METAL6_398000_4053000 METAL6_398000_4065000 0.024
R_VDD4_12947 METAL6_398000_4065000 METAL6_398000_4077000 0.024
R_VDD4_12948 METAL6_398000_4077000 METAL6_398000_4193000 0.232
R_VDD4_12949 METAL6_398000_4193000 METAL6_398000_4207000 0.028
R_VDD4_12950 METAL6_398000_4207000 METAL6_398000_4353000 0.292
R_VDD4_12951 METAL6_398000_4353000 METAL6_398000_4365000 0.024
R_VDD4_12952 METAL6_398000_4365000 METAL6_398000_4377000 0.024
R_VDD4_12953 METAL6_398000_4377000 METAL6_398000_4453000 0.152
R_VDD4_12954 METAL6_398000_4453000 METAL6_398000_4465000 0.024
R_VDD4_12955 METAL6_398000_4465000 METAL6_398000_4477000 0.024
R_VDD4_12956 METAL6_398000_4477000 METAL6_398000_4553000 0.152
R_VDD4_12957 METAL6_398000_4553000 METAL6_398000_4565000 0.024
R_VDD4_12958 METAL6_398000_4565000 METAL6_398000_4577000 0.024
R_VDD4_12959 METAL6_398000_4577000 METAL6_398000_4653000 0.152
R_VDD4_12960 METAL6_398000_4653000 METAL6_398000_4665000 0.024
R_VDD4_12961 METAL6_398000_4665000 METAL6_398000_4677000 0.024
R_VDD4_12962 METAL6_398000_4677000 METAL6_398000_4729000 0.104
R_VDD4_12963 METAL6_398000_4729000 METAL6_398000_4741000 0.024
R_VDD4_12964 METAL6_398000_4741000 METAL6_398000_4753000 0.024
R_VDD4_12965 METAL6_398000_4753000 METAL6_398000_4765000 0.024
R_VDD4_12966 METAL6_398000_4765000 METAL6_398000_4777000 0.024
R_VDD4_12967 METAL6_398000_4777000 METAL6_398000_4893000 0.232
R_VDD4_12968 METAL6_398000_4893000 METAL6_398000_4907000 0.028
R_VDD4_12969 METAL6_398000_4907000 METAL6_398000_5053000 0.292
R_VDD4_12970 METAL6_398000_5053000 METAL6_398000_5065000 0.024
R_VDD4_12971 METAL6_398000_5065000 METAL6_398000_5077000 0.024
R_VDD4_12972 METAL6_398000_5077000 METAL6_398000_5153000 0.152
R_VDD4_12973 METAL6_398000_5153000 METAL6_398000_5165000 0.024
R_VDD4_12974 METAL6_398000_5165000 METAL6_398000_5177000 0.024
R_VDD4_12975 METAL6_398000_5177000 METAL6_398000_5253000 0.152
R_VDD4_12976 METAL6_398000_5253000 METAL6_398000_5265000 0.024
R_VDD4_12977 METAL6_398000_5265000 METAL6_398000_5277000 0.024
R_VDD4_12978 METAL6_398000_5277000 METAL6_398000_5353000 0.152
R_VDD4_12979 METAL6_398000_5353000 METAL6_398000_5365000 0.024
R_VDD4_12980 METAL6_398000_5365000 METAL6_398000_5377000 0.024
R_VDD4_12981 METAL6_398000_5377000 METAL6_398000_5441000 0.128
R_VDD4_12982 METAL6_398000_5441000 METAL5_398000_5441000 0.1
R_VDD4_12983 METAL5_398000_5441000 METAL5_390000_5441000 0.032
R_VDD4_12984 METAL5_390000_5441000 METAL5_388000_5441000 0.008
R_VDD4_12985 METAL5_388000_5441000 METAL5_386000_5441000 0.008
R_VDD4_12986 METAL5_386000_5441000 METAL5_378000_5441000 0.032
R_VDD4_12987 METAL5_378000_5441000 METAL5_376000_5441000 0.008
R_VDD4_12988 METAL5_376000_5441000 METAL5_374000_5441000 0.008
R_VDD4_12989 METAL5_374000_5441000 METAL5_366000_5441000 0.032
R_VDD4_12990 METAL5_366000_5441000 METAL5_364000_5441000 0.008
R_VDD4_12991 METAL5_364000_5441000 METAL5_362000_5441000 0.008
R_VDD4_12992 METAL5_362000_5441000 METAL5_362000_5453000 0.048
R_VDD4_12993 METAL5_362000_5453000 METAL5_362000_5465000 0.048
R_VDD4_12994 METAL5_362000_5465000 METAL5_362000_5477000 0.048
R_VDD4_12995 METAL5_362000_5477000 METAL6_362000_5477000 0.1
R_VDD4_12996 METAL6_362000_5477000 METAL6_362000_5489000 0.024
R_VDD4_12997 METAL6_362000_5489000 METAL6_362000_5593000 0.208
R_VDD4_12998 METAL6_362000_5593000 METAL6_362000_5607000 0.028
R_VDD4_12999 METAL6_362000_5607000 METAL6_362000_5753000 0.292
R_VDD4_13000 METAL6_362000_5753000 METAL6_362000_5765000 0.024
R_VDD4_13001 METAL6_362000_5765000 METAL6_362000_5777000 0.024
R_VDD4_13002 METAL6_362000_5777000 METAL6_362000_5853000 0.152
R_VDD4_13003 METAL6_362000_5853000 METAL6_362000_5865000 0.024
R_VDD4_13004 METAL6_362000_5865000 METAL6_362000_5877000 0.024
R_VDD4_13005 METAL6_362000_5877000 METAL6_362000_5953000 0.152
R_VDD4_13006 METAL6_362000_5953000 METAL6_362000_5965000 0.024
R_VDD4_13007 METAL6_362000_5965000 METAL6_362000_5977000 0.024
R_VDD4_13008 METAL6_362000_5977000 METAL6_362000_6053000 0.152
R_VDD4_13009 METAL6_362000_6053000 METAL6_362000_6065000 0.024
R_VDD4_13010 METAL6_362000_6065000 METAL6_352000_6065000 0.02
R_VDD4_13011 METAL6_352000_6065000 METAL6_350000_6065000 0.004
R_VDD4_13012 METAL6_350000_6065000 METAL6_348000_6065000 0.004
R_VDD4_13013 METAL6_348000_6065000 METAL6_340000_6065000 0.016
R_VDD4_13014 METAL6_340000_6065000 METAL6_338000_6065000 0.004
R_VDD4_13015 METAL6_338000_6065000 METAL6_336000_6065000 0.004
R_VDD4_13016 METAL6_336000_6065000 METAL6_328000_6065000 0.016
R_VDD4_13017 METAL6_328000_6065000 METAL6_326000_6065000 0.004
R_VDD4_13018 METAL6_326000_6065000 METAL6_324000_6065000 0.004
R_VDD4_13019 METAL6_324000_6065000 METAL6_314000_6065000 0.02
R_VDD4_13020 METAL6_314000_6065000 METAL6_312000_6065000 0.004
R_VDD4_13021 METAL6_312000_6065000 METAL6_302000_6065000 0.02
R_VDD4_13022 METAL6_302000_6065000 METAL6_300000_6065000 0.004
R_VDD4_13023 METAL6_300000_6065000 METAL5_300000_6065000 0.1
R_VDD4_13024 METAL5_300000_6065000 METAL5_293000_6065000 0.028
R_VDD4_13025 METAL5_293000_6065000 METAL5_288000_6065000 0.02
R_VDD4_13026 METAL5_288000_6065000 METAL5_281000_6065000 0.028
R_VDD4_13027 METAL5_281000_6065000 METAL5_276000_6065000 0.02
R_VDD4_13028 METAL5_276000_6065000 METAL5_269000_6065000 0.028
R_VDD4_13029 METAL5_269000_6065000 METAL5_264000_6065000 0.02
R_VDD4_13030 METAL5_264000_6065000 METAL5_257000_6065000 0.028
R_VDD4_13031 METAL5_257000_6065000 METAL6_257000_6065000 0.1
R_VDD4_13032 METAL6_555000_6065000 METAL6_543000_6065000 0.024
R_VDD4_13033 METAL6_374000_1277000 METAL5_374000_1277000 0.1
R_VDD4_13034 METAL5_374000_1277000 METAL5_376000_1277000 0.008
R_VDD4_13035 METAL5_376000_1277000 METAL5_378000_1277000 0.008
R_VDD4_13036 METAL5_378000_1277000 METAL5_386000_1277000 0.032
R_VDD4_13037 METAL5_386000_1277000 METAL5_388000_1277000 0.008
R_VDD4_13038 METAL5_388000_1277000 METAL5_390000_1277000 0.008
R_VDD4_13039 METAL5_390000_1277000 METAL5_398000_1277000 0.032
R_VDD4_13040 METAL5_398000_1277000 METAL5_400000_1277000 0.008
R_VDD4_13041 METAL5_400000_1277000 METAL5_402000_1277000 0.008
R_VDD4_13042 METAL5_402000_1277000 METAL5_410000_1277000 0.032
R_VDD4_13043 METAL5_410000_1277000 METAL6_410000_1277000 0.1
R_VDD4_13044 METAL6_410000_1277000 METAL6_410000_1381000 0.208
R_VDD4_13045 METAL6_410000_1381000 METAL6_410000_1393000 0.024
R_VDD4_13046 METAL6_410000_1393000 METAL6_410000_1405000 0.024
R_VDD4_13047 METAL6_410000_1405000 METAL6_410000_1407000 0.004
R_VDD4_13048 METAL6_410000_1407000 METAL6_410000_1553000 0.292
R_VDD4_13049 METAL6_410000_1553000 METAL6_410000_1565000 0.024
R_VDD4_13050 METAL6_410000_1565000 METAL6_410000_1577000 0.024
R_VDD4_13051 METAL6_410000_1577000 METAL6_410000_1653000 0.152
R_VDD4_13052 METAL6_410000_1653000 METAL6_410000_1665000 0.024
R_VDD4_13053 METAL6_410000_1665000 METAL6_410000_1677000 0.024
R_VDD4_13054 METAL6_410000_1677000 METAL6_410000_1753000 0.152
R_VDD4_13055 METAL6_410000_1753000 METAL6_410000_1765000 0.024
R_VDD4_13056 METAL6_410000_1765000 METAL6_410000_1777000 0.024
R_VDD4_13057 METAL6_410000_1777000 METAL6_410000_1841000 0.128
R_VDD4_13058 METAL6_410000_1841000 METAL6_410000_1853000 0.024
R_VDD4_13059 METAL6_410000_1853000 METAL6_410000_1865000 0.024
R_VDD4_13060 METAL6_410000_1865000 METAL6_410000_1877000 0.024
R_VDD4_13061 METAL6_410000_1877000 METAL6_410000_1929000 0.104
R_VDD4_13062 METAL6_410000_1929000 METAL6_410000_1941000 0.024
R_VDD4_13063 METAL6_410000_1941000 METAL6_410000_1953000 0.024
R_VDD4_13064 METAL6_410000_1953000 METAL6_410000_1965000 0.024
R_VDD4_13065 METAL6_410000_1965000 METAL6_410000_1977000 0.024
R_VDD4_13066 METAL6_410000_1977000 METAL6_410000_2093000 0.232
R_VDD4_13067 METAL6_410000_2093000 METAL6_410000_2107000 0.028
R_VDD4_13068 METAL6_410000_2107000 METAL6_410000_2241000 0.268
R_VDD4_13069 METAL6_410000_2241000 METAL6_410000_2253000 0.024
R_VDD4_13070 METAL6_410000_2253000 METAL6_410000_2265000 0.024
R_VDD4_13071 METAL6_410000_2265000 METAL6_410000_2277000 0.024
R_VDD4_13072 METAL6_410000_2277000 METAL6_410000_2353000 0.152
R_VDD4_13073 METAL6_410000_2353000 METAL6_410000_2365000 0.024
R_VDD4_13074 METAL6_410000_2365000 METAL6_410000_2377000 0.024
R_VDD4_13075 METAL6_410000_2377000 METAL6_410000_2453000 0.152
R_VDD4_13076 METAL6_410000_2453000 METAL6_410000_2465000 0.024
R_VDD4_13077 METAL6_410000_2465000 METAL6_410000_2477000 0.024
R_VDD4_13078 METAL6_410000_2477000 METAL6_410000_2553000 0.152
R_VDD4_13079 METAL6_410000_2553000 METAL6_410000_2565000 0.024
R_VDD4_13080 METAL6_410000_2565000 METAL6_410000_2577000 0.024
R_VDD4_13081 METAL6_410000_2577000 METAL6_410000_2629000 0.104
R_VDD4_13082 METAL6_410000_2629000 METAL6_410000_2641000 0.024
R_VDD4_13083 METAL6_410000_2641000 METAL6_410000_2653000 0.024
R_VDD4_13084 METAL6_410000_2653000 METAL6_410000_2665000 0.024
R_VDD4_13085 METAL6_410000_2665000 METAL6_410000_2677000 0.024
R_VDD4_13086 METAL6_410000_2677000 METAL6_410000_2793000 0.232
R_VDD4_13087 METAL6_410000_2793000 METAL6_410000_2807000 0.028
R_VDD4_13088 METAL6_410000_2807000 METAL6_410000_2953000 0.292
R_VDD4_13089 METAL6_410000_2953000 METAL6_410000_2965000 0.024
R_VDD4_13090 METAL6_410000_2965000 METAL6_410000_2977000 0.024
R_VDD4_13091 METAL6_410000_2977000 METAL6_410000_3053000 0.152
R_VDD4_13092 METAL6_410000_3053000 METAL6_410000_3065000 0.024
R_VDD4_13093 METAL6_410000_3065000 METAL6_410000_3077000 0.024
R_VDD4_13094 METAL6_410000_3077000 METAL6_410000_3153000 0.152
R_VDD4_13095 METAL6_410000_3153000 METAL6_410000_3165000 0.024
R_VDD4_13096 METAL6_410000_3165000 METAL6_410000_3177000 0.024
R_VDD4_13097 METAL6_410000_3177000 METAL6_410000_3253000 0.152
R_VDD4_13098 METAL6_410000_3253000 METAL6_410000_3265000 0.024
R_VDD4_13099 METAL6_410000_3265000 METAL6_410000_3277000 0.024
R_VDD4_13100 METAL6_410000_3277000 METAL6_410000_3341000 0.128
R_VDD4_13101 METAL6_410000_3341000 METAL6_410000_3353000 0.024
R_VDD4_13102 METAL6_410000_3353000 METAL6_410000_3365000 0.024
R_VDD4_13103 METAL6_410000_3365000 METAL6_410000_3377000 0.024
R_VDD4_13104 METAL6_410000_3377000 METAL6_410000_3493000 0.232
R_VDD4_13105 METAL6_410000_3493000 METAL6_410000_3507000 0.028
R_VDD4_13106 METAL6_410000_3507000 METAL6_410000_3653000 0.292
R_VDD4_13107 METAL6_410000_3653000 METAL6_410000_3665000 0.024
R_VDD4_13108 METAL6_410000_3665000 METAL6_410000_3677000 0.024
R_VDD4_13109 METAL6_410000_3677000 METAL6_410000_3753000 0.152
R_VDD4_13110 METAL6_410000_3753000 METAL6_410000_3765000 0.024
R_VDD4_13111 METAL6_410000_3765000 METAL6_410000_3777000 0.024
R_VDD4_13112 METAL6_410000_3777000 METAL6_410000_3853000 0.152
R_VDD4_13113 METAL6_410000_3853000 METAL6_410000_3865000 0.024
R_VDD4_13114 METAL6_410000_3865000 METAL6_410000_3877000 0.024
R_VDD4_13115 METAL6_410000_3877000 METAL6_410000_3953000 0.152
R_VDD4_13116 METAL6_410000_3953000 METAL6_410000_3965000 0.024
R_VDD4_13117 METAL6_410000_3965000 METAL6_410000_3977000 0.024
R_VDD4_13118 METAL6_410000_3977000 METAL6_410000_4053000 0.152
R_VDD4_13119 METAL6_410000_4053000 METAL6_410000_4065000 0.024
R_VDD4_13120 METAL6_410000_4065000 METAL6_410000_4077000 0.024
R_VDD4_13121 METAL6_410000_4077000 METAL6_410000_4193000 0.232
R_VDD4_13122 METAL6_410000_4193000 METAL6_410000_4207000 0.028
R_VDD4_13123 METAL6_410000_4207000 METAL6_410000_4353000 0.292
R_VDD4_13124 METAL6_410000_4353000 METAL6_410000_4365000 0.024
R_VDD4_13125 METAL6_410000_4365000 METAL6_410000_4377000 0.024
R_VDD4_13126 METAL6_410000_4377000 METAL6_410000_4453000 0.152
R_VDD4_13127 METAL6_410000_4453000 METAL6_410000_4465000 0.024
R_VDD4_13128 METAL6_410000_4465000 METAL6_410000_4477000 0.024
R_VDD4_13129 METAL6_410000_4477000 METAL6_410000_4553000 0.152
R_VDD4_13130 METAL6_410000_4553000 METAL6_410000_4565000 0.024
R_VDD4_13131 METAL6_410000_4565000 METAL6_410000_4577000 0.024
R_VDD4_13132 METAL6_410000_4577000 METAL6_410000_4653000 0.152
R_VDD4_13133 METAL6_410000_4653000 METAL6_410000_4665000 0.024
R_VDD4_13134 METAL6_410000_4665000 METAL6_410000_4677000 0.024
R_VDD4_13135 METAL6_410000_4677000 METAL6_410000_4729000 0.104
R_VDD4_13136 METAL6_410000_4729000 METAL6_410000_4741000 0.024
R_VDD4_13137 METAL6_410000_4741000 METAL6_410000_4753000 0.024
R_VDD4_13138 METAL6_410000_4753000 METAL6_410000_4765000 0.024
R_VDD4_13139 METAL6_410000_4765000 METAL6_410000_4777000 0.024
R_VDD4_13140 METAL6_410000_4777000 METAL6_410000_4893000 0.232
R_VDD4_13141 METAL6_410000_4893000 METAL6_410000_4907000 0.028
R_VDD4_13142 METAL6_410000_4907000 METAL6_410000_5053000 0.292
R_VDD4_13143 METAL6_410000_5053000 METAL6_410000_5065000 0.024
R_VDD4_13144 METAL6_410000_5065000 METAL6_410000_5077000 0.024
R_VDD4_13145 METAL6_410000_5077000 METAL6_410000_5153000 0.152
R_VDD4_13146 METAL6_410000_5153000 METAL6_410000_5165000 0.024
R_VDD4_13147 METAL6_410000_5165000 METAL6_410000_5177000 0.024
R_VDD4_13148 METAL6_410000_5177000 METAL6_410000_5253000 0.152
R_VDD4_13149 METAL6_410000_5253000 METAL6_410000_5265000 0.024
R_VDD4_13150 METAL6_410000_5265000 METAL6_410000_5277000 0.024
R_VDD4_13151 METAL6_410000_5277000 METAL6_410000_5353000 0.152
R_VDD4_13152 METAL6_410000_5353000 METAL6_410000_5365000 0.024
R_VDD4_13153 METAL6_410000_5365000 METAL6_410000_5377000 0.024
R_VDD4_13154 METAL6_410000_5377000 METAL6_410000_5429000 0.104
R_VDD4_13155 METAL6_410000_5429000 METAL6_410000_5441000 0.024
R_VDD4_13156 METAL6_410000_5441000 METAL6_410000_5453000 0.024
R_VDD4_13157 METAL6_410000_5453000 METAL5_410000_5453000 0.1
R_VDD4_13158 METAL5_410000_5453000 METAL5_410000_5465000 0.048
R_VDD4_13159 METAL5_410000_5465000 METAL5_410000_5477000 0.048
R_VDD4_13160 METAL5_410000_5477000 METAL6_410000_5477000 0.1
R_VDD4_13161 METAL6_410000_5477000 METAL6_410000_5489000 0.024
R_VDD4_13162 METAL6_410000_5489000 METAL6_410000_5593000 0.208
R_VDD4_13163 METAL6_410000_5593000 METAL6_410000_5607000 0.028
R_VDD4_13164 METAL6_410000_5607000 METAL6_410000_5753000 0.292
R_VDD4_13165 METAL6_410000_5753000 METAL6_410000_5765000 0.024
R_VDD4_13166 METAL6_410000_5765000 METAL6_410000_5777000 0.024
R_VDD4_13167 METAL6_410000_5777000 METAL6_410000_5853000 0.152
R_VDD4_13168 METAL6_410000_5853000 METAL6_410000_5865000 0.024
R_VDD4_13169 METAL6_410000_5865000 METAL6_410000_5877000 0.024
R_VDD4_13170 METAL6_410000_5877000 METAL6_410000_5953000 0.152
R_VDD4_13171 METAL6_410000_5953000 METAL6_410000_5965000 0.024
R_VDD4_13172 METAL6_410000_5965000 METAL6_410000_5977000 0.024
R_VDD4_13173 METAL6_410000_5977000 METAL6_410000_6053000 0.152
R_VDD4_13174 METAL6_410000_6053000 METAL6_410000_6065000 0.024
R_VDD4_13175 METAL6_410000_6065000 METAL6_412000_6065000 0.004
R_VDD4_13176 METAL6_412000_6065000 METAL6_414000_6065000 0.004
R_VDD4_13177 METAL6_414000_6065000 METAL6_424000_6065000 0.02
R_VDD4_13178 METAL6_424000_6065000 METAL6_426000_6065000 0.004
R_VDD4_13179 METAL6_426000_6065000 METAL6_436000_6065000 0.02
R_VDD4_13180 METAL6_436000_6065000 METAL6_438000_6065000 0.004
R_VDD4_13181 METAL6_438000_6065000 METAL6_448000_6065000 0.02
R_VDD4_13182 METAL6_448000_6065000 METAL6_450000_6065000 0.004
R_VDD4_13183 METAL6_450000_6065000 METAL6_452000_6065000 0.004
R_VDD4_13184 METAL6_452000_6065000 METAL6_460000_6065000 0.016
R_VDD4_13185 METAL6_460000_6065000 METAL6_462000_6065000 0.004
R_VDD4_13186 METAL6_462000_6065000 METAL6_464000_6065000 0.004
R_VDD4_13187 METAL6_464000_6065000 METAL6_472000_6065000 0.016
R_VDD4_13188 METAL6_472000_6065000 METAL6_474000_6065000 0.004
R_VDD4_13189 METAL6_474000_6065000 METAL6_476000_6065000 0.004
R_VDD4_13190 METAL6_476000_6065000 METAL6_484000_6065000 0.016
R_VDD4_13191 METAL6_484000_6065000 METAL6_486000_6065000 0.004
R_VDD4_13192 METAL6_486000_6065000 METAL6_488000_6065000 0.004
R_VDD4_13193 METAL6_488000_6065000 METAL6_500000_6065000 0.024
R_VDD4_13194 METAL6_500000_6065000 METAL5_500000_6065000 0.1
R_VDD4_13195 METAL5_500000_6065000 METAL5_507000_6065000 0.028
R_VDD4_13196 METAL5_507000_6065000 METAL5_512000_6065000 0.02
R_VDD4_13197 METAL5_512000_6065000 METAL5_519000_6065000 0.028
R_VDD4_13198 METAL5_519000_6065000 METAL5_524000_6065000 0.02
R_VDD4_13199 METAL5_524000_6065000 METAL5_531000_6065000 0.028
R_VDD4_13200 METAL5_531000_6065000 METAL5_543000_6065000 0.048
R_VDD4_13201 METAL5_543000_6065000 METAL6_543000_6065000 0.1
R_VDD4_13202 METAL6_245000_5365000 METAL6_257000_5365000 0.024
R_VDD4_13203 METAL6_386000_1653000 METAL5_386000_1653000 0.1
R_VDD4_13204 METAL5_386000_1653000 METAL5_386000_1665000 0.048
R_VDD4_13205 METAL5_386000_1665000 METAL5_386000_1677000 0.048
R_VDD4_13206 METAL5_386000_1677000 METAL5_386000_1753000 0.304
R_VDD4_13207 METAL5_386000_1753000 METAL5_386000_1765000 0.048
R_VDD4_13208 METAL5_386000_1765000 METAL5_386000_1777000 0.048
R_VDD4_13209 METAL5_386000_1777000 METAL5_386000_1841000 0.256
R_VDD4_13210 METAL5_386000_1841000 METAL5_386000_1853000 0.048
R_VDD4_13211 METAL5_386000_1853000 METAL5_386000_1865000 0.048
R_VDD4_13212 METAL5_386000_1865000 METAL5_386000_1877000 0.048
R_VDD4_13213 METAL5_386000_1877000 METAL5_386000_1929000 0.208
R_VDD4_13214 METAL5_386000_1929000 METAL5_386000_1941000 0.048
R_VDD4_13215 METAL5_386000_1941000 METAL5_386000_1953000 0.048
R_VDD4_13216 METAL5_386000_1953000 METAL5_386000_1965000 0.048
R_VDD4_13217 METAL5_386000_1965000 METAL5_378000_1965000 0.032
R_VDD4_13218 METAL5_378000_1965000 METAL5_376000_1965000 0.008
R_VDD4_13219 METAL5_376000_1965000 METAL5_374000_1965000 0.008
R_VDD4_13220 METAL5_374000_1965000 METAL5_366000_1965000 0.032
R_VDD4_13221 METAL5_366000_1965000 METAL5_364000_1965000 0.008
R_VDD4_13222 METAL5_364000_1965000 METAL5_362000_1965000 0.008
R_VDD4_13223 METAL5_362000_1965000 METAL6_362000_1965000 0.1
R_VDD4_13224 METAL6_362000_1965000 METAL6_362000_1977000 0.024
R_VDD4_13225 METAL6_362000_1977000 METAL6_362000_2093000 0.232
R_VDD4_13226 METAL6_362000_2093000 METAL6_362000_2107000 0.028
R_VDD4_13227 METAL6_362000_2107000 METAL6_362000_2241000 0.268
R_VDD4_13228 METAL6_362000_2241000 METAL6_362000_2253000 0.024
R_VDD4_13229 METAL6_362000_2253000 METAL6_362000_2265000 0.024
R_VDD4_13230 METAL6_362000_2265000 METAL6_362000_2277000 0.024
R_VDD4_13231 METAL6_362000_2277000 METAL6_362000_2353000 0.152
R_VDD4_13232 METAL6_362000_2353000 METAL6_362000_2365000 0.024
R_VDD4_13233 METAL6_362000_2365000 METAL6_362000_2377000 0.024
R_VDD4_13234 METAL6_362000_2377000 METAL6_362000_2453000 0.152
R_VDD4_13235 METAL6_362000_2453000 METAL6_362000_2465000 0.024
R_VDD4_13236 METAL6_362000_2465000 METAL6_362000_2477000 0.024
R_VDD4_13237 METAL6_362000_2477000 METAL6_362000_2553000 0.152
R_VDD4_13238 METAL6_362000_2553000 METAL6_362000_2565000 0.024
R_VDD4_13239 METAL6_362000_2565000 METAL6_362000_2577000 0.024
R_VDD4_13240 METAL6_362000_2577000 METAL6_362000_2629000 0.104
R_VDD4_13241 METAL6_362000_2629000 METAL6_362000_2641000 0.024
R_VDD4_13242 METAL6_362000_2641000 METAL6_362000_2653000 0.024
R_VDD4_13243 METAL6_362000_2653000 METAL6_362000_2665000 0.024
R_VDD4_13244 METAL6_362000_2665000 METAL6_362000_2677000 0.024
R_VDD4_13245 METAL6_362000_2677000 METAL6_362000_2793000 0.232
R_VDD4_13246 METAL6_362000_2793000 METAL6_362000_2807000 0.028
R_VDD4_13247 METAL6_362000_2807000 METAL6_362000_2953000 0.292
R_VDD4_13248 METAL6_362000_2953000 METAL6_362000_2965000 0.024
R_VDD4_13249 METAL6_362000_2965000 METAL6_362000_2977000 0.024
R_VDD4_13250 METAL6_362000_2977000 METAL6_362000_3053000 0.152
R_VDD4_13251 METAL6_362000_3053000 METAL6_362000_3065000 0.024
R_VDD4_13252 METAL6_362000_3065000 METAL6_362000_3077000 0.024
R_VDD4_13253 METAL6_362000_3077000 METAL6_362000_3153000 0.152
R_VDD4_13254 METAL6_362000_3153000 METAL6_362000_3165000 0.024
R_VDD4_13255 METAL6_362000_3165000 METAL6_362000_3177000 0.024
R_VDD4_13256 METAL6_362000_3177000 METAL6_362000_3253000 0.152
R_VDD4_13257 METAL6_362000_3253000 METAL6_362000_3265000 0.024
R_VDD4_13258 METAL6_362000_3265000 METAL6_362000_3277000 0.024
R_VDD4_13259 METAL6_362000_3277000 METAL6_362000_3341000 0.128
R_VDD4_13260 METAL6_362000_3341000 METAL6_362000_3353000 0.024
R_VDD4_13261 METAL6_362000_3353000 METAL6_362000_3365000 0.024
R_VDD4_13262 METAL6_362000_3365000 METAL6_362000_3377000 0.024
R_VDD4_13263 METAL6_362000_3377000 METAL6_362000_3493000 0.232
R_VDD4_13264 METAL6_362000_3493000 METAL6_362000_3507000 0.028
R_VDD4_13265 METAL6_362000_3507000 METAL6_362000_3653000 0.292
R_VDD4_13266 METAL6_362000_3653000 METAL6_362000_3665000 0.024
R_VDD4_13267 METAL6_362000_3665000 METAL6_362000_3677000 0.024
R_VDD4_13268 METAL6_362000_3677000 METAL6_362000_3753000 0.152
R_VDD4_13269 METAL6_362000_3753000 METAL6_362000_3765000 0.024
R_VDD4_13270 METAL6_362000_3765000 METAL6_362000_3777000 0.024
R_VDD4_13271 METAL6_362000_3777000 METAL6_362000_3853000 0.152
R_VDD4_13272 METAL6_362000_3853000 METAL6_362000_3865000 0.024
R_VDD4_13273 METAL6_362000_3865000 METAL6_362000_3877000 0.024
R_VDD4_13274 METAL6_362000_3877000 METAL6_362000_3953000 0.152
R_VDD4_13275 METAL6_362000_3953000 METAL6_362000_3965000 0.024
R_VDD4_13276 METAL6_362000_3965000 METAL6_362000_3977000 0.024
R_VDD4_13277 METAL6_362000_3977000 METAL6_362000_4053000 0.152
R_VDD4_13278 METAL6_362000_4053000 METAL6_362000_4065000 0.024
R_VDD4_13279 METAL6_362000_4065000 METAL6_362000_4077000 0.024
R_VDD4_13280 METAL6_362000_4077000 METAL6_362000_4193000 0.232
R_VDD4_13281 METAL6_362000_4193000 METAL6_362000_4207000 0.028
R_VDD4_13282 METAL6_362000_4207000 METAL6_362000_4353000 0.292
R_VDD4_13283 METAL6_362000_4353000 METAL6_362000_4365000 0.024
R_VDD4_13284 METAL6_362000_4365000 METAL6_362000_4377000 0.024
R_VDD4_13285 METAL6_362000_4377000 METAL6_362000_4453000 0.152
R_VDD4_13286 METAL6_362000_4453000 METAL6_362000_4465000 0.024
R_VDD4_13287 METAL6_362000_4465000 METAL6_362000_4477000 0.024
R_VDD4_13288 METAL6_362000_4477000 METAL6_362000_4553000 0.152
R_VDD4_13289 METAL6_362000_4553000 METAL6_362000_4565000 0.024
R_VDD4_13290 METAL6_362000_4565000 METAL6_362000_4577000 0.024
R_VDD4_13291 METAL6_362000_4577000 METAL6_362000_4653000 0.152
R_VDD4_13292 METAL6_362000_4653000 METAL6_362000_4665000 0.024
R_VDD4_13293 METAL6_362000_4665000 METAL6_362000_4677000 0.024
R_VDD4_13294 METAL6_362000_4677000 METAL6_362000_4729000 0.104
R_VDD4_13295 METAL6_362000_4729000 METAL6_362000_4741000 0.024
R_VDD4_13296 METAL6_362000_4741000 METAL6_362000_4753000 0.024
R_VDD4_13297 METAL6_362000_4753000 METAL6_362000_4765000 0.024
R_VDD4_13298 METAL6_362000_4765000 METAL6_362000_4777000 0.024
R_VDD4_13299 METAL6_362000_4777000 METAL6_362000_4893000 0.232
R_VDD4_13300 METAL6_362000_4893000 METAL6_362000_4907000 0.028
R_VDD4_13301 METAL6_362000_4907000 METAL6_362000_5053000 0.292
R_VDD4_13302 METAL6_362000_5053000 METAL6_362000_5065000 0.024
R_VDD4_13303 METAL6_362000_5065000 METAL6_362000_5077000 0.024
R_VDD4_13304 METAL6_362000_5077000 METAL6_362000_5153000 0.152
R_VDD4_13305 METAL6_362000_5153000 METAL6_362000_5165000 0.024
R_VDD4_13306 METAL6_362000_5165000 METAL6_362000_5177000 0.024
R_VDD4_13307 METAL6_362000_5177000 METAL6_362000_5253000 0.152
R_VDD4_13308 METAL6_362000_5253000 METAL6_362000_5265000 0.024
R_VDD4_13309 METAL6_362000_5265000 METAL6_362000_5277000 0.024
R_VDD4_13310 METAL6_362000_5277000 METAL6_362000_5353000 0.152
R_VDD4_13311 METAL6_362000_5353000 METAL6_362000_5365000 0.024
R_VDD4_13312 METAL6_362000_5365000 METAL6_354000_5365000 0.016
R_VDD4_13313 METAL6_354000_5365000 METAL6_352000_5365000 0.004
R_VDD4_13314 METAL6_352000_5365000 METAL6_350000_5365000 0.004
R_VDD4_13315 METAL6_350000_5365000 METAL6_348000_5365000 0.004
R_VDD4_13316 METAL6_348000_5365000 METAL6_340000_5365000 0.016
R_VDD4_13317 METAL6_340000_5365000 METAL6_338000_5365000 0.004
R_VDD4_13318 METAL6_338000_5365000 METAL6_336000_5365000 0.004
R_VDD4_13319 METAL6_336000_5365000 METAL6_328000_5365000 0.016
R_VDD4_13320 METAL6_328000_5365000 METAL6_326000_5365000 0.004
R_VDD4_13321 METAL6_326000_5365000 METAL6_324000_5365000 0.004
R_VDD4_13322 METAL6_324000_5365000 METAL6_314000_5365000 0.02
R_VDD4_13323 METAL6_314000_5365000 METAL6_312000_5365000 0.004
R_VDD4_13324 METAL6_312000_5365000 METAL6_302000_5365000 0.02
R_VDD4_13325 METAL6_302000_5365000 METAL6_300000_5365000 0.004
R_VDD4_13326 METAL6_300000_5365000 METAL5_300000_5365000 0.1
R_VDD4_13327 METAL5_300000_5365000 METAL5_293000_5365000 0.028
R_VDD4_13328 METAL5_293000_5365000 METAL5_288000_5365000 0.02
R_VDD4_13329 METAL5_288000_5365000 METAL5_281000_5365000 0.028
R_VDD4_13330 METAL5_281000_5365000 METAL5_276000_5365000 0.02
R_VDD4_13331 METAL5_276000_5365000 METAL5_269000_5365000 0.028
R_VDD4_13332 METAL5_269000_5365000 METAL5_264000_5365000 0.02
R_VDD4_13333 METAL5_264000_5365000 METAL5_257000_5365000 0.028
R_VDD4_13334 METAL5_257000_5365000 METAL6_257000_5365000 0.1
R_VDD4_13335 METAL6_555000_5365000 METAL6_543000_5365000 0.024
R_VDD4_13336 METAL6_398000_1189000 METAL6_400000_1189000 0.004
R_VDD4_13337 METAL6_400000_1189000 METAL6_402000_1189000 0.004
R_VDD4_13338 METAL6_402000_1189000 METAL6_410000_1189000 0.016
R_VDD4_13339 METAL6_410000_1189000 METAL6_410000_1253000 0.128
R_VDD4_13340 METAL6_410000_1253000 METAL6_410000_1265000 0.024
R_VDD4_13341 METAL6_410000_1265000 METAL6_412000_1265000 0.004
R_VDD4_13342 METAL6_412000_1265000 METAL5_412000_1265000 0.1
R_VDD4_13343 METAL5_412000_1265000 METAL5_414000_1265000 0.008
R_VDD4_13344 METAL5_414000_1265000 METAL5_422000_1265000 0.032
R_VDD4_13345 METAL5_422000_1265000 METAL5_422000_1277000 0.048
R_VDD4_13346 METAL5_422000_1277000 METAL5_422000_1289000 0.048
R_VDD4_13347 METAL5_422000_1289000 METAL5_422000_1381000 0.368
R_VDD4_13348 METAL5_422000_1381000 METAL5_422000_1393000 0.048
R_VDD4_13349 METAL5_422000_1393000 METAL5_422000_1405000 0.048
R_VDD4_13350 METAL5_422000_1405000 METAL5_414000_1405000 0.032
R_VDD4_13351 METAL5_414000_1405000 METAL5_414000_1407000 0.008
R_VDD4_13352 METAL5_414000_1407000 METAL5_414000_1553000 0.584
R_VDD4_13353 METAL5_414000_1553000 METAL5_414000_1565000 0.048
R_VDD4_13354 METAL5_414000_1565000 METAL5_414000_1577000 0.048
R_VDD4_13355 METAL5_414000_1577000 METAL5_414000_1641000 0.256
R_VDD4_13356 METAL5_414000_1641000 METAL5_414000_1653000 0.048
R_VDD4_13357 METAL5_414000_1653000 METAL5_414000_1665000 0.048
R_VDD4_13358 METAL5_414000_1665000 METAL5_414000_1677000 0.048
R_VDD4_13359 METAL5_414000_1677000 METAL5_414000_1753000 0.304
R_VDD4_13360 METAL5_414000_1753000 METAL5_414000_1765000 0.048
R_VDD4_13361 METAL5_414000_1765000 METAL5_414000_1777000 0.048
R_VDD4_13362 METAL5_414000_1777000 METAL5_414000_1841000 0.256
R_VDD4_13363 METAL5_414000_1841000 METAL5_414000_1853000 0.048
R_VDD4_13364 METAL5_414000_1853000 METAL5_414000_1865000 0.048
R_VDD4_13365 METAL5_414000_1865000 METAL5_414000_1877000 0.048
R_VDD4_13366 METAL5_414000_1877000 METAL5_414000_1929000 0.208
R_VDD4_13367 METAL5_414000_1929000 METAL5_412000_1929000 0.008
R_VDD4_13368 METAL5_412000_1929000 METAL5_412000_1941000 0.048
R_VDD4_13369 METAL5_412000_1941000 METAL5_412000_1953000 0.048
R_VDD4_13370 METAL5_412000_1953000 METAL5_414000_1953000 0.008
R_VDD4_13371 METAL5_414000_1953000 METAL5_422000_1953000 0.032
R_VDD4_13372 METAL5_422000_1953000 METAL6_422000_1953000 0.1
R_VDD4_13373 METAL6_422000_1953000 METAL6_422000_1965000 0.024
R_VDD4_13374 METAL6_422000_1965000 METAL6_422000_1977000 0.024
R_VDD4_13375 METAL6_422000_1977000 METAL6_422000_2093000 0.232
R_VDD4_13376 METAL6_422000_2093000 METAL6_422000_2107000 0.028
R_VDD4_13377 METAL6_422000_2107000 METAL6_422000_2241000 0.268
R_VDD4_13378 METAL6_422000_2241000 METAL6_422000_2253000 0.024
R_VDD4_13379 METAL6_422000_2253000 METAL6_422000_2265000 0.024
R_VDD4_13380 METAL6_422000_2265000 METAL6_422000_2277000 0.024
R_VDD4_13381 METAL6_422000_2277000 METAL6_422000_2353000 0.152
R_VDD4_13382 METAL6_422000_2353000 METAL6_422000_2365000 0.024
R_VDD4_13383 METAL6_422000_2365000 METAL6_422000_2377000 0.024
R_VDD4_13384 METAL6_422000_2377000 METAL6_422000_2453000 0.152
R_VDD4_13385 METAL6_422000_2453000 METAL6_422000_2465000 0.024
R_VDD4_13386 METAL6_422000_2465000 METAL6_422000_2477000 0.024
R_VDD4_13387 METAL6_422000_2477000 METAL6_422000_2553000 0.152
R_VDD4_13388 METAL6_422000_2553000 METAL6_422000_2565000 0.024
R_VDD4_13389 METAL6_422000_2565000 METAL6_422000_2577000 0.024
R_VDD4_13390 METAL6_422000_2577000 METAL6_422000_2629000 0.104
R_VDD4_13391 METAL6_422000_2629000 METAL6_422000_2641000 0.024
R_VDD4_13392 METAL6_422000_2641000 METAL6_422000_2653000 0.024
R_VDD4_13393 METAL6_422000_2653000 METAL6_422000_2665000 0.024
R_VDD4_13394 METAL6_422000_2665000 METAL6_422000_2677000 0.024
R_VDD4_13395 METAL6_422000_2677000 METAL6_422000_2793000 0.232
R_VDD4_13396 METAL6_422000_2793000 METAL6_422000_2807000 0.028
R_VDD4_13397 METAL6_422000_2807000 METAL6_422000_2953000 0.292
R_VDD4_13398 METAL6_422000_2953000 METAL6_422000_2965000 0.024
R_VDD4_13399 METAL6_422000_2965000 METAL6_422000_2977000 0.024
R_VDD4_13400 METAL6_422000_2977000 METAL6_422000_3053000 0.152
R_VDD4_13401 METAL6_422000_3053000 METAL6_422000_3065000 0.024
R_VDD4_13402 METAL6_422000_3065000 METAL6_422000_3077000 0.024
R_VDD4_13403 METAL6_422000_3077000 METAL6_422000_3153000 0.152
R_VDD4_13404 METAL6_422000_3153000 METAL6_422000_3165000 0.024
R_VDD4_13405 METAL6_422000_3165000 METAL6_422000_3177000 0.024
R_VDD4_13406 METAL6_422000_3177000 METAL6_422000_3253000 0.152
R_VDD4_13407 METAL6_422000_3253000 METAL6_422000_3265000 0.024
R_VDD4_13408 METAL6_422000_3265000 METAL6_422000_3277000 0.024
R_VDD4_13409 METAL6_422000_3277000 METAL6_422000_3341000 0.128
R_VDD4_13410 METAL6_422000_3341000 METAL6_422000_3353000 0.024
R_VDD4_13411 METAL6_422000_3353000 METAL6_422000_3365000 0.024
R_VDD4_13412 METAL6_422000_3365000 METAL6_422000_3377000 0.024
R_VDD4_13413 METAL6_422000_3377000 METAL6_422000_3493000 0.232
R_VDD4_13414 METAL6_422000_3493000 METAL6_422000_3507000 0.028
R_VDD4_13415 METAL6_422000_3507000 METAL6_422000_3653000 0.292
R_VDD4_13416 METAL6_422000_3653000 METAL6_422000_3665000 0.024
R_VDD4_13417 METAL6_422000_3665000 METAL6_422000_3677000 0.024
R_VDD4_13418 METAL6_422000_3677000 METAL6_422000_3753000 0.152
R_VDD4_13419 METAL6_422000_3753000 METAL6_422000_3765000 0.024
R_VDD4_13420 METAL6_422000_3765000 METAL6_422000_3777000 0.024
R_VDD4_13421 METAL6_422000_3777000 METAL6_422000_3853000 0.152
R_VDD4_13422 METAL6_422000_3853000 METAL6_422000_3865000 0.024
R_VDD4_13423 METAL6_422000_3865000 METAL6_422000_3877000 0.024
R_VDD4_13424 METAL6_422000_3877000 METAL6_422000_3953000 0.152
R_VDD4_13425 METAL6_422000_3953000 METAL6_422000_3965000 0.024
R_VDD4_13426 METAL6_422000_3965000 METAL6_422000_3977000 0.024
R_VDD4_13427 METAL6_422000_3977000 METAL6_422000_4053000 0.152
R_VDD4_13428 METAL6_422000_4053000 METAL6_422000_4065000 0.024
R_VDD4_13429 METAL6_422000_4065000 METAL6_422000_4077000 0.024
R_VDD4_13430 METAL6_422000_4077000 METAL6_422000_4193000 0.232
R_VDD4_13431 METAL6_422000_4193000 METAL6_422000_4207000 0.028
R_VDD4_13432 METAL6_422000_4207000 METAL6_422000_4353000 0.292
R_VDD4_13433 METAL6_422000_4353000 METAL6_422000_4365000 0.024
R_VDD4_13434 METAL6_422000_4365000 METAL6_422000_4377000 0.024
R_VDD4_13435 METAL6_422000_4377000 METAL6_422000_4453000 0.152
R_VDD4_13436 METAL6_422000_4453000 METAL6_422000_4465000 0.024
R_VDD4_13437 METAL6_422000_4465000 METAL6_422000_4477000 0.024
R_VDD4_13438 METAL6_422000_4477000 METAL6_422000_4553000 0.152
R_VDD4_13439 METAL6_422000_4553000 METAL6_422000_4565000 0.024
R_VDD4_13440 METAL6_422000_4565000 METAL6_422000_4577000 0.024
R_VDD4_13441 METAL6_422000_4577000 METAL6_422000_4653000 0.152
R_VDD4_13442 METAL6_422000_4653000 METAL6_422000_4665000 0.024
R_VDD4_13443 METAL6_422000_4665000 METAL6_422000_4677000 0.024
R_VDD4_13444 METAL6_422000_4677000 METAL6_422000_4729000 0.104
R_VDD4_13445 METAL6_422000_4729000 METAL6_422000_4741000 0.024
R_VDD4_13446 METAL6_422000_4741000 METAL6_422000_4753000 0.024
R_VDD4_13447 METAL6_422000_4753000 METAL6_422000_4765000 0.024
R_VDD4_13448 METAL6_422000_4765000 METAL6_422000_4777000 0.024
R_VDD4_13449 METAL6_422000_4777000 METAL6_422000_4893000 0.232
R_VDD4_13450 METAL6_422000_4893000 METAL6_422000_4907000 0.028
R_VDD4_13451 METAL6_422000_4907000 METAL6_422000_5053000 0.292
R_VDD4_13452 METAL6_422000_5053000 METAL6_422000_5065000 0.024
R_VDD4_13453 METAL6_422000_5065000 METAL6_422000_5077000 0.024
R_VDD4_13454 METAL6_422000_5077000 METAL6_422000_5153000 0.152
R_VDD4_13455 METAL6_422000_5153000 METAL6_422000_5165000 0.024
R_VDD4_13456 METAL6_422000_5165000 METAL6_422000_5177000 0.024
R_VDD4_13457 METAL6_422000_5177000 METAL6_422000_5253000 0.152
R_VDD4_13458 METAL6_422000_5253000 METAL6_422000_5265000 0.024
R_VDD4_13459 METAL6_422000_5265000 METAL6_422000_5277000 0.024
R_VDD4_13460 METAL6_422000_5277000 METAL6_422000_5353000 0.152
R_VDD4_13461 METAL6_422000_5353000 METAL6_422000_5365000 0.024
R_VDD4_13462 METAL6_422000_5365000 METAL6_424000_5365000 0.004
R_VDD4_13463 METAL6_424000_5365000 METAL6_426000_5365000 0.004
R_VDD4_13464 METAL6_426000_5365000 METAL6_436000_5365000 0.02
R_VDD4_13465 METAL6_436000_5365000 METAL6_438000_5365000 0.004
R_VDD4_13466 METAL6_438000_5365000 METAL6_448000_5365000 0.02
R_VDD4_13467 METAL6_448000_5365000 METAL6_450000_5365000 0.004
R_VDD4_13468 METAL6_450000_5365000 METAL6_452000_5365000 0.004
R_VDD4_13469 METAL6_452000_5365000 METAL6_460000_5365000 0.016
R_VDD4_13470 METAL6_460000_5365000 METAL6_462000_5365000 0.004
R_VDD4_13471 METAL6_462000_5365000 METAL6_464000_5365000 0.004
R_VDD4_13472 METAL6_464000_5365000 METAL6_472000_5365000 0.016
R_VDD4_13473 METAL6_472000_5365000 METAL6_474000_5365000 0.004
R_VDD4_13474 METAL6_474000_5365000 METAL6_476000_5365000 0.004
R_VDD4_13475 METAL6_476000_5365000 METAL5_476000_5365000 0.1
R_VDD4_13476 METAL5_476000_5365000 METAL5_484000_5365000 0.032
R_VDD4_13477 METAL5_484000_5365000 METAL5_486000_5365000 0.008
R_VDD4_13478 METAL5_486000_5365000 METAL5_488000_5365000 0.008
R_VDD4_13479 METAL5_488000_5365000 METAL5_500000_5365000 0.048
R_VDD4_13480 METAL5_500000_5365000 METAL5_507000_5365000 0.028
R_VDD4_13481 METAL5_507000_5365000 METAL5_512000_5365000 0.02
R_VDD4_13482 METAL5_512000_5365000 METAL5_519000_5365000 0.028
R_VDD4_13483 METAL5_519000_5365000 METAL5_524000_5365000 0.02
R_VDD4_13484 METAL5_524000_5365000 METAL5_531000_5365000 0.028
R_VDD4_13485 METAL5_531000_5365000 METAL5_543000_5365000 0.048
R_VDD4_13486 METAL5_543000_5365000 METAL6_543000_5365000 0.1
R_VDD4_13487 METAL6_245000_4665000 METAL6_257000_4665000 0.024
R_VDD4_13488 METAL6_374000_1665000 METAL5_374000_1665000 0.1
R_VDD4_13489 METAL5_374000_1665000 METAL5_366000_1665000 0.032
R_VDD4_13490 METAL5_366000_1665000 METAL5_364000_1665000 0.008
R_VDD4_13491 METAL5_364000_1665000 METAL5_362000_1665000 0.008
R_VDD4_13492 METAL5_362000_1665000 METAL5_354000_1665000 0.032
R_VDD4_13493 METAL5_354000_1665000 METAL5_352000_1665000 0.008
R_VDD4_13494 METAL5_352000_1665000 METAL5_350000_1665000 0.008
R_VDD4_13495 METAL5_350000_1665000 METAL5_348000_1665000 0.008
R_VDD4_13496 METAL5_348000_1665000 METAL5_340000_1665000 0.032
R_VDD4_13497 METAL5_340000_1665000 METAL5_338000_1665000 0.008
R_VDD4_13498 METAL5_338000_1665000 METAL5_336000_1665000 0.008
R_VDD4_13499 METAL5_336000_1665000 METAL5_328000_1665000 0.032
R_VDD4_13500 METAL5_328000_1665000 METAL5_326000_1665000 0.008
R_VDD4_13501 METAL5_326000_1665000 METAL5_324000_1665000 0.008
R_VDD4_13502 METAL5_324000_1665000 METAL5_314000_1665000 0.04
R_VDD4_13503 METAL5_314000_1665000 METAL5_312000_1665000 0.008
R_VDD4_13504 METAL5_312000_1665000 METAL5_302000_1665000 0.04
R_VDD4_13505 METAL5_302000_1665000 METAL5_300000_1665000 0.008
R_VDD4_13506 METAL5_300000_1665000 METAL5_293000_1665000 0.028
R_VDD4_13507 METAL5_293000_1665000 METAL5_288000_1665000 0.02
R_VDD4_13508 METAL5_288000_1665000 METAL6_288000_1665000 0.1
R_VDD4_13509 METAL6_288000_1665000 METAL6_288000_1677000 0.024
R_VDD4_13510 METAL6_288000_1677000 METAL6_288000_1753000 0.152
R_VDD4_13511 METAL6_288000_1753000 METAL6_288000_1765000 0.024
R_VDD4_13512 METAL6_288000_1765000 METAL6_288000_1777000 0.024
R_VDD4_13513 METAL6_288000_1777000 METAL6_288000_1841000 0.128
R_VDD4_13514 METAL6_288000_1841000 METAL5_288000_1841000 0.1
R_VDD4_13515 METAL5_288000_1841000 METAL5_288000_1853000 0.048
R_VDD4_13516 METAL5_288000_1853000 METAL5_288000_1865000 0.048
R_VDD4_13517 METAL5_288000_1865000 METAL5_293000_1865000 0.02
R_VDD4_13518 METAL5_293000_1865000 METAL5_300000_1865000 0.028
R_VDD4_13519 METAL5_300000_1865000 METAL6_300000_1865000 0.1
R_VDD4_13520 METAL6_300000_1865000 METAL6_300000_1877000 0.024
R_VDD4_13521 METAL6_300000_1877000 METAL6_300000_1917000 0.08
R_VDD4_13522 METAL6_300000_1917000 METAL6_300000_1929000 0.024
R_VDD4_13523 METAL6_300000_1929000 METAL6_300000_1941000 0.024
R_VDD4_13524 METAL6_300000_1941000 METAL6_300000_1953000 0.024
R_VDD4_13525 METAL6_300000_1953000 METAL6_300000_1965000 0.024
R_VDD4_13526 METAL6_300000_1965000 METAL6_300000_1977000 0.024
R_VDD4_13527 METAL6_300000_1977000 METAL6_300000_2093000 0.232
R_VDD4_13528 METAL6_300000_2093000 METAL6_300000_2107000 0.028
R_VDD4_13529 METAL6_300000_2107000 METAL6_300000_2241000 0.268
R_VDD4_13530 METAL6_300000_2241000 METAL5_300000_2241000 0.1
R_VDD4_13531 METAL5_300000_2241000 METAL5_300000_2253000 0.048
R_VDD4_13532 METAL5_300000_2253000 METAL5_300000_2265000 0.048
R_VDD4_13533 METAL5_300000_2265000 METAL5_302000_2265000 0.008
R_VDD4_13534 METAL5_302000_2265000 METAL5_312000_2265000 0.04
R_VDD4_13535 METAL5_312000_2265000 METAL6_312000_2265000 0.1
R_VDD4_13536 METAL6_312000_2265000 METAL6_312000_2277000 0.024
R_VDD4_13537 METAL6_312000_2277000 METAL6_312000_2353000 0.152
R_VDD4_13538 METAL6_312000_2353000 METAL6_312000_2365000 0.024
R_VDD4_13539 METAL6_312000_2365000 METAL6_312000_2377000 0.024
R_VDD4_13540 METAL6_312000_2377000 METAL6_312000_2453000 0.152
R_VDD4_13541 METAL6_312000_2453000 METAL6_312000_2465000 0.024
R_VDD4_13542 METAL6_312000_2465000 METAL6_312000_2477000 0.024
R_VDD4_13543 METAL6_312000_2477000 METAL6_312000_2553000 0.152
R_VDD4_13544 METAL6_312000_2553000 METAL6_312000_2565000 0.024
R_VDD4_13545 METAL6_312000_2565000 METAL6_312000_2577000 0.024
R_VDD4_13546 METAL6_312000_2577000 METAL6_312000_2629000 0.104
R_VDD4_13547 METAL6_312000_2629000 METAL5_312000_2629000 0.1
R_VDD4_13548 METAL5_312000_2629000 METAL5_314000_2629000 0.008
R_VDD4_13549 METAL5_314000_2629000 METAL5_324000_2629000 0.04
R_VDD4_13550 METAL5_324000_2629000 METAL5_326000_2629000 0.008
R_VDD4_13551 METAL5_326000_2629000 METAL5_328000_2629000 0.008
R_VDD4_13552 METAL5_328000_2629000 METAL5_336000_2629000 0.032
R_VDD4_13553 METAL5_336000_2629000 METAL5_338000_2629000 0.008
R_VDD4_13554 METAL5_338000_2629000 METAL5_340000_2629000 0.008
R_VDD4_13555 METAL5_340000_2629000 METAL5_348000_2629000 0.032
R_VDD4_13556 METAL5_348000_2629000 METAL5_350000_2629000 0.008
R_VDD4_13557 METAL5_350000_2629000 METAL5_352000_2629000 0.008
R_VDD4_13558 METAL5_352000_2629000 METAL5_354000_2629000 0.008
R_VDD4_13559 METAL5_354000_2629000 METAL5_362000_2629000 0.032
R_VDD4_13560 METAL5_362000_2629000 METAL5_362000_2641000 0.048
R_VDD4_13561 METAL5_362000_2641000 METAL5_362000_2653000 0.048
R_VDD4_13562 METAL5_362000_2653000 METAL5_354000_2653000 0.032
R_VDD4_13563 METAL5_354000_2653000 METAL5_352000_2653000 0.008
R_VDD4_13564 METAL5_352000_2653000 METAL5_350000_2653000 0.008
R_VDD4_13565 METAL5_350000_2653000 METAL6_350000_2653000 0.1
R_VDD4_13566 METAL6_350000_2653000 METAL6_350000_2665000 0.024
R_VDD4_13567 METAL6_350000_2665000 METAL6_350000_2677000 0.024
R_VDD4_13568 METAL6_350000_2677000 METAL6_350000_2793000 0.232
R_VDD4_13569 METAL6_350000_2793000 METAL6_350000_2807000 0.028
R_VDD4_13570 METAL6_350000_2807000 METAL6_350000_2953000 0.292
R_VDD4_13571 METAL6_350000_2953000 METAL6_350000_2965000 0.024
R_VDD4_13572 METAL6_350000_2965000 METAL6_350000_2977000 0.024
R_VDD4_13573 METAL6_350000_2977000 METAL6_350000_3053000 0.152
R_VDD4_13574 METAL6_350000_3053000 METAL6_350000_3065000 0.024
R_VDD4_13575 METAL6_350000_3065000 METAL6_350000_3077000 0.024
R_VDD4_13576 METAL6_350000_3077000 METAL6_350000_3153000 0.152
R_VDD4_13577 METAL6_350000_3153000 METAL6_350000_3165000 0.024
R_VDD4_13578 METAL6_350000_3165000 METAL6_350000_3177000 0.024
R_VDD4_13579 METAL6_350000_3177000 METAL6_350000_3253000 0.152
R_VDD4_13580 METAL6_350000_3253000 METAL6_350000_3265000 0.024
R_VDD4_13581 METAL6_350000_3265000 METAL6_350000_3277000 0.024
R_VDD4_13582 METAL6_350000_3277000 METAL6_350000_3341000 0.128
R_VDD4_13583 METAL6_350000_3341000 METAL6_350000_3353000 0.024
R_VDD4_13584 METAL6_350000_3353000 METAL6_350000_3365000 0.024
R_VDD4_13585 METAL6_350000_3365000 METAL6_350000_3377000 0.024
R_VDD4_13586 METAL6_350000_3377000 METAL6_350000_3493000 0.232
R_VDD4_13587 METAL6_350000_3493000 METAL6_350000_3507000 0.028
R_VDD4_13588 METAL6_350000_3507000 METAL6_350000_3653000 0.292
R_VDD4_13589 METAL6_350000_3653000 METAL6_350000_3665000 0.024
R_VDD4_13590 METAL6_350000_3665000 METAL6_350000_3677000 0.024
R_VDD4_13591 METAL6_350000_3677000 METAL6_350000_3753000 0.152
R_VDD4_13592 METAL6_350000_3753000 METAL6_350000_3765000 0.024
R_VDD4_13593 METAL6_350000_3765000 METAL6_350000_3777000 0.024
R_VDD4_13594 METAL6_350000_3777000 METAL6_350000_3853000 0.152
R_VDD4_13595 METAL6_350000_3853000 METAL6_350000_3865000 0.024
R_VDD4_13596 METAL6_350000_3865000 METAL6_350000_3877000 0.024
R_VDD4_13597 METAL6_350000_3877000 METAL6_350000_3953000 0.152
R_VDD4_13598 METAL6_350000_3953000 METAL6_350000_3965000 0.024
R_VDD4_13599 METAL6_350000_3965000 METAL6_350000_3977000 0.024
R_VDD4_13600 METAL6_350000_3977000 METAL6_350000_4053000 0.152
R_VDD4_13601 METAL6_350000_4053000 METAL6_350000_4065000 0.024
R_VDD4_13602 METAL6_350000_4065000 METAL6_350000_4077000 0.024
R_VDD4_13603 METAL6_350000_4077000 METAL6_350000_4193000 0.232
R_VDD4_13604 METAL6_350000_4193000 METAL6_350000_4207000 0.028
R_VDD4_13605 METAL6_350000_4207000 METAL6_350000_4353000 0.292
R_VDD4_13606 METAL6_350000_4353000 METAL6_350000_4365000 0.024
R_VDD4_13607 METAL6_350000_4365000 METAL6_350000_4377000 0.024
R_VDD4_13608 METAL6_350000_4377000 METAL6_350000_4453000 0.152
R_VDD4_13609 METAL6_350000_4453000 METAL6_350000_4465000 0.024
R_VDD4_13610 METAL6_350000_4465000 METAL6_350000_4477000 0.024
R_VDD4_13611 METAL6_350000_4477000 METAL6_350000_4553000 0.152
R_VDD4_13612 METAL6_350000_4553000 METAL6_350000_4565000 0.024
R_VDD4_13613 METAL6_350000_4565000 METAL6_350000_4577000 0.024
R_VDD4_13614 METAL6_350000_4577000 METAL6_350000_4653000 0.152
R_VDD4_13615 METAL6_350000_4653000 METAL6_350000_4665000 0.024
R_VDD4_13616 METAL6_350000_4665000 METAL6_348000_4665000 0.004
R_VDD4_13617 METAL6_348000_4665000 METAL6_340000_4665000 0.016
R_VDD4_13618 METAL6_340000_4665000 METAL6_338000_4665000 0.004
R_VDD4_13619 METAL6_338000_4665000 METAL6_336000_4665000 0.004
R_VDD4_13620 METAL6_336000_4665000 METAL6_328000_4665000 0.016
R_VDD4_13621 METAL6_328000_4665000 METAL6_326000_4665000 0.004
R_VDD4_13622 METAL6_326000_4665000 METAL6_324000_4665000 0.004
R_VDD4_13623 METAL6_324000_4665000 METAL6_314000_4665000 0.02
R_VDD4_13624 METAL6_314000_4665000 METAL6_312000_4665000 0.004
R_VDD4_13625 METAL6_312000_4665000 METAL5_312000_4665000 0.1
R_VDD4_13626 METAL5_312000_4665000 METAL5_302000_4665000 0.04
R_VDD4_13627 METAL5_302000_4665000 METAL5_300000_4665000 0.008
R_VDD4_13628 METAL5_300000_4665000 METAL5_293000_4665000 0.028
R_VDD4_13629 METAL5_293000_4665000 METAL5_288000_4665000 0.02
R_VDD4_13630 METAL5_288000_4665000 METAL5_281000_4665000 0.028
R_VDD4_13631 METAL5_281000_4665000 METAL5_276000_4665000 0.02
R_VDD4_13632 METAL5_276000_4665000 METAL5_269000_4665000 0.028
R_VDD4_13633 METAL5_269000_4665000 METAL5_264000_4665000 0.02
R_VDD4_13634 METAL5_264000_4665000 METAL5_257000_4665000 0.028
R_VDD4_13635 METAL5_257000_4665000 METAL6_257000_4665000 0.1
R_VDD4_13636 METAL6_555000_4665000 METAL6_543000_4665000 0.024
R_VDD4_13637 METAL6_398000_1189000 METAL5_398000_1189000 0.1
R_VDD4_13638 METAL5_398000_1189000 METAL5_398000_1201000 0.048
R_VDD4_13639 METAL5_398000_1201000 METAL5_398000_1253000 0.208
R_VDD4_13640 METAL5_398000_1253000 METAL5_398000_1265000 0.048
R_VDD4_13641 METAL5_398000_1265000 METAL5_390000_1265000 0.032
R_VDD4_13642 METAL5_390000_1265000 METAL5_388000_1265000 0.008
R_VDD4_13643 METAL5_388000_1265000 METAL5_386000_1265000 0.008
R_VDD4_13644 METAL5_386000_1265000 METAL5_378000_1265000 0.032
R_VDD4_13645 METAL5_378000_1265000 METAL5_376000_1265000 0.008
R_VDD4_13646 METAL5_376000_1265000 METAL5_374000_1265000 0.008
R_VDD4_13647 METAL5_374000_1265000 METAL5_366000_1265000 0.032
R_VDD4_13648 METAL5_366000_1265000 METAL5_364000_1265000 0.008
R_VDD4_13649 METAL5_364000_1265000 METAL5_362000_1265000 0.008
R_VDD4_13650 METAL5_362000_1265000 METAL5_362000_1277000 0.048
R_VDD4_13651 METAL5_362000_1277000 METAL5_362000_1289000 0.048
R_VDD4_13652 METAL5_362000_1289000 METAL5_362000_1381000 0.368
R_VDD4_13653 METAL5_362000_1381000 METAL5_362000_1393000 0.048
R_VDD4_13654 METAL5_362000_1393000 METAL5_362000_1405000 0.048
R_VDD4_13655 METAL5_362000_1405000 METAL5_364000_1405000 0.008
R_VDD4_13656 METAL5_364000_1405000 METAL5_366000_1405000 0.008
R_VDD4_13657 METAL5_366000_1405000 METAL5_374000_1405000 0.032
R_VDD4_13658 METAL5_374000_1405000 METAL5_376000_1405000 0.008
R_VDD4_13659 METAL5_376000_1405000 METAL5_378000_1405000 0.008
R_VDD4_13660 METAL5_378000_1405000 METAL5_386000_1405000 0.032
R_VDD4_13661 METAL5_386000_1405000 METAL5_388000_1405000 0.008
R_VDD4_13662 METAL5_388000_1405000 METAL5_390000_1405000 0.008
R_VDD4_13663 METAL5_390000_1405000 METAL5_398000_1405000 0.032
R_VDD4_13664 METAL5_398000_1405000 METAL5_398000_1407000 0.008
R_VDD4_13665 METAL5_398000_1407000 METAL5_398000_1417000 0.04
R_VDD4_13666 METAL5_398000_1417000 METAL5_398000_1553000 0.544
R_VDD4_13667 METAL5_398000_1553000 METAL5_398000_1565000 0.048
R_VDD4_13668 METAL5_398000_1565000 METAL5_398000_1577000 0.048
R_VDD4_13669 METAL5_398000_1577000 METAL5_398000_1641000 0.256
R_VDD4_13670 METAL5_398000_1641000 METAL5_398000_1653000 0.048
R_VDD4_13671 METAL5_398000_1653000 METAL5_398000_1665000 0.048
R_VDD4_13672 METAL5_398000_1665000 METAL5_398000_1677000 0.048
R_VDD4_13673 METAL5_398000_1677000 METAL5_398000_1753000 0.304
R_VDD4_13674 METAL5_398000_1753000 METAL5_398000_1765000 0.048
R_VDD4_13675 METAL5_398000_1765000 METAL5_398000_1777000 0.048
R_VDD4_13676 METAL5_398000_1777000 METAL5_398000_1829000 0.208
R_VDD4_13677 METAL5_398000_1829000 METAL5_398000_1841000 0.048
R_VDD4_13678 METAL5_398000_1841000 METAL5_398000_1853000 0.048
R_VDD4_13679 METAL5_398000_1853000 METAL5_398000_1865000 0.048
R_VDD4_13680 METAL5_398000_1865000 METAL5_398000_1877000 0.048
R_VDD4_13681 METAL5_398000_1877000 METAL5_398000_1917000 0.16
R_VDD4_13682 METAL5_398000_1917000 METAL5_398000_1929000 0.048
R_VDD4_13683 METAL5_398000_1929000 METAL5_398000_1941000 0.048
R_VDD4_13684 METAL5_398000_1941000 METAL5_398000_1953000 0.048
R_VDD4_13685 METAL5_398000_1953000 METAL5_398000_1965000 0.048
R_VDD4_13686 METAL5_398000_1965000 METAL5_398000_1977000 0.048
R_VDD4_13687 METAL5_398000_1977000 METAL5_398000_2093000 0.464
R_VDD4_13688 METAL5_398000_2093000 METAL5_398000_2107000 0.056
R_VDD4_13689 METAL5_398000_2107000 METAL5_398000_2229000 0.488
R_VDD4_13690 METAL5_398000_2229000 METAL5_398000_2241000 0.048
R_VDD4_13691 METAL5_398000_2241000 METAL5_398000_2253000 0.048
R_VDD4_13692 METAL5_398000_2253000 METAL5_398000_2265000 0.048
R_VDD4_13693 METAL5_398000_2265000 METAL5_398000_2277000 0.048
R_VDD4_13694 METAL5_398000_2277000 METAL5_398000_2353000 0.304
R_VDD4_13695 METAL5_398000_2353000 METAL5_398000_2365000 0.048
R_VDD4_13696 METAL5_398000_2365000 METAL5_398000_2377000 0.048
R_VDD4_13697 METAL5_398000_2377000 METAL5_398000_2453000 0.304
R_VDD4_13698 METAL5_398000_2453000 METAL5_398000_2465000 0.048
R_VDD4_13699 METAL5_398000_2465000 METAL5_398000_2477000 0.048
R_VDD4_13700 METAL5_398000_2477000 METAL5_398000_2553000 0.304
R_VDD4_13701 METAL5_398000_2553000 METAL5_398000_2565000 0.048
R_VDD4_13702 METAL5_398000_2565000 METAL5_398000_2577000 0.048
R_VDD4_13703 METAL5_398000_2577000 METAL5_398000_2617000 0.16
R_VDD4_13704 METAL5_398000_2617000 METAL5_398000_2629000 0.048
R_VDD4_13705 METAL5_398000_2629000 METAL5_398000_2641000 0.048
R_VDD4_13706 METAL5_398000_2641000 METAL5_398000_2653000 0.048
R_VDD4_13707 METAL5_398000_2653000 METAL5_398000_2665000 0.048
R_VDD4_13708 METAL5_398000_2665000 METAL5_398000_2677000 0.048
R_VDD4_13709 METAL5_398000_2677000 METAL5_400000_2677000 0.008
R_VDD4_13710 METAL5_400000_2677000 METAL5_402000_2677000 0.008
R_VDD4_13711 METAL5_402000_2677000 METAL5_410000_2677000 0.032
R_VDD4_13712 METAL5_410000_2677000 METAL5_412000_2677000 0.008
R_VDD4_13713 METAL5_412000_2677000 METAL5_414000_2677000 0.008
R_VDD4_13714 METAL5_414000_2677000 METAL5_422000_2677000 0.032
R_VDD4_13715 METAL5_422000_2677000 METAL5_424000_2677000 0.008
R_VDD4_13716 METAL5_424000_2677000 METAL5_426000_2677000 0.008
R_VDD4_13717 METAL5_426000_2677000 METAL5_434000_2677000 0.032
R_VDD4_13718 METAL5_434000_2677000 METAL5_436000_2677000 0.008
R_VDD4_13719 METAL5_436000_2677000 METAL5_438000_2677000 0.008
R_VDD4_13720 METAL5_438000_2677000 METAL5_448000_2677000 0.04
R_VDD4_13721 METAL5_448000_2677000 METAL5_450000_2677000 0.008
R_VDD4_13722 METAL5_450000_2677000 METAL5_452000_2677000 0.008
R_VDD4_13723 METAL5_452000_2677000 METAL5_460000_2677000 0.032
R_VDD4_13724 METAL5_460000_2677000 METAL6_460000_2677000 0.1
R_VDD4_13725 METAL6_460000_2677000 METAL6_460000_2793000 0.232
R_VDD4_13726 METAL6_460000_2793000 METAL6_460000_2807000 0.028
R_VDD4_13727 METAL6_460000_2807000 METAL6_460000_2953000 0.292
R_VDD4_13728 METAL6_460000_2953000 METAL6_460000_2965000 0.024
R_VDD4_13729 METAL6_460000_2965000 METAL6_460000_2977000 0.024
R_VDD4_13730 METAL6_460000_2977000 METAL6_460000_3053000 0.152
R_VDD4_13731 METAL6_460000_3053000 METAL6_460000_3065000 0.024
R_VDD4_13732 METAL6_460000_3065000 METAL6_460000_3077000 0.024
R_VDD4_13733 METAL6_460000_3077000 METAL6_460000_3153000 0.152
R_VDD4_13734 METAL6_460000_3153000 METAL6_460000_3165000 0.024
R_VDD4_13735 METAL6_460000_3165000 METAL6_460000_3177000 0.024
R_VDD4_13736 METAL6_460000_3177000 METAL6_460000_3253000 0.152
R_VDD4_13737 METAL6_460000_3253000 METAL6_460000_3265000 0.024
R_VDD4_13738 METAL6_460000_3265000 METAL6_460000_3277000 0.024
R_VDD4_13739 METAL6_460000_3277000 METAL6_460000_3341000 0.128
R_VDD4_13740 METAL6_460000_3341000 METAL6_460000_3353000 0.024
R_VDD4_13741 METAL6_460000_3353000 METAL5_460000_3353000 0.1
R_VDD4_13742 METAL5_460000_3353000 METAL5_452000_3353000 0.032
R_VDD4_13743 METAL5_452000_3353000 METAL5_452000_3365000 0.048
R_VDD4_13744 METAL5_452000_3365000 METAL5_452000_3377000 0.048
R_VDD4_13745 METAL5_452000_3377000 METAL6_452000_3377000 0.1
R_VDD4_13746 METAL6_452000_3377000 METAL6_452000_3493000 0.232
R_VDD4_13747 METAL6_452000_3493000 METAL6_452000_3507000 0.028
R_VDD4_13748 METAL6_452000_3507000 METAL6_452000_3653000 0.292
R_VDD4_13749 METAL6_452000_3653000 METAL6_452000_3665000 0.024
R_VDD4_13750 METAL6_452000_3665000 METAL6_452000_3677000 0.024
R_VDD4_13751 METAL6_452000_3677000 METAL6_452000_3753000 0.152
R_VDD4_13752 METAL6_452000_3753000 METAL6_452000_3765000 0.024
R_VDD4_13753 METAL6_452000_3765000 METAL6_452000_3777000 0.024
R_VDD4_13754 METAL6_452000_3777000 METAL6_452000_3853000 0.152
R_VDD4_13755 METAL6_452000_3853000 METAL6_452000_3865000 0.024
R_VDD4_13756 METAL6_452000_3865000 METAL6_452000_3877000 0.024
R_VDD4_13757 METAL6_452000_3877000 METAL6_452000_3953000 0.152
R_VDD4_13758 METAL6_452000_3953000 METAL6_452000_3965000 0.024
R_VDD4_13759 METAL6_452000_3965000 METAL6_452000_3977000 0.024
R_VDD4_13760 METAL6_452000_3977000 METAL6_452000_4053000 0.152
R_VDD4_13761 METAL6_452000_4053000 METAL5_452000_4053000 0.1
R_VDD4_13762 METAL5_452000_4053000 METAL5_452000_4065000 0.048
R_VDD4_13763 METAL5_452000_4065000 METAL5_452000_4077000 0.048
R_VDD4_13764 METAL5_452000_4077000 METAL6_452000_4077000 0.1
R_VDD4_13765 METAL6_452000_4077000 METAL6_452000_4193000 0.232
R_VDD4_13766 METAL6_452000_4193000 METAL6_452000_4207000 0.028
R_VDD4_13767 METAL6_452000_4207000 METAL6_452000_4353000 0.292
R_VDD4_13768 METAL6_452000_4353000 METAL6_452000_4365000 0.024
R_VDD4_13769 METAL6_452000_4365000 METAL6_452000_4377000 0.024
R_VDD4_13770 METAL6_452000_4377000 METAL6_452000_4453000 0.152
R_VDD4_13771 METAL6_452000_4453000 METAL6_452000_4465000 0.024
R_VDD4_13772 METAL6_452000_4465000 METAL6_452000_4477000 0.024
R_VDD4_13773 METAL6_452000_4477000 METAL6_452000_4553000 0.152
R_VDD4_13774 METAL6_452000_4553000 METAL6_452000_4565000 0.024
R_VDD4_13775 METAL6_452000_4565000 METAL6_452000_4577000 0.024
R_VDD4_13776 METAL6_452000_4577000 METAL6_452000_4653000 0.152
R_VDD4_13777 METAL6_452000_4653000 METAL6_452000_4665000 0.024
R_VDD4_13778 METAL6_452000_4665000 METAL6_460000_4665000 0.016
R_VDD4_13779 METAL6_460000_4665000 METAL6_462000_4665000 0.004
R_VDD4_13780 METAL6_462000_4665000 METAL6_464000_4665000 0.004
R_VDD4_13781 METAL6_464000_4665000 METAL5_464000_4665000 0.1
R_VDD4_13782 METAL5_464000_4665000 METAL5_472000_4665000 0.032
R_VDD4_13783 METAL5_472000_4665000 METAL5_474000_4665000 0.008
R_VDD4_13784 METAL5_474000_4665000 METAL5_476000_4665000 0.008
R_VDD4_13785 METAL5_476000_4665000 METAL5_484000_4665000 0.032
R_VDD4_13786 METAL5_484000_4665000 METAL5_486000_4665000 0.008
R_VDD4_13787 METAL5_486000_4665000 METAL5_488000_4665000 0.008
R_VDD4_13788 METAL5_488000_4665000 METAL5_500000_4665000 0.048
R_VDD4_13789 METAL5_500000_4665000 METAL5_507000_4665000 0.028
R_VDD4_13790 METAL5_507000_4665000 METAL5_512000_4665000 0.02
R_VDD4_13791 METAL5_512000_4665000 METAL5_519000_4665000 0.028
R_VDD4_13792 METAL5_519000_4665000 METAL5_524000_4665000 0.02
R_VDD4_13793 METAL5_524000_4665000 METAL5_531000_4665000 0.028
R_VDD4_13794 METAL5_531000_4665000 METAL5_543000_4665000 0.048
R_VDD4_13795 METAL5_543000_4665000 METAL6_543000_4665000 0.1
R_VDD4_13796 METAL6_245000_3965000 METAL6_257000_3965000 0.024
R_VDD4_13797 METAL6_386000_2353000 METAL5_386000_2353000 0.1
R_VDD4_13798 METAL5_386000_2353000 METAL5_386000_2365000 0.048
R_VDD4_13799 METAL5_386000_2365000 METAL5_386000_2377000 0.048
R_VDD4_13800 METAL5_386000_2377000 METAL5_386000_2453000 0.304
R_VDD4_13801 METAL5_386000_2453000 METAL5_386000_2465000 0.048
R_VDD4_13802 METAL5_386000_2465000 METAL5_386000_2477000 0.048
R_VDD4_13803 METAL5_386000_2477000 METAL5_386000_2553000 0.304
R_VDD4_13804 METAL5_386000_2553000 METAL5_386000_2565000 0.048
R_VDD4_13805 METAL5_386000_2565000 METAL5_386000_2577000 0.048
R_VDD4_13806 METAL5_386000_2577000 METAL5_386000_2617000 0.16
R_VDD4_13807 METAL5_386000_2617000 METAL5_386000_2629000 0.048
R_VDD4_13808 METAL5_386000_2629000 METAL5_386000_2641000 0.048
R_VDD4_13809 METAL5_386000_2641000 METAL5_386000_2653000 0.048
R_VDD4_13810 METAL5_386000_2653000 METAL5_386000_2665000 0.048
R_VDD4_13811 METAL5_386000_2665000 METAL5_378000_2665000 0.032
R_VDD4_13812 METAL5_378000_2665000 METAL5_376000_2665000 0.008
R_VDD4_13813 METAL5_376000_2665000 METAL5_374000_2665000 0.008
R_VDD4_13814 METAL5_374000_2665000 METAL5_366000_2665000 0.032
R_VDD4_13815 METAL5_366000_2665000 METAL5_364000_2665000 0.008
R_VDD4_13816 METAL5_364000_2665000 METAL5_362000_2665000 0.008
R_VDD4_13817 METAL5_362000_2665000 METAL5_354000_2665000 0.032
R_VDD4_13818 METAL5_354000_2665000 METAL5_352000_2665000 0.008
R_VDD4_13819 METAL5_352000_2665000 METAL5_350000_2665000 0.008
R_VDD4_13820 METAL5_350000_2665000 METAL5_348000_2665000 0.008
R_VDD4_13821 METAL5_348000_2665000 METAL5_340000_2665000 0.032
R_VDD4_13822 METAL5_340000_2665000 METAL5_338000_2665000 0.008
R_VDD4_13823 METAL5_338000_2665000 METAL5_336000_2665000 0.008
R_VDD4_13824 METAL5_336000_2665000 METAL5_328000_2665000 0.032
R_VDD4_13825 METAL5_328000_2665000 METAL5_326000_2665000 0.008
R_VDD4_13826 METAL5_326000_2665000 METAL6_326000_2665000 0.1
R_VDD4_13827 METAL6_326000_2665000 METAL6_326000_2677000 0.024
R_VDD4_13828 METAL6_326000_2677000 METAL6_326000_2689000 0.024
R_VDD4_13829 METAL6_326000_2689000 METAL6_326000_2793000 0.208
R_VDD4_13830 METAL6_326000_2793000 METAL6_326000_2807000 0.028
R_VDD4_13831 METAL6_326000_2807000 METAL6_326000_2953000 0.292
R_VDD4_13832 METAL6_326000_2953000 METAL6_326000_2965000 0.024
R_VDD4_13833 METAL6_326000_2965000 METAL6_326000_2977000 0.024
R_VDD4_13834 METAL6_326000_2977000 METAL6_326000_3053000 0.152
R_VDD4_13835 METAL6_326000_3053000 METAL6_326000_3065000 0.024
R_VDD4_13836 METAL6_326000_3065000 METAL6_326000_3077000 0.024
R_VDD4_13837 METAL6_326000_3077000 METAL6_326000_3153000 0.152
R_VDD4_13838 METAL6_326000_3153000 METAL6_326000_3165000 0.024
R_VDD4_13839 METAL6_326000_3165000 METAL6_326000_3177000 0.024
R_VDD4_13840 METAL6_326000_3177000 METAL6_326000_3253000 0.152
R_VDD4_13841 METAL6_326000_3253000 METAL6_326000_3265000 0.024
R_VDD4_13842 METAL6_326000_3265000 METAL6_326000_3277000 0.024
R_VDD4_13843 METAL6_326000_3277000 METAL6_326000_3341000 0.128
R_VDD4_13844 METAL6_326000_3341000 METAL6_326000_3353000 0.024
R_VDD4_13845 METAL6_326000_3353000 METAL6_326000_3365000 0.024
R_VDD4_13846 METAL6_326000_3365000 METAL6_326000_3377000 0.024
R_VDD4_13847 METAL6_326000_3377000 METAL6_326000_3389000 0.024
R_VDD4_13848 METAL6_326000_3389000 METAL6_326000_3493000 0.208
R_VDD4_13849 METAL6_326000_3493000 METAL6_326000_3507000 0.028
R_VDD4_13850 METAL6_326000_3507000 METAL6_326000_3653000 0.292
R_VDD4_13851 METAL6_326000_3653000 METAL6_326000_3665000 0.024
R_VDD4_13852 METAL6_326000_3665000 METAL6_326000_3677000 0.024
R_VDD4_13853 METAL6_326000_3677000 METAL6_326000_3753000 0.152
R_VDD4_13854 METAL6_326000_3753000 METAL6_326000_3765000 0.024
R_VDD4_13855 METAL6_326000_3765000 METAL6_326000_3777000 0.024
R_VDD4_13856 METAL6_326000_3777000 METAL6_326000_3853000 0.152
R_VDD4_13857 METAL6_326000_3853000 METAL6_326000_3865000 0.024
R_VDD4_13858 METAL6_326000_3865000 METAL6_326000_3877000 0.024
R_VDD4_13859 METAL6_326000_3877000 METAL6_326000_3953000 0.152
R_VDD4_13860 METAL6_326000_3953000 METAL6_326000_3965000 0.024
R_VDD4_13861 METAL6_326000_3965000 METAL6_324000_3965000 0.004
R_VDD4_13862 METAL6_324000_3965000 METAL6_314000_3965000 0.02
R_VDD4_13863 METAL6_314000_3965000 METAL6_312000_3965000 0.004
R_VDD4_13864 METAL6_312000_3965000 METAL5_312000_3965000 0.1
R_VDD4_13865 METAL5_312000_3965000 METAL5_302000_3965000 0.04
R_VDD4_13866 METAL5_302000_3965000 METAL5_300000_3965000 0.008
R_VDD4_13867 METAL5_300000_3965000 METAL5_293000_3965000 0.028
R_VDD4_13868 METAL5_293000_3965000 METAL5_288000_3965000 0.02
R_VDD4_13869 METAL5_288000_3965000 METAL5_281000_3965000 0.028
R_VDD4_13870 METAL5_281000_3965000 METAL5_276000_3965000 0.02
R_VDD4_13871 METAL5_276000_3965000 METAL5_269000_3965000 0.028
R_VDD4_13872 METAL5_269000_3965000 METAL5_264000_3965000 0.02
R_VDD4_13873 METAL5_264000_3965000 METAL5_257000_3965000 0.028
R_VDD4_13874 METAL5_257000_3965000 METAL6_257000_3965000 0.1
R_VDD4_13875 METAL6_555000_3965000 METAL6_543000_3965000 0.024
R_VDD4_13876 METAL6_410000_2977000 METAL5_410000_2977000 0.1
R_VDD4_13877 METAL5_410000_2977000 METAL5_410000_3053000 0.304
R_VDD4_13878 METAL5_410000_3053000 METAL5_410000_3065000 0.048
R_VDD4_13879 METAL5_410000_3065000 METAL5_410000_3077000 0.048
R_VDD4_13880 METAL5_410000_3077000 METAL5_410000_3153000 0.304
R_VDD4_13881 METAL5_410000_3153000 METAL5_410000_3165000 0.048
R_VDD4_13882 METAL5_410000_3165000 METAL5_410000_3177000 0.048
R_VDD4_13883 METAL5_410000_3177000 METAL5_410000_3253000 0.304
R_VDD4_13884 METAL5_410000_3253000 METAL5_410000_3265000 0.048
R_VDD4_13885 METAL5_410000_3265000 METAL5_410000_3277000 0.048
R_VDD4_13886 METAL5_410000_3277000 METAL5_410000_3341000 0.256
R_VDD4_13887 METAL5_410000_3341000 METAL5_410000_3353000 0.048
R_VDD4_13888 METAL5_410000_3353000 METAL5_410000_3365000 0.048
R_VDD4_13889 METAL5_410000_3365000 METAL5_410000_3377000 0.048
R_VDD4_13890 METAL5_410000_3377000 METAL5_410000_3389000 0.048
R_VDD4_13891 METAL5_410000_3389000 METAL5_412000_3389000 0.008
R_VDD4_13892 METAL5_412000_3389000 METAL5_414000_3389000 0.008
R_VDD4_13893 METAL5_414000_3389000 METAL5_422000_3389000 0.032
R_VDD4_13894 METAL5_422000_3389000 METAL5_424000_3389000 0.008
R_VDD4_13895 METAL5_424000_3389000 METAL5_426000_3389000 0.008
R_VDD4_13896 METAL5_426000_3389000 METAL5_434000_3389000 0.032
R_VDD4_13897 METAL5_434000_3389000 METAL5_436000_3389000 0.008
R_VDD4_13898 METAL5_436000_3389000 METAL5_438000_3389000 0.008
R_VDD4_13899 METAL5_438000_3389000 METAL5_440000_3389000 0.008
R_VDD4_13900 METAL5_440000_3389000 METAL5_448000_3389000 0.032
R_VDD4_13901 METAL5_448000_3389000 METAL5_450000_3389000 0.008
R_VDD4_13902 METAL5_450000_3389000 METAL5_452000_3389000 0.008
R_VDD4_13903 METAL5_452000_3389000 METAL5_460000_3389000 0.032
R_VDD4_13904 METAL5_460000_3389000 METAL5_462000_3389000 0.008
R_VDD4_13905 METAL5_462000_3389000 METAL5_464000_3389000 0.008
R_VDD4_13906 METAL5_464000_3389000 METAL6_464000_3389000 0.1
R_VDD4_13907 METAL6_464000_3389000 METAL6_464000_3493000 0.208
R_VDD4_13908 METAL6_464000_3493000 METAL6_464000_3507000 0.028
R_VDD4_13909 METAL6_464000_3507000 METAL6_464000_3653000 0.292
R_VDD4_13910 METAL6_464000_3653000 METAL6_464000_3665000 0.024
R_VDD4_13911 METAL6_464000_3665000 METAL6_464000_3677000 0.024
R_VDD4_13912 METAL6_464000_3677000 METAL6_464000_3753000 0.152
R_VDD4_13913 METAL6_464000_3753000 METAL6_464000_3765000 0.024
R_VDD4_13914 METAL6_464000_3765000 METAL6_464000_3777000 0.024
R_VDD4_13915 METAL6_464000_3777000 METAL6_464000_3853000 0.152
R_VDD4_13916 METAL6_464000_3853000 METAL6_464000_3865000 0.024
R_VDD4_13917 METAL6_464000_3865000 METAL6_464000_3877000 0.024
R_VDD4_13918 METAL6_464000_3877000 METAL6_464000_3953000 0.152
R_VDD4_13919 METAL6_464000_3953000 METAL5_464000_3953000 0.1
R_VDD4_13920 METAL5_464000_3953000 METAL5_472000_3953000 0.032
R_VDD4_13921 METAL5_472000_3953000 METAL5_474000_3953000 0.008
R_VDD4_13922 METAL5_474000_3953000 METAL5_476000_3953000 0.008
R_VDD4_13923 METAL5_476000_3953000 METAL5_484000_3953000 0.032
R_VDD4_13924 METAL5_484000_3953000 METAL5_486000_3953000 0.008
R_VDD4_13925 METAL5_486000_3953000 METAL5_488000_3953000 0.008
R_VDD4_13926 METAL5_488000_3953000 METAL5_500000_3953000 0.048
R_VDD4_13927 METAL5_500000_3953000 METAL5_507000_3953000 0.028
R_VDD4_13928 METAL5_507000_3953000 METAL5_512000_3953000 0.02
R_VDD4_13929 METAL5_512000_3953000 METAL5_519000_3953000 0.028
R_VDD4_13930 METAL5_519000_3953000 METAL5_524000_3953000 0.02
R_VDD4_13931 METAL5_524000_3953000 METAL5_531000_3953000 0.028
R_VDD4_13932 METAL5_531000_3953000 METAL5_543000_3953000 0.048
R_VDD4_13933 METAL5_543000_3953000 METAL6_543000_3953000 0.1
R_VDD4_13934 METAL6_543000_3953000 METAL6_543000_3965000 0.024
R_VDD4_13935 METAL6_245000_3265000 METAL6_257000_3265000 0.024
R_VDD4_13936 METAL6_398000_2793000 METAL5_398000_2793000 0.1
R_VDD4_13937 METAL5_398000_2793000 METAL5_390000_2793000 0.032
R_VDD4_13938 METAL5_390000_2793000 METAL5_388000_2793000 0.008
R_VDD4_13939 METAL5_388000_2793000 METAL5_386000_2793000 0.008
R_VDD4_13940 METAL5_386000_2793000 METAL5_378000_2793000 0.032
R_VDD4_13941 METAL5_378000_2793000 METAL5_376000_2793000 0.008
R_VDD4_13942 METAL5_376000_2793000 METAL5_374000_2793000 0.008
R_VDD4_13943 METAL5_374000_2793000 METAL5_366000_2793000 0.032
R_VDD4_13944 METAL5_366000_2793000 METAL5_364000_2793000 0.008
R_VDD4_13945 METAL5_364000_2793000 METAL5_362000_2793000 0.008
R_VDD4_13946 METAL5_362000_2793000 METAL5_354000_2793000 0.032
R_VDD4_13947 METAL5_354000_2793000 METAL5_352000_2793000 0.008
R_VDD4_13948 METAL5_352000_2793000 METAL5_350000_2793000 0.008
R_VDD4_13949 METAL5_350000_2793000 METAL5_348000_2793000 0.008
R_VDD4_13950 METAL5_348000_2793000 METAL5_340000_2793000 0.032
R_VDD4_13951 METAL5_340000_2793000 METAL5_338000_2793000 0.008
R_VDD4_13952 METAL5_338000_2793000 METAL5_336000_2793000 0.008
R_VDD4_13953 METAL5_336000_2793000 METAL5_328000_2793000 0.032
R_VDD4_13954 METAL5_328000_2793000 METAL5_326000_2793000 0.008
R_VDD4_13955 METAL5_326000_2793000 METAL5_324000_2793000 0.008
R_VDD4_13956 METAL5_324000_2793000 METAL5_314000_2793000 0.04
R_VDD4_13957 METAL5_314000_2793000 METAL5_312000_2793000 0.008
R_VDD4_13958 METAL5_312000_2793000 METAL5_302000_2793000 0.04
R_VDD4_13959 METAL5_302000_2793000 METAL5_300000_2793000 0.008
R_VDD4_13960 METAL5_300000_2793000 METAL5_293000_2793000 0.028
R_VDD4_13961 METAL5_293000_2793000 METAL5_288000_2793000 0.02
R_VDD4_13962 METAL5_288000_2793000 METAL5_281000_2793000 0.028
R_VDD4_13963 METAL5_281000_2793000 METAL5_276000_2793000 0.02
R_VDD4_13964 METAL5_276000_2793000 METAL5_269000_2793000 0.028
R_VDD4_13965 METAL5_269000_2793000 METAL5_264000_2793000 0.02
R_VDD4_13966 METAL5_264000_2793000 METAL5_257000_2793000 0.028
R_VDD4_13967 METAL5_257000_2793000 METAL6_257000_2793000 0.1
R_VDD4_13968 METAL6_257000_2793000 METAL6_257000_2807000 0.028
R_VDD4_13969 METAL6_257000_2807000 METAL6_257000_2953000 0.292
R_VDD4_13970 METAL6_257000_2953000 METAL5_257000_2953000 0.1
R_VDD4_13971 METAL5_257000_2953000 METAL5_264000_2953000 0.028
R_VDD4_13972 METAL5_264000_2953000 METAL5_269000_2953000 0.02
R_VDD4_13973 METAL5_269000_2953000 METAL5_269000_2965000 0.048
R_VDD4_13974 METAL5_269000_2965000 METAL5_269000_2977000 0.048
R_VDD4_13975 METAL5_269000_2977000 METAL5_269000_2989000 0.048
R_VDD4_13976 METAL5_269000_2989000 METAL5_269000_3053000 0.256
R_VDD4_13977 METAL5_269000_3053000 METAL5_269000_3065000 0.048
R_VDD4_13978 METAL5_269000_3065000 METAL5_269000_3077000 0.048
R_VDD4_13979 METAL5_269000_3077000 METAL5_269000_3153000 0.304
R_VDD4_13980 METAL5_269000_3153000 METAL5_269000_3165000 0.048
R_VDD4_13981 METAL5_269000_3165000 METAL5_269000_3177000 0.048
R_VDD4_13982 METAL5_269000_3177000 METAL5_264000_3177000 0.02
R_VDD4_13983 METAL5_264000_3177000 METAL5_257000_3177000 0.028
R_VDD4_13984 METAL5_257000_3177000 METAL6_257000_3177000 0.1
R_VDD4_13985 METAL6_257000_3177000 METAL6_257000_3253000 0.152
R_VDD4_13986 METAL6_257000_3253000 METAL6_257000_3265000 0.024
R_VDD4_13987 METAL6_555000_3265000 METAL6_543000_3265000 0.024
R_VDD4_13988 METAL6_374000_2677000 METAL5_374000_2677000 0.1
R_VDD4_13989 METAL5_374000_2677000 METAL5_374000_2689000 0.048
R_VDD4_13990 METAL5_374000_2689000 METAL5_376000_2689000 0.008
R_VDD4_13991 METAL5_376000_2689000 METAL5_378000_2689000 0.008
R_VDD4_13992 METAL5_378000_2689000 METAL5_386000_2689000 0.032
R_VDD4_13993 METAL5_386000_2689000 METAL5_388000_2689000 0.008
R_VDD4_13994 METAL5_388000_2689000 METAL5_390000_2689000 0.008
R_VDD4_13995 METAL5_390000_2689000 METAL5_398000_2689000 0.032
R_VDD4_13996 METAL5_398000_2689000 METAL5_400000_2689000 0.008
R_VDD4_13997 METAL5_400000_2689000 METAL5_402000_2689000 0.008
R_VDD4_13998 METAL5_402000_2689000 METAL5_410000_2689000 0.032
R_VDD4_13999 METAL5_410000_2689000 METAL5_412000_2689000 0.008
R_VDD4_14000 METAL5_412000_2689000 METAL5_414000_2689000 0.008
R_VDD4_14001 METAL5_414000_2689000 METAL5_422000_2689000 0.032
R_VDD4_14002 METAL5_422000_2689000 METAL5_424000_2689000 0.008
R_VDD4_14003 METAL5_424000_2689000 METAL5_426000_2689000 0.008
R_VDD4_14004 METAL5_426000_2689000 METAL5_434000_2689000 0.032
R_VDD4_14005 METAL5_434000_2689000 METAL5_436000_2689000 0.008
R_VDD4_14006 METAL5_436000_2689000 METAL5_438000_2689000 0.008
R_VDD4_14007 METAL5_438000_2689000 METAL5_440000_2689000 0.008
R_VDD4_14008 METAL5_440000_2689000 METAL5_448000_2689000 0.032
R_VDD4_14009 METAL5_448000_2689000 METAL5_450000_2689000 0.008
R_VDD4_14010 METAL5_450000_2689000 METAL5_452000_2689000 0.008
R_VDD4_14011 METAL5_452000_2689000 METAL5_460000_2689000 0.032
R_VDD4_14012 METAL5_460000_2689000 METAL5_462000_2689000 0.008
R_VDD4_14013 METAL5_462000_2689000 METAL5_464000_2689000 0.008
R_VDD4_14014 METAL5_464000_2689000 METAL5_472000_2689000 0.032
R_VDD4_14015 METAL5_472000_2689000 METAL5_474000_2689000 0.008
R_VDD4_14016 METAL5_474000_2689000 METAL5_476000_2689000 0.008
R_VDD4_14017 METAL5_476000_2689000 METAL5_484000_2689000 0.032
R_VDD4_14018 METAL5_484000_2689000 METAL5_486000_2689000 0.008
R_VDD4_14019 METAL5_486000_2689000 METAL5_488000_2689000 0.008
R_VDD4_14020 METAL5_488000_2689000 METAL5_500000_2689000 0.048
R_VDD4_14021 METAL5_500000_2689000 METAL5_507000_2689000 0.028
R_VDD4_14022 METAL5_507000_2689000 METAL5_512000_2689000 0.02
R_VDD4_14023 METAL5_512000_2689000 METAL5_519000_2689000 0.028
R_VDD4_14024 METAL5_519000_2689000 METAL5_524000_2689000 0.02
R_VDD4_14025 METAL5_524000_2689000 METAL5_531000_2689000 0.028
R_VDD4_14026 METAL5_531000_2689000 METAL5_543000_2689000 0.048
R_VDD4_14027 METAL5_543000_2689000 METAL6_543000_2689000 0.1
R_VDD4_14028 METAL6_543000_2689000 METAL6_543000_2781000 0.184
R_VDD4_14029 METAL6_543000_2781000 METAL6_543000_2793000 0.024
R_VDD4_14030 METAL6_543000_2793000 METAL6_543000_2805000 0.024
R_VDD4_14031 METAL6_543000_2805000 METAL6_543000_2807000 0.004
R_VDD4_14032 METAL6_543000_2807000 METAL6_543000_2941000 0.268
R_VDD4_14033 METAL6_543000_2941000 METAL6_543000_2953000 0.024
R_VDD4_14034 METAL6_543000_2953000 METAL5_543000_2953000 0.1
R_VDD4_14035 METAL5_543000_2953000 METAL5_531000_2953000 0.048
R_VDD4_14036 METAL5_531000_2953000 METAL5_531000_2965000 0.048
R_VDD4_14037 METAL5_531000_2965000 METAL5_531000_2977000 0.048
R_VDD4_14038 METAL5_531000_2977000 METAL5_531000_2989000 0.048
R_VDD4_14039 METAL5_531000_2989000 METAL5_531000_3053000 0.256
R_VDD4_14040 METAL5_531000_3053000 METAL5_531000_3065000 0.048
R_VDD4_14041 METAL5_531000_3065000 METAL5_531000_3077000 0.048
R_VDD4_14042 METAL5_531000_3077000 METAL5_531000_3153000 0.304
R_VDD4_14043 METAL5_531000_3153000 METAL5_531000_3165000 0.048
R_VDD4_14044 METAL5_531000_3165000 METAL5_531000_3177000 0.048
R_VDD4_14045 METAL5_531000_3177000 METAL5_543000_3177000 0.048
R_VDD4_14046 METAL5_543000_3177000 METAL6_543000_3177000 0.1
R_VDD4_14047 METAL6_543000_3177000 METAL6_543000_3189000 0.024
R_VDD4_14048 METAL6_543000_3189000 METAL6_543000_3253000 0.128
R_VDD4_14049 METAL6_543000_3253000 METAL6_543000_3265000 0.024
R_VDD4_14050 METAL6_245000_2565000 METAL6_257000_2565000 0.024
R_VDD4_14051 METAL6_362000_1977000 METAL5_362000_1977000 0.1
R_VDD4_14052 METAL5_362000_1977000 METAL5_354000_1977000 0.032
R_VDD4_14053 METAL5_354000_1977000 METAL5_352000_1977000 0.008
R_VDD4_14054 METAL5_352000_1977000 METAL5_350000_1977000 0.008
R_VDD4_14055 METAL5_350000_1977000 METAL5_348000_1977000 0.008
R_VDD4_14056 METAL5_348000_1977000 METAL5_340000_1977000 0.032
R_VDD4_14057 METAL5_340000_1977000 METAL5_338000_1977000 0.008
R_VDD4_14058 METAL5_338000_1977000 METAL5_336000_1977000 0.008
R_VDD4_14059 METAL5_336000_1977000 METAL5_328000_1977000 0.032
R_VDD4_14060 METAL5_328000_1977000 METAL5_326000_1977000 0.008
R_VDD4_14061 METAL5_326000_1977000 METAL5_324000_1977000 0.008
R_VDD4_14062 METAL5_324000_1977000 METAL5_314000_1977000 0.04
R_VDD4_14063 METAL5_314000_1977000 METAL5_312000_1977000 0.008
R_VDD4_14064 METAL5_312000_1977000 METAL5_302000_1977000 0.04
R_VDD4_14065 METAL5_302000_1977000 METAL5_300000_1977000 0.008
R_VDD4_14066 METAL5_300000_1977000 METAL5_293000_1977000 0.028
R_VDD4_14067 METAL5_293000_1977000 METAL5_288000_1977000 0.02
R_VDD4_14068 METAL5_288000_1977000 METAL5_281000_1977000 0.028
R_VDD4_14069 METAL5_281000_1977000 METAL5_276000_1977000 0.02
R_VDD4_14070 METAL5_276000_1977000 METAL5_269000_1977000 0.028
R_VDD4_14071 METAL5_269000_1977000 METAL5_264000_1977000 0.02
R_VDD4_14072 METAL5_264000_1977000 METAL5_257000_1977000 0.028
R_VDD4_14073 METAL5_257000_1977000 METAL6_257000_1977000 0.1
R_VDD4_14074 METAL6_257000_1977000 METAL6_257000_2093000 0.232
R_VDD4_14075 METAL6_257000_2093000 METAL6_257000_2107000 0.028
R_VDD4_14076 METAL6_257000_2107000 METAL6_257000_2229000 0.244
R_VDD4_14077 METAL6_257000_2229000 METAL6_257000_2241000 0.024
R_VDD4_14078 METAL6_257000_2241000 METAL6_257000_2253000 0.024
R_VDD4_14079 METAL6_257000_2253000 METAL5_257000_2253000 0.1
R_VDD4_14080 METAL5_257000_2253000 METAL5_264000_2253000 0.028
R_VDD4_14081 METAL5_264000_2253000 METAL5_269000_2253000 0.02
R_VDD4_14082 METAL5_269000_2253000 METAL5_269000_2265000 0.048
R_VDD4_14083 METAL5_269000_2265000 METAL5_269000_2277000 0.048
R_VDD4_14084 METAL5_269000_2277000 METAL5_269000_2341000 0.256
R_VDD4_14085 METAL5_269000_2341000 METAL5_269000_2353000 0.048
R_VDD4_14086 METAL5_269000_2353000 METAL5_269000_2365000 0.048
R_VDD4_14087 METAL5_269000_2365000 METAL5_269000_2377000 0.048
R_VDD4_14088 METAL5_269000_2377000 METAL5_269000_2453000 0.304
R_VDD4_14089 METAL5_269000_2453000 METAL5_269000_2465000 0.048
R_VDD4_14090 METAL5_269000_2465000 METAL5_269000_2477000 0.048
R_VDD4_14091 METAL5_269000_2477000 METAL5_264000_2477000 0.02
R_VDD4_14092 METAL5_264000_2477000 METAL5_257000_2477000 0.028
R_VDD4_14093 METAL5_257000_2477000 METAL6_257000_2477000 0.1
R_VDD4_14094 METAL6_257000_2477000 METAL6_257000_2553000 0.152
R_VDD4_14095 METAL6_257000_2553000 METAL6_257000_2565000 0.024
R_VDD4_14096 METAL6_555000_2565000 METAL6_543000_2565000 0.024
R_VDD4_14097 METAL6_410000_1977000 METAL5_410000_1977000 0.1
R_VDD4_14098 METAL5_410000_1977000 METAL5_412000_1977000 0.008
R_VDD4_14099 METAL5_412000_1977000 METAL5_414000_1977000 0.008
R_VDD4_14100 METAL5_414000_1977000 METAL5_422000_1977000 0.032
R_VDD4_14101 METAL5_422000_1977000 METAL5_424000_1977000 0.008
R_VDD4_14102 METAL5_424000_1977000 METAL5_426000_1977000 0.008
R_VDD4_14103 METAL5_426000_1977000 METAL5_434000_1977000 0.032
R_VDD4_14104 METAL5_434000_1977000 METAL5_436000_1977000 0.008
R_VDD4_14105 METAL5_436000_1977000 METAL5_438000_1977000 0.008
R_VDD4_14106 METAL5_438000_1977000 METAL5_440000_1977000 0.008
R_VDD4_14107 METAL5_440000_1977000 METAL5_448000_1977000 0.032
R_VDD4_14108 METAL5_448000_1977000 METAL5_450000_1977000 0.008
R_VDD4_14109 METAL5_450000_1977000 METAL5_452000_1977000 0.008
R_VDD4_14110 METAL5_452000_1977000 METAL5_460000_1977000 0.032
R_VDD4_14111 METAL5_460000_1977000 METAL5_462000_1977000 0.008
R_VDD4_14112 METAL5_462000_1977000 METAL5_464000_1977000 0.008
R_VDD4_14113 METAL5_464000_1977000 METAL5_472000_1977000 0.032
R_VDD4_14114 METAL5_472000_1977000 METAL5_474000_1977000 0.008
R_VDD4_14115 METAL5_474000_1977000 METAL5_476000_1977000 0.008
R_VDD4_14116 METAL5_476000_1977000 METAL5_484000_1977000 0.032
R_VDD4_14117 METAL5_484000_1977000 METAL5_486000_1977000 0.008
R_VDD4_14118 METAL5_486000_1977000 METAL5_488000_1977000 0.008
R_VDD4_14119 METAL5_488000_1977000 METAL5_500000_1977000 0.048
R_VDD4_14120 METAL5_500000_1977000 METAL5_507000_1977000 0.028
R_VDD4_14121 METAL5_507000_1977000 METAL5_512000_1977000 0.02
R_VDD4_14122 METAL5_512000_1977000 METAL5_519000_1977000 0.028
R_VDD4_14123 METAL5_519000_1977000 METAL5_524000_1977000 0.02
R_VDD4_14124 METAL5_524000_1977000 METAL5_531000_1977000 0.028
R_VDD4_14125 METAL5_531000_1977000 METAL5_543000_1977000 0.048
R_VDD4_14126 METAL5_543000_1977000 METAL6_543000_1977000 0.1
R_VDD4_14127 METAL6_543000_1977000 METAL6_543000_1989000 0.024
R_VDD4_14128 METAL6_543000_1989000 METAL6_543000_2093000 0.208
R_VDD4_14129 METAL6_543000_2093000 METAL6_543000_2107000 0.028
R_VDD4_14130 METAL6_543000_2107000 METAL6_543000_2229000 0.244
R_VDD4_14131 METAL6_543000_2229000 METAL6_543000_2241000 0.024
R_VDD4_14132 METAL6_543000_2241000 METAL6_543000_2253000 0.024
R_VDD4_14133 METAL6_543000_2253000 METAL5_543000_2253000 0.1
R_VDD4_14134 METAL5_543000_2253000 METAL5_531000_2253000 0.048
R_VDD4_14135 METAL5_531000_2253000 METAL5_531000_2265000 0.048
R_VDD4_14136 METAL5_531000_2265000 METAL5_531000_2277000 0.048
R_VDD4_14137 METAL5_531000_2277000 METAL5_531000_2341000 0.256
R_VDD4_14138 METAL5_531000_2341000 METAL5_531000_2353000 0.048
R_VDD4_14139 METAL5_531000_2353000 METAL5_531000_2365000 0.048
R_VDD4_14140 METAL5_531000_2365000 METAL5_531000_2377000 0.048
R_VDD4_14141 METAL5_531000_2377000 METAL5_531000_2453000 0.304
R_VDD4_14142 METAL5_531000_2453000 METAL5_531000_2465000 0.048
R_VDD4_14143 METAL5_531000_2465000 METAL5_531000_2477000 0.048
R_VDD4_14144 METAL5_531000_2477000 METAL5_543000_2477000 0.048
R_VDD4_14145 METAL5_543000_2477000 METAL6_543000_2477000 0.1
R_VDD4_14146 METAL6_543000_2477000 METAL6_543000_2489000 0.024
R_VDD4_14147 METAL6_543000_2489000 METAL6_543000_2553000 0.128
R_VDD4_14148 METAL6_543000_2553000 METAL6_543000_2565000 0.024
R_VDD4_14149 METAL6_245000_1865000 METAL6_257000_1865000 0.024
R_VDD4_14150 METAL5_398000_1553000 METAL5_390000_1553000 0.032
R_VDD4_14151 METAL5_390000_1553000 METAL5_388000_1553000 0.008
R_VDD4_14152 METAL5_388000_1553000 METAL5_386000_1553000 0.008
R_VDD4_14153 METAL5_386000_1553000 METAL5_378000_1553000 0.032
R_VDD4_14154 METAL5_378000_1553000 METAL5_376000_1553000 0.008
R_VDD4_14155 METAL5_376000_1553000 METAL5_374000_1553000 0.008
R_VDD4_14156 METAL5_374000_1553000 METAL5_366000_1553000 0.032
R_VDD4_14157 METAL5_366000_1553000 METAL5_364000_1553000 0.008
R_VDD4_14158 METAL5_364000_1553000 METAL5_362000_1553000 0.008
R_VDD4_14159 METAL5_362000_1553000 METAL5_354000_1553000 0.032
R_VDD4_14160 METAL5_354000_1553000 METAL5_352000_1553000 0.008
R_VDD4_14161 METAL5_352000_1553000 METAL5_350000_1553000 0.008
R_VDD4_14162 METAL5_350000_1553000 METAL5_348000_1553000 0.008
R_VDD4_14163 METAL5_348000_1553000 METAL5_340000_1553000 0.032
R_VDD4_14164 METAL5_340000_1553000 METAL5_338000_1553000 0.008
R_VDD4_14165 METAL5_338000_1553000 METAL5_336000_1553000 0.008
R_VDD4_14166 METAL5_336000_1553000 METAL5_328000_1553000 0.032
R_VDD4_14167 METAL5_328000_1553000 METAL5_326000_1553000 0.008
R_VDD4_14168 METAL5_326000_1553000 METAL5_324000_1553000 0.008
R_VDD4_14169 METAL5_324000_1553000 METAL5_314000_1553000 0.04
R_VDD4_14170 METAL5_314000_1553000 METAL5_312000_1553000 0.008
R_VDD4_14171 METAL5_312000_1553000 METAL5_302000_1553000 0.04
R_VDD4_14172 METAL5_302000_1553000 METAL5_300000_1553000 0.008
R_VDD4_14173 METAL5_300000_1553000 METAL5_293000_1553000 0.028
R_VDD4_14174 METAL5_293000_1553000 METAL5_288000_1553000 0.02
R_VDD4_14175 METAL5_288000_1553000 METAL6_288000_1553000 0.1
R_VDD4_14176 METAL6_288000_1553000 METAL6_288000_1565000 0.024
R_VDD4_14177 METAL6_288000_1565000 METAL6_288000_1577000 0.024
R_VDD4_14178 METAL6_288000_1577000 METAL6_288000_1641000 0.128
R_VDD4_14179 METAL6_288000_1641000 METAL6_288000_1653000 0.024
R_VDD4_14180 METAL6_288000_1653000 METAL6_281000_1653000 0.014
R_VDD4_14181 METAL6_281000_1653000 METAL5_281000_1653000 0.1
R_VDD4_14182 METAL5_281000_1653000 METAL5_276000_1653000 0.02
R_VDD4_14183 METAL5_276000_1653000 METAL5_276000_1665000 0.048
R_VDD4_14184 METAL5_276000_1665000 METAL5_276000_1677000 0.048
R_VDD4_14185 METAL5_276000_1677000 METAL5_276000_1753000 0.304
R_VDD4_14186 METAL5_276000_1753000 METAL5_276000_1765000 0.048
R_VDD4_14187 METAL5_276000_1765000 METAL5_276000_1777000 0.048
R_VDD4_14188 METAL5_276000_1777000 METAL5_269000_1777000 0.028
R_VDD4_14189 METAL5_269000_1777000 METAL5_264000_1777000 0.02
R_VDD4_14190 METAL5_264000_1777000 METAL5_257000_1777000 0.028
R_VDD4_14191 METAL5_257000_1777000 METAL6_257000_1777000 0.1
R_VDD4_14192 METAL6_257000_1777000 METAL6_257000_1829000 0.104
R_VDD4_14193 METAL6_257000_1829000 METAL6_257000_1841000 0.024
R_VDD4_14194 METAL6_257000_1841000 METAL6_257000_1853000 0.024
R_VDD4_14195 METAL6_257000_1853000 METAL6_257000_1865000 0.024
R_VDD4_14196 METAL6_555000_1865000 METAL6_543000_1865000 0.024
R_VDD4_14197 METAL5_422000_1381000 METAL5_424000_1381000 0.008
R_VDD4_14198 METAL5_424000_1381000 METAL5_426000_1381000 0.008
R_VDD4_14199 METAL5_426000_1381000 METAL5_434000_1381000 0.032
R_VDD4_14200 METAL5_434000_1381000 METAL5_436000_1381000 0.008
R_VDD4_14201 METAL5_436000_1381000 METAL5_438000_1381000 0.008
R_VDD4_14202 METAL5_438000_1381000 METAL5_440000_1381000 0.008
R_VDD4_14203 METAL5_440000_1381000 METAL5_448000_1381000 0.032
R_VDD4_14204 METAL5_448000_1381000 METAL5_450000_1381000 0.008
R_VDD4_14205 METAL5_450000_1381000 METAL5_452000_1381000 0.008
R_VDD4_14206 METAL5_452000_1381000 METAL5_460000_1381000 0.032
R_VDD4_14207 METAL5_460000_1381000 METAL5_462000_1381000 0.008
R_VDD4_14208 METAL5_462000_1381000 METAL5_464000_1381000 0.008
R_VDD4_14209 METAL5_464000_1381000 METAL5_472000_1381000 0.032
R_VDD4_14210 METAL5_472000_1381000 METAL5_474000_1381000 0.008
R_VDD4_14211 METAL5_474000_1381000 METAL5_476000_1381000 0.008
R_VDD4_14212 METAL5_476000_1381000 METAL5_484000_1381000 0.032
R_VDD4_14213 METAL5_484000_1381000 METAL5_486000_1381000 0.008
R_VDD4_14214 METAL5_486000_1381000 METAL5_488000_1381000 0.008
R_VDD4_14215 METAL5_488000_1381000 METAL5_500000_1381000 0.048
R_VDD4_14216 METAL5_500000_1381000 METAL5_507000_1381000 0.028
R_VDD4_14217 METAL5_507000_1381000 METAL5_512000_1381000 0.02
R_VDD4_14218 METAL5_512000_1381000 METAL5_519000_1381000 0.028
R_VDD4_14219 METAL5_519000_1381000 METAL5_524000_1381000 0.02
R_VDD4_14220 METAL5_524000_1381000 METAL5_531000_1381000 0.028
R_VDD4_14221 METAL5_531000_1381000 METAL5_543000_1381000 0.048
R_VDD4_14222 METAL5_543000_1381000 METAL6_543000_1381000 0.1
R_VDD4_14223 METAL6_543000_1381000 METAL6_543000_1393000 0.024
R_VDD4_14224 METAL6_543000_1393000 METAL6_543000_1405000 0.024
R_VDD4_14225 METAL6_543000_1405000 METAL6_543000_1407000 0.004
R_VDD4_14226 METAL6_543000_1407000 METAL6_543000_1417000 0.02
R_VDD4_14227 METAL6_543000_1417000 METAL6_543000_1541000 0.248
R_VDD4_14228 METAL6_543000_1541000 METAL6_543000_1553000 0.024
R_VDD4_14229 METAL6_543000_1553000 METAL5_543000_1553000 0.1
R_VDD4_14230 METAL5_543000_1553000 METAL5_531000_1553000 0.048
R_VDD4_14231 METAL5_531000_1553000 METAL5_531000_1565000 0.048
R_VDD4_14232 METAL5_531000_1565000 METAL5_531000_1577000 0.048
R_VDD4_14233 METAL5_531000_1577000 METAL5_531000_1641000 0.256
R_VDD4_14234 METAL5_531000_1641000 METAL5_531000_1653000 0.048
R_VDD4_14235 METAL5_531000_1653000 METAL5_531000_1665000 0.048
R_VDD4_14236 METAL5_531000_1665000 METAL5_531000_1677000 0.048
R_VDD4_14237 METAL5_531000_1677000 METAL5_531000_1753000 0.304
R_VDD4_14238 METAL5_531000_1753000 METAL5_531000_1765000 0.048
R_VDD4_14239 METAL5_531000_1765000 METAL5_531000_1777000 0.048
R_VDD4_14240 METAL5_531000_1777000 METAL5_543000_1777000 0.048
R_VDD4_14241 METAL5_543000_1777000 METAL6_543000_1777000 0.1
R_VDD4_14242 METAL6_543000_1777000 METAL6_543000_1789000 0.024
R_VDD4_14243 METAL6_543000_1789000 METAL6_543000_1829000 0.08
R_VDD4_14244 METAL6_543000_1829000 METAL6_543000_1841000 0.024
R_VDD4_14245 METAL6_543000_1841000 METAL6_543000_1853000 0.024
R_VDD4_14246 METAL6_543000_1853000 METAL6_543000_1865000 0.024
R_VDD4_14247 METAL6_245000_1165000 METAL6_257000_1165000 0.024
R_VDD4_14248 METAL5_450000_8000 METAL5_450000_20000 0.048
R_VDD4_14249 METAL5_450000_20000 METAL5_448000_20000 0.008
R_VDD4_14250 METAL5_448000_20000 METAL5_440000_20000 0.032
R_VDD4_14251 METAL5_440000_20000 METAL5_438000_20000 0.008
R_VDD4_14252 METAL5_438000_20000 METAL5_436000_20000 0.008
R_VDD4_14253 METAL5_436000_20000 METAL5_434000_20000 0.008
R_VDD4_14254 METAL5_434000_20000 METAL5_426000_20000 0.032
R_VDD4_14255 METAL5_426000_20000 METAL5_424000_20000 0.008
R_VDD4_14256 METAL5_424000_20000 METAL5_422000_20000 0.008
R_VDD4_14257 METAL5_422000_20000 METAL5_414000_20000 0.032
R_VDD4_14258 METAL5_414000_20000 METAL6_414000_20000 0.1
R_VDD4_14259 METAL6_414000_20000 METAL6_414000_32000 0.024
R_VDD4_14260 METAL6_414000_32000 METAL6_414000_129000 0.194
R_VDD4_14261 METAL6_414000_129000 METAL6_414000_141000 0.024
R_VDD4_14262 METAL6_414000_141000 METAL6_414000_153000 0.024
R_VDD4_14263 METAL6_414000_153000 METAL6_414000_165000 0.024
R_VDD4_14264 METAL6_414000_165000 METAL6_414000_177000 0.024
R_VDD4_14265 METAL6_414000_177000 METAL6_414000_205000 0.056
R_VDD4_14266 METAL6_414000_205000 METAL6_412000_205000 0.004
R_VDD4_14267 METAL6_412000_205000 METAL6_410000_205000 0.004
R_VDD4_14268 METAL6_410000_205000 METAL6_402000_205000 0.016
R_VDD4_14269 METAL6_402000_205000 METAL6_400000_205000 0.004
R_VDD4_14270 METAL6_400000_205000 METAL6_398000_205000 0.004
R_VDD4_14271 METAL6_398000_205000 METAL6_390000_205000 0.016
R_VDD4_14272 METAL6_390000_205000 METAL6_390000_217000 0.024
R_VDD4_14273 METAL6_390000_217000 METAL6_388000_217000 0.004
R_VDD4_14274 METAL6_388000_217000 METAL6_386000_217000 0.004
R_VDD4_14275 METAL6_386000_217000 METAL6_378000_217000 0.016
R_VDD4_14276 METAL6_378000_217000 METAL6_378000_229000 0.024
R_VDD4_14277 METAL6_378000_229000 METAL6_376000_229000 0.004
R_VDD4_14278 METAL6_376000_229000 METAL6_374000_229000 0.004
R_VDD4_14279 METAL6_374000_229000 METAL6_366000_229000 0.016
R_VDD4_14280 METAL6_366000_229000 METAL6_366000_241000 0.024
R_VDD4_14281 METAL6_366000_241000 METAL6_366000_253000 0.024
R_VDD4_14282 METAL6_366000_253000 METAL6_366000_265000 0.024
R_VDD4_14283 METAL6_366000_265000 METAL6_366000_277000 0.024
R_VDD4_14284 METAL6_366000_277000 METAL6_366000_281000 0.008
R_VDD4_14285 METAL6_366000_281000 METAL6_364000_281000 0.004
R_VDD4_14286 METAL6_364000_281000 METAL6_362000_281000 0.004
R_VDD4_14287 METAL6_362000_281000 METAL6_354000_281000 0.016
R_VDD4_14288 METAL6_354000_281000 METAL6_354000_289000 0.016
R_VDD4_14289 METAL6_354000_289000 METAL6_354000_293000 0.008
R_VDD4_14290 METAL6_354000_293000 METAL6_354000_301000 0.016
R_VDD4_14291 METAL6_354000_301000 METAL6_354000_305000 0.008
R_VDD4_14292 METAL6_354000_305000 METAL6_354000_317000 0.024
R_VDD4_14293 METAL6_354000_317000 METAL6_352000_317000 0.004
R_VDD4_14294 METAL6_352000_317000 METAL6_350000_317000 0.004
R_VDD4_14295 METAL6_350000_317000 METAL6_348000_317000 0.004
R_VDD4_14296 METAL6_348000_317000 METAL6_340000_317000 0.016
R_VDD4_14297 METAL6_340000_317000 METAL6_338000_317000 0.004
R_VDD4_14298 METAL6_338000_317000 METAL6_336000_317000 0.004
R_VDD4_14299 METAL6_336000_317000 METAL6_328000_317000 0.016
R_VDD4_14300 METAL6_328000_317000 METAL6_326000_317000 0.004
R_VDD4_14301 METAL6_326000_317000 METAL6_326000_329000 0.024
R_VDD4_14302 METAL6_326000_329000 METAL5_326000_329000 0.1
R_VDD4_14303 METAL5_326000_329000 METAL5_326000_341000 0.048
R_VDD4_14304 METAL5_326000_341000 METAL5_326000_353000 0.048
R_VDD4_14305 METAL5_326000_353000 METAL5_326000_365000 0.048
R_VDD4_14306 METAL5_326000_365000 METAL5_326000_377000 0.048
R_VDD4_14307 METAL5_326000_377000 METAL6_326000_377000 0.1
R_VDD4_14308 METAL6_326000_377000 METAL6_326000_441000 0.128
R_VDD4_14309 METAL6_326000_441000 METAL6_326000_453000 0.024
R_VDD4_14310 METAL6_326000_453000 METAL6_326000_465000 0.024
R_VDD4_14311 METAL6_326000_465000 METAL6_326000_477000 0.024
R_VDD4_14312 METAL6_326000_477000 METAL6_326000_481000 0.008
R_VDD4_14313 METAL6_326000_481000 METAL6_326000_489000 0.016
R_VDD4_14314 METAL6_326000_489000 METAL6_326000_493000 0.008
R_VDD4_14315 METAL6_326000_493000 METAL6_326000_505000 0.024
R_VDD4_14316 METAL6_326000_505000 METAL6_326000_517000 0.024
R_VDD4_14317 METAL6_326000_517000 METAL6_326000_529000 0.024
R_VDD4_14318 METAL6_326000_529000 METAL6_326000_541000 0.024
R_VDD4_14319 METAL6_326000_541000 METAL6_324000_541000 0.004
R_VDD4_14320 METAL6_324000_541000 METAL5_324000_541000 0.1
R_VDD4_14321 METAL5_324000_541000 METAL5_324000_553000 0.048
R_VDD4_14322 METAL5_324000_553000 METAL5_324000_565000 0.048
R_VDD4_14323 METAL5_324000_565000 METAL5_324000_577000 0.048
R_VDD4_14324 METAL5_324000_577000 METAL5_314000_577000 0.04
R_VDD4_14325 METAL5_314000_577000 METAL5_312000_577000 0.008
R_VDD4_14326 METAL5_312000_577000 METAL6_312000_577000 0.1
R_VDD4_14327 METAL6_312000_577000 METAL6_312000_589000 0.024
R_VDD4_14328 METAL6_312000_589000 METAL6_312000_601000 0.024
R_VDD4_14329 METAL6_312000_601000 METAL6_312000_613000 0.024
R_VDD4_14330 METAL6_312000_613000 METAL6_312000_681000 0.136
R_VDD4_14331 METAL6_312000_681000 METAL6_312000_693000 0.024
R_VDD4_14332 METAL6_312000_693000 METAL6_312000_705000 0.024
R_VDD4_14333 METAL6_312000_705000 METAL6_312000_707000 0.004
R_VDD4_14334 METAL6_312000_707000 METAL6_312000_717000 0.02
R_VDD4_14335 METAL6_312000_717000 METAL6_312000_793000 0.152
R_VDD4_14336 METAL6_312000_793000 METAL6_312000_805000 0.024
R_VDD4_14337 METAL6_312000_805000 METAL6_312000_817000 0.024
R_VDD4_14338 METAL6_312000_817000 METAL5_312000_817000 0.1
R_VDD4_14339 METAL5_312000_817000 METAL5_312000_829000 0.048
R_VDD4_14340 METAL5_312000_829000 METAL5_312000_841000 0.048
R_VDD4_14341 METAL5_312000_841000 METAL5_312000_853000 0.048
R_VDD4_14342 METAL5_312000_853000 METAL5_312000_865000 0.048
R_VDD4_14343 METAL5_312000_865000 METAL5_312000_877000 0.048
R_VDD4_14344 METAL5_312000_877000 METAL5_302000_877000 0.04
R_VDD4_14345 METAL5_302000_877000 METAL5_300000_877000 0.008
R_VDD4_14346 METAL5_300000_877000 METAL5_293000_877000 0.028
R_VDD4_14347 METAL5_293000_877000 METAL5_288000_877000 0.02
R_VDD4_14348 METAL5_288000_877000 METAL4_288000_877000 0.1
R_VDD4_14349 METAL4_288000_877000 METAL4_288000_889000 0.096
R_VDD4_14350 METAL4_288000_889000 METAL4_288000_893000 0.032
R_VDD4_14351 METAL4_288000_893000 METAL4_288000_901000 0.064
R_VDD4_14352 METAL4_288000_901000 METAL4_288000_905000 0.032
R_VDD4_14353 METAL4_288000_905000 METAL4_288000_917000 0.096
R_VDD4_14354 METAL4_288000_917000 METAL4_288000_929000 0.096
R_VDD4_14355 METAL4_288000_929000 METAL4_288000_941000 0.096
R_VDD4_14356 METAL4_288000_941000 METAL4_288000_953000 0.096
R_VDD4_14357 METAL4_288000_953000 METAL4_288000_965000 0.096
R_VDD4_14358 METAL4_288000_965000 METAL4_288000_977000 0.096
R_VDD4_14359 METAL4_288000_977000 METAL5_288000_977000 0.1
R_VDD4_14360 METAL5_288000_977000 METAL5_288000_989000 0.048
R_VDD4_14361 METAL5_288000_989000 METAL5_288000_1001000 0.048
R_VDD4_14362 METAL5_288000_1001000 METAL5_288000_1013000 0.048
R_VDD4_14363 METAL5_288000_1013000 METAL5_288000_1041000 0.112
R_VDD4_14364 METAL5_288000_1041000 METAL5_288000_1053000 0.048
R_VDD4_14365 METAL5_288000_1053000 METAL5_288000_1065000 0.048
R_VDD4_14366 METAL5_288000_1065000 METAL5_288000_1077000 0.048
R_VDD4_14367 METAL5_288000_1077000 METAL5_281000_1077000 0.028
R_VDD4_14368 METAL5_281000_1077000 METAL4_281000_1077000 0.1
R_VDD4_14369 METAL4_281000_1077000 METAL4_276000_1077000 0.04
R_VDD4_14370 METAL4_276000_1077000 METAL4_269000_1077000 0.056
R_VDD4_14371 METAL4_269000_1077000 METAL4_264000_1077000 0.04
R_VDD4_14372 METAL4_264000_1077000 METAL4_257000_1077000 0.056
R_VDD4_14373 METAL4_257000_1077000 METAL5_257000_1077000 0.1
R_VDD4_14374 METAL5_257000_1077000 METAL6_257000_1077000 0.1
R_VDD4_14375 METAL6_257000_1077000 METAL6_257000_1153000 0.152
R_VDD4_14376 METAL6_257000_1153000 METAL6_257000_1165000 0.024
R_VDD4_14377 METAL6_555000_1165000 METAL6_543000_1165000 0.024
R_VDD4_14378 METAL5_288000_1065000 METAL5_293000_1065000 0.02
R_VDD4_14379 METAL5_293000_1065000 METAL5_300000_1065000 0.028
R_VDD4_14380 METAL5_300000_1065000 METAL5_300000_1077000 0.048
R_VDD4_14381 METAL5_300000_1077000 METAL5_302000_1077000 0.008
R_VDD4_14382 METAL5_302000_1077000 METAL5_312000_1077000 0.04
R_VDD4_14383 METAL5_312000_1077000 METAL5_314000_1077000 0.008
R_VDD4_14384 METAL5_314000_1077000 METAL5_324000_1077000 0.04
R_VDD4_14385 METAL5_324000_1077000 METAL5_326000_1077000 0.008
R_VDD4_14386 METAL5_326000_1077000 METAL5_328000_1077000 0.008
R_VDD4_14387 METAL5_328000_1077000 METAL5_336000_1077000 0.032
R_VDD4_14388 METAL5_336000_1077000 METAL5_338000_1077000 0.008
R_VDD4_14389 METAL5_338000_1077000 METAL5_340000_1077000 0.008
R_VDD4_14390 METAL5_340000_1077000 METAL5_342000_1077000 0.008
R_VDD4_14391 METAL5_342000_1077000 METAL5_348000_1077000 0.024
R_VDD4_14392 METAL5_348000_1077000 METAL5_350000_1077000 0.008
R_VDD4_14393 METAL5_350000_1077000 METAL5_352000_1077000 0.008
R_VDD4_14394 METAL5_352000_1077000 METAL5_354000_1077000 0.008
R_VDD4_14395 METAL5_354000_1077000 METAL5_362000_1077000 0.032
R_VDD4_14396 METAL5_362000_1077000 METAL5_364000_1077000 0.008
R_VDD4_14397 METAL5_364000_1077000 METAL5_366000_1077000 0.008
R_VDD4_14398 METAL5_366000_1077000 METAL5_374000_1077000 0.032
R_VDD4_14399 METAL5_374000_1077000 METAL5_376000_1077000 0.008
R_VDD4_14400 METAL5_376000_1077000 METAL5_378000_1077000 0.008
R_VDD4_14401 METAL5_378000_1077000 METAL5_386000_1077000 0.032
R_VDD4_14402 METAL5_386000_1077000 METAL5_388000_1077000 0.008
R_VDD4_14403 METAL5_388000_1077000 METAL5_390000_1077000 0.008
R_VDD4_14404 METAL5_390000_1077000 METAL5_398000_1077000 0.032
R_VDD4_14405 METAL5_398000_1077000 METAL5_400000_1077000 0.008
R_VDD4_14406 METAL5_400000_1077000 METAL5_402000_1077000 0.008
R_VDD4_14407 METAL5_402000_1077000 METAL5_410000_1077000 0.032
R_VDD4_14408 METAL5_410000_1077000 METAL5_412000_1077000 0.008
R_VDD4_14409 METAL5_412000_1077000 METAL5_414000_1077000 0.008
R_VDD4_14410 METAL5_414000_1077000 METAL5_422000_1077000 0.032
R_VDD4_14411 METAL5_422000_1077000 METAL5_424000_1077000 0.008
R_VDD4_14412 METAL5_424000_1077000 METAL5_426000_1077000 0.008
R_VDD4_14413 METAL5_426000_1077000 METAL5_434000_1077000 0.032
R_VDD4_14414 METAL5_434000_1077000 METAL5_436000_1077000 0.008
R_VDD4_14415 METAL5_436000_1077000 METAL5_438000_1077000 0.008
R_VDD4_14416 METAL5_438000_1077000 METAL5_440000_1077000 0.008
R_VDD4_14417 METAL5_440000_1077000 METAL5_448000_1077000 0.032
R_VDD4_14418 METAL5_448000_1077000 METAL5_450000_1077000 0.008
R_VDD4_14419 METAL5_450000_1077000 METAL5_452000_1077000 0.008
R_VDD4_14420 METAL5_452000_1077000 METAL5_460000_1077000 0.032
R_VDD4_14421 METAL5_460000_1077000 METAL5_462000_1077000 0.008
R_VDD4_14422 METAL5_462000_1077000 METAL5_464000_1077000 0.008
R_VDD4_14423 METAL5_464000_1077000 METAL5_472000_1077000 0.032
R_VDD4_14424 METAL5_472000_1077000 METAL5_474000_1077000 0.008
R_VDD4_14425 METAL5_474000_1077000 METAL5_476000_1077000 0.008
R_VDD4_14426 METAL5_476000_1077000 METAL5_484000_1077000 0.032
R_VDD4_14427 METAL5_484000_1077000 METAL5_486000_1077000 0.008
R_VDD4_14428 METAL5_486000_1077000 METAL5_488000_1077000 0.008
R_VDD4_14429 METAL5_488000_1077000 METAL5_500000_1077000 0.048
R_VDD4_14430 METAL5_500000_1077000 METAL5_507000_1077000 0.028
R_VDD4_14431 METAL5_507000_1077000 METAL5_512000_1077000 0.02
R_VDD4_14432 METAL5_512000_1077000 METAL5_519000_1077000 0.028
R_VDD4_14433 METAL5_519000_1077000 METAL5_524000_1077000 0.02
R_VDD4_14434 METAL5_524000_1077000 METAL5_531000_1077000 0.028
R_VDD4_14435 METAL5_531000_1077000 METAL5_543000_1077000 0.048
R_VDD4_14436 METAL5_543000_1077000 METAL6_543000_1077000 0.1
R_VDD4_14437 METAL6_543000_1077000 METAL6_543000_1089000 0.024
R_VDD4_14438 METAL6_543000_1089000 METAL6_543000_1153000 0.128
R_VDD4_14439 METAL6_543000_1153000 METAL6_543000_1165000 0.024
R_VDD4_14440 METAL6_245000_465000 METAL6_257000_465000 0.024
R_VDD4_14441 METAL6_450000_8000 METAL6_452000_8000 0.004
R_VDD4_14442 METAL6_452000_8000 METAL6_460000_8000 0.016
R_VDD4_14443 METAL6_460000_8000 METAL6_462000_8000 0.004
R_VDD4_14444 METAL6_462000_8000 METAL6_462000_20000 0.024
R_VDD4_14445 METAL6_462000_20000 METAL6_462000_32000 0.024
R_VDD4_14446 METAL6_462000_32000 METAL6_462000_129000 0.194
R_VDD4_14447 METAL6_462000_129000 METAL5_462000_129000 0.1
R_VDD4_14448 METAL5_462000_129000 METAL5_460000_129000 0.008
R_VDD4_14449 METAL5_460000_129000 METAL5_452000_129000 0.032
R_VDD4_14450 METAL5_452000_129000 METAL5_450000_129000 0.008
R_VDD4_14451 METAL5_450000_129000 METAL5_448000_129000 0.008
R_VDD4_14452 METAL5_448000_129000 METAL5_440000_129000 0.032
R_VDD4_14453 METAL5_440000_129000 METAL5_438000_129000 0.008
R_VDD4_14454 METAL5_438000_129000 METAL5_436000_129000 0.008
R_VDD4_14455 METAL5_436000_129000 METAL5_434000_129000 0.008
R_VDD4_14456 METAL5_434000_129000 METAL5_426000_129000 0.032
R_VDD4_14457 METAL5_426000_129000 METAL5_424000_129000 0.008
R_VDD4_14458 METAL5_424000_129000 METAL5_422000_129000 0.008
R_VDD4_14459 METAL5_422000_129000 METAL5_414000_129000 0.032
R_VDD4_14460 METAL5_414000_129000 METAL5_412000_129000 0.008
R_VDD4_14461 METAL5_412000_129000 METAL5_410000_129000 0.008
R_VDD4_14462 METAL5_410000_129000 METAL5_402000_129000 0.032
R_VDD4_14463 METAL5_402000_129000 METAL6_402000_129000 0.1
R_VDD4_14464 METAL6_402000_129000 METAL6_402000_141000 0.024
R_VDD4_14465 METAL6_402000_141000 METAL6_402000_153000 0.024
R_VDD4_14466 METAL6_402000_153000 METAL6_402000_165000 0.024
R_VDD4_14467 METAL6_402000_165000 METAL6_402000_177000 0.024
R_VDD4_14468 METAL6_402000_177000 METAL6_402000_193000 0.032
R_VDD4_14469 METAL6_402000_193000 METAL6_400000_193000 0.004
R_VDD4_14470 METAL6_400000_193000 METAL6_398000_193000 0.004
R_VDD4_14471 METAL6_398000_193000 METAL6_390000_193000 0.016
R_VDD4_14472 METAL6_390000_193000 METAL6_388000_193000 0.004
R_VDD4_14473 METAL6_388000_193000 METAL6_386000_193000 0.004
R_VDD4_14474 METAL6_386000_193000 METAL6_378000_193000 0.016
R_VDD4_14475 METAL6_378000_193000 METAL6_378000_205000 0.024
R_VDD4_14476 METAL6_378000_205000 METAL6_376000_205000 0.004
R_VDD4_14477 METAL6_376000_205000 METAL6_374000_205000 0.004
R_VDD4_14478 METAL6_374000_205000 METAL6_366000_205000 0.016
R_VDD4_14479 METAL6_366000_205000 METAL6_366000_217000 0.024
R_VDD4_14480 METAL6_366000_217000 METAL6_364000_217000 0.004
R_VDD4_14481 METAL6_364000_217000 METAL6_362000_217000 0.004
R_VDD4_14482 METAL6_362000_217000 METAL6_354000_217000 0.016
R_VDD4_14483 METAL6_354000_217000 METAL6_354000_229000 0.024
R_VDD4_14484 METAL6_354000_229000 METAL6_354000_241000 0.024
R_VDD4_14485 METAL6_354000_241000 METAL6_354000_253000 0.024
R_VDD4_14486 METAL6_354000_253000 METAL6_354000_265000 0.024
R_VDD4_14487 METAL6_354000_265000 METAL6_354000_269000 0.008
R_VDD4_14488 METAL6_354000_269000 METAL6_352000_269000 0.004
R_VDD4_14489 METAL6_352000_269000 METAL6_350000_269000 0.004
R_VDD4_14490 METAL6_350000_269000 METAL6_348000_269000 0.004
R_VDD4_14491 METAL6_348000_269000 METAL6_342000_269000 0.012
R_VDD4_14492 METAL6_342000_269000 METAL6_342000_277000 0.016
R_VDD4_14493 METAL6_342000_277000 METAL6_342000_281000 0.008
R_VDD4_14494 METAL6_342000_281000 METAL6_342000_289000 0.016
R_VDD4_14495 METAL6_342000_289000 METAL6_342000_293000 0.008
R_VDD4_14496 METAL6_342000_293000 METAL6_342000_301000 0.016
R_VDD4_14497 METAL6_342000_301000 METAL6_342000_305000 0.008
R_VDD4_14498 METAL6_342000_305000 METAL6_340000_305000 0.004
R_VDD4_14499 METAL6_340000_305000 METAL6_338000_305000 0.004
R_VDD4_14500 METAL6_338000_305000 METAL6_336000_305000 0.004
R_VDD4_14501 METAL6_336000_305000 METAL6_328000_305000 0.016
R_VDD4_14502 METAL6_328000_305000 METAL6_326000_305000 0.004
R_VDD4_14503 METAL6_326000_305000 METAL6_324000_305000 0.004
R_VDD4_14504 METAL6_324000_305000 METAL6_314000_305000 0.02
R_VDD4_14505 METAL6_314000_305000 METAL6_314000_317000 0.024
R_VDD4_14506 METAL6_314000_317000 METAL6_314000_329000 0.024
R_VDD4_14507 METAL6_314000_329000 METAL6_312000_329000 0.004
R_VDD4_14508 METAL6_312000_329000 METAL6_302000_329000 0.02
R_VDD4_14509 METAL6_302000_329000 METAL6_300000_329000 0.004
R_VDD4_14510 METAL6_300000_329000 METAL6_293000_329000 0.014
R_VDD4_14511 METAL6_293000_329000 METAL6_288000_329000 0.01
R_VDD4_14512 METAL6_288000_329000 METAL6_281000_329000 0.014
R_VDD4_14513 METAL6_281000_329000 METAL6_276000_329000 0.01
R_VDD4_14514 METAL6_276000_329000 METAL6_276000_341000 0.024
R_VDD4_14515 METAL6_276000_341000 METAL6_276000_353000 0.024
R_VDD4_14516 METAL6_276000_353000 METAL6_276000_365000 0.024
R_VDD4_14517 METAL6_276000_365000 METAL6_276000_377000 0.024
R_VDD4_14518 METAL6_276000_377000 METAL6_276000_389000 0.024
R_VDD4_14519 METAL6_276000_389000 METAL6_276000_441000 0.104
R_VDD4_14520 METAL6_276000_441000 METAL6_269000_441000 0.014
R_VDD4_14521 METAL6_269000_441000 METAL6_264000_441000 0.01
R_VDD4_14522 METAL6_264000_441000 METAL6_264000_453000 0.024
R_VDD4_14523 METAL6_264000_453000 METAL6_257000_453000 0.014
R_VDD4_14524 METAL6_257000_453000 METAL6_257000_465000 0.024
R_VDD4_14525 METAL6_555000_465000 METAL6_543000_465000 0.024
R_VDD4_14526 METAL5_460000_129000 METAL5_460000_141000 0.048
R_VDD4_14527 METAL5_460000_141000 METAL5_460000_153000 0.048
R_VDD4_14528 METAL5_460000_153000 METAL5_460000_165000 0.048
R_VDD4_14529 METAL5_460000_165000 METAL5_460000_177000 0.048
R_VDD4_14530 METAL5_460000_177000 METAL5_460000_181000 0.016
R_VDD4_14531 METAL5_460000_181000 METAL5_460000_193000 0.048
R_VDD4_14532 METAL5_460000_193000 METAL5_460000_205000 0.048
R_VDD4_14533 METAL5_460000_205000 METAL5_460000_217000 0.048
R_VDD4_14534 METAL5_460000_217000 METAL5_460000_229000 0.048
R_VDD4_14535 METAL5_460000_229000 METAL5_460000_241000 0.048
R_VDD4_14536 METAL5_460000_241000 METAL5_462000_241000 0.008
R_VDD4_14537 METAL5_462000_241000 METAL5_464000_241000 0.008
R_VDD4_14538 METAL5_464000_241000 METAL5_472000_241000 0.032
R_VDD4_14539 METAL5_472000_241000 METAL5_474000_241000 0.008
R_VDD4_14540 METAL5_474000_241000 METAL5_476000_241000 0.008
R_VDD4_14541 METAL5_476000_241000 METAL5_484000_241000 0.032
R_VDD4_14542 METAL5_484000_241000 METAL5_486000_241000 0.008
R_VDD4_14543 METAL5_486000_241000 METAL5_488000_241000 0.008
R_VDD4_14544 METAL5_488000_241000 METAL5_500000_241000 0.048
R_VDD4_14545 METAL5_500000_241000 METAL5_507000_241000 0.028
R_VDD4_14546 METAL5_507000_241000 METAL5_512000_241000 0.02
R_VDD4_14547 METAL5_512000_241000 METAL5_512000_253000 0.048
R_VDD4_14548 METAL5_512000_253000 METAL5_519000_253000 0.028
R_VDD4_14549 METAL5_519000_253000 METAL5_524000_253000 0.02
R_VDD4_14550 METAL5_524000_253000 METAL5_531000_253000 0.028
R_VDD4_14551 METAL5_531000_253000 METAL5_531000_257000 0.016
R_VDD4_14552 METAL5_531000_257000 METAL5_531000_265000 0.032
R_VDD4_14553 METAL5_531000_265000 METAL5_531000_269000 0.016
R_VDD4_14554 METAL5_531000_269000 METAL5_531000_277000 0.032
R_VDD4_14555 METAL5_531000_277000 METAL5_531000_281000 0.016
R_VDD4_14556 METAL5_531000_281000 METAL5_531000_289000 0.032
R_VDD4_14557 METAL5_531000_289000 METAL5_531000_293000 0.016
R_VDD4_14558 METAL5_531000_293000 METAL5_531000_301000 0.032
R_VDD4_14559 METAL5_531000_301000 METAL5_531000_305000 0.016
R_VDD4_14560 METAL5_531000_305000 METAL5_531000_317000 0.048
R_VDD4_14561 METAL5_531000_317000 METAL4_531000_317000 0.1
R_VDD4_14562 METAL4_531000_317000 METAL4_531000_329000 0.096
R_VDD4_14563 METAL4_531000_329000 METAL4_531000_341000 0.096
R_VDD4_14564 METAL4_531000_341000 METAL4_531000_353000 0.096
R_VDD4_14565 METAL4_531000_353000 METAL4_531000_365000 0.096
R_VDD4_14566 METAL4_531000_365000 METAL4_531000_377000 0.096
R_VDD4_14567 METAL4_531000_377000 METAL4_543000_377000 0.096
R_VDD4_14568 METAL4_543000_377000 METAL5_543000_377000 0.1
R_VDD4_14569 METAL5_543000_377000 METAL6_543000_377000 0.1
R_VDD4_14570 METAL6_543000_377000 METAL6_543000_389000 0.024
R_VDD4_14571 METAL6_543000_389000 METAL6_543000_429000 0.08
R_VDD4_14572 METAL6_543000_429000 METAL6_543000_441000 0.024
R_VDD4_14573 METAL6_543000_441000 METAL6_543000_453000 0.024
R_VDD4_14574 METAL6_543000_453000 METAL6_543000_465000 0.024
I_VDD4_61 METAL6_245000_6765000 gnd 0.01
I_VDD4_62 METAL6_555000_6765000 gnd 0.01
I_VDD4_63 METAL6_245000_6065000 gnd 0.01
I_VDD4_64 METAL6_555000_6065000 gnd 0.01
I_VDD4_65 METAL6_245000_5365000 gnd 0.01
I_VDD4_66 METAL6_555000_5365000 gnd 0.01
I_VDD4_67 METAL6_245000_4665000 gnd 0.01
I_VDD4_68 METAL6_555000_4665000 gnd 0.01
I_VDD4_69 METAL6_245000_3965000 gnd 0.01
I_VDD4_70 METAL6_555000_3965000 gnd 0.01
I_VDD4_71 METAL6_245000_3265000 gnd 0.01
I_VDD4_72 METAL6_555000_3265000 gnd 0.01
I_VDD4_73 METAL6_245000_2565000 gnd 0.01
I_VDD4_74 METAL6_555000_2565000 gnd 0.01
I_VDD4_75 METAL6_245000_1865000 gnd 0.01
I_VDD4_76 METAL6_555000_1865000 gnd 0.01
I_VDD4_77 METAL6_245000_1165000 gnd 0.01
I_VDD4_78 METAL6_555000_1165000 gnd 0.01
I_VDD4_79 METAL6_245000_465000 gnd 0.01
I_VDD4_80 METAL6_555000_465000 gnd 0.01

V_VDD5_5 METAL6_500000_0 gnd 1
R_VDD5_14575 METAL6_500000_0 METAL6_500000_8000 0.016
R_VDD5_14576 METAL6_500000_8000 METAL6_500000_20000 0.024
R_VDD5_14577 METAL6_500000_20000 METAL6_500000_153000 0.266
R_VDD5_14578 METAL6_500000_153000 METAL6_488000_153000 0.024
R_VDD5_14579 METAL6_488000_153000 METAL6_462000_153000 0.052
R_VDD5_14580 METAL6_462000_153000 METAL6_462000_165000 0.024
R_VDD5_14581 METAL6_462000_165000 METAL6_462000_177000 0.024
R_VDD5_14582 METAL6_462000_177000 METAL6_462000_253000 0.152
R_VDD5_14583 METAL6_462000_253000 METAL6_450000_253000 0.024
R_VDD5_14584 METAL6_450000_253000 METAL6_450000_265000 0.024
R_VDD5_14585 METAL6_450000_265000 METAL6_450000_277000 0.024
R_VDD5_14586 METAL6_450000_277000 METAL6_450000_353000 0.152
R_VDD5_14587 METAL6_450000_353000 METAL6_438000_353000 0.024
R_VDD5_14588 METAL6_438000_353000 METAL6_412000_353000 0.052
R_VDD5_14589 METAL6_412000_353000 METAL6_400000_353000 0.024
R_VDD5_14590 METAL6_400000_353000 METAL6_388000_353000 0.024
R_VDD5_14591 METAL6_388000_353000 METAL6_362000_353000 0.052
R_VDD5_14592 METAL6_362000_353000 METAL6_362000_365000 0.024
R_VDD5_14593 METAL6_362000_365000 METAL6_350000_365000 0.024
R_VDD5_14594 METAL6_350000_365000 METAL6_338000_365000 0.024
R_VDD5_14595 METAL6_338000_365000 METAL6_312000_365000 0.052
R_VDD5_14596 METAL6_312000_365000 METAL6_312000_377000 0.024
R_VDD5_14597 METAL6_312000_377000 METAL6_312000_453000 0.152
R_VDD5_14598 METAL6_312000_453000 METAL6_312000_465000 0.024
R_VDD5_14599 METAL6_312000_465000 METAL6_312000_477000 0.024
R_VDD5_14600 METAL6_312000_477000 METAL6_312000_553000 0.152
R_VDD5_14601 METAL6_312000_553000 METAL6_312000_565000 0.024
R_VDD5_14602 METAL6_312000_565000 METAL6_300000_565000 0.024
R_VDD5_14603 METAL6_300000_565000 METAL6_300000_577000 0.024
R_VDD5_14604 METAL6_300000_577000 METAL6_300000_693000 0.232
R_VDD5_14605 METAL6_300000_693000 METAL6_300000_707000 0.028
R_VDD5_14606 METAL6_300000_707000 METAL6_300000_853000 0.292
R_VDD5_14607 METAL6_300000_853000 METAL6_300000_865000 0.024
R_VDD5_14608 METAL6_300000_865000 METAL6_300000_877000 0.024
R_VDD5_14609 METAL6_300000_877000 METAL6_300000_953000 0.152
R_VDD5_14610 METAL6_300000_953000 METAL6_288000_953000 0.024
R_VDD5_14611 METAL6_288000_953000 METAL6_269000_953000 0.038
R_VDD5_14612 METAL6_269000_953000 METAL6_269000_965000 0.024
R_VDD5_14613 METAL6_269000_965000 METAL6_269000_977000 0.024
R_VDD5_14614 METAL6_269000_977000 METAL6_269000_1053000 0.152
R_VDD5_14615 METAL6_269000_1053000 METAL6_269000_1065000 0.024
R_VDD5_14616 METAL6_269000_1065000 METAL6_269000_1077000 0.024
R_VDD5_14617 METAL6_269000_1077000 METAL6_269000_1153000 0.152
R_VDD5_14618 METAL6_269000_1153000 METAL6_269000_1165000 0.024
R_VDD5_14619 METAL6_269000_1165000 METAL6_269000_1177000 0.024
R_VDD5_14620 METAL6_269000_1177000 METAL6_269000_1253000 0.152
R_VDD5_14621 METAL6_269000_1253000 METAL6_269000_1265000 0.024
R_VDD5_14622 METAL6_269000_1265000 METAL6_269000_1277000 0.024
R_VDD5_14623 METAL6_269000_1277000 METAL6_269000_1393000 0.232
R_VDD5_14624 METAL6_269000_1393000 METAL6_269000_1407000 0.028
R_VDD5_14625 METAL6_269000_1407000 METAL6_269000_1553000 0.292
R_VDD5_14626 METAL6_269000_1553000 METAL6_269000_1565000 0.024
R_VDD5_14627 METAL6_269000_1565000 METAL6_269000_1577000 0.024
R_VDD5_14628 METAL6_269000_1577000 METAL6_269000_1653000 0.152
R_VDD5_14629 METAL6_269000_1653000 METAL6_269000_1665000 0.024
R_VDD5_14630 METAL6_269000_1665000 METAL6_269000_1677000 0.024
R_VDD5_14631 METAL6_269000_1677000 METAL6_269000_1753000 0.152
R_VDD5_14632 METAL6_269000_1753000 METAL6_269000_1765000 0.024
R_VDD5_14633 METAL6_269000_1765000 METAL6_269000_1777000 0.024
R_VDD5_14634 METAL6_269000_1777000 METAL6_269000_1853000 0.152
R_VDD5_14635 METAL6_269000_1853000 METAL6_269000_1865000 0.024
R_VDD5_14636 METAL6_269000_1865000 METAL6_269000_1877000 0.024
R_VDD5_14637 METAL6_269000_1877000 METAL6_269000_1953000 0.152
R_VDD5_14638 METAL6_269000_1953000 METAL6_269000_1965000 0.024
R_VDD5_14639 METAL6_269000_1965000 METAL6_269000_1977000 0.024
R_VDD5_14640 METAL6_269000_1977000 METAL6_269000_2093000 0.232
R_VDD5_14641 METAL6_269000_2093000 METAL6_269000_2107000 0.028
R_VDD5_14642 METAL6_269000_2107000 METAL6_269000_2253000 0.292
R_VDD5_14643 METAL6_269000_2253000 METAL6_269000_2265000 0.024
R_VDD5_14644 METAL6_269000_2265000 METAL6_269000_2277000 0.024
R_VDD5_14645 METAL6_269000_2277000 METAL6_269000_2353000 0.152
R_VDD5_14646 METAL6_269000_2353000 METAL6_269000_2365000 0.024
R_VDD5_14647 METAL6_269000_2365000 METAL6_269000_2377000 0.024
R_VDD5_14648 METAL6_269000_2377000 METAL6_269000_2453000 0.152
R_VDD5_14649 METAL6_269000_2453000 METAL6_269000_2465000 0.024
R_VDD5_14650 METAL6_269000_2465000 METAL6_269000_2477000 0.024
R_VDD5_14651 METAL6_269000_2477000 METAL6_269000_2553000 0.152
R_VDD5_14652 METAL6_269000_2553000 METAL6_269000_2565000 0.024
R_VDD5_14653 METAL6_269000_2565000 METAL6_269000_2577000 0.024
R_VDD5_14654 METAL6_269000_2577000 METAL6_269000_2653000 0.152
R_VDD5_14655 METAL6_269000_2653000 METAL6_269000_2665000 0.024
R_VDD5_14656 METAL6_269000_2665000 METAL6_269000_2677000 0.024
R_VDD5_14657 METAL6_269000_2677000 METAL6_269000_2793000 0.232
R_VDD5_14658 METAL6_269000_2793000 METAL6_269000_2807000 0.028
R_VDD5_14659 METAL6_269000_2807000 METAL6_269000_2953000 0.292
R_VDD5_14660 METAL6_269000_2953000 METAL6_269000_2965000 0.024
R_VDD5_14661 METAL6_269000_2965000 METAL6_269000_2977000 0.024
R_VDD5_14662 METAL6_269000_2977000 METAL6_269000_3053000 0.152
R_VDD5_14663 METAL6_269000_3053000 METAL6_269000_3065000 0.024
R_VDD5_14664 METAL6_269000_3065000 METAL6_269000_3077000 0.024
R_VDD5_14665 METAL6_269000_3077000 METAL6_269000_3153000 0.152
R_VDD5_14666 METAL6_269000_3153000 METAL6_269000_3165000 0.024
R_VDD5_14667 METAL6_269000_3165000 METAL6_269000_3177000 0.024
R_VDD5_14668 METAL6_269000_3177000 METAL6_269000_3253000 0.152
R_VDD5_14669 METAL6_269000_3253000 METAL6_269000_3265000 0.024
R_VDD5_14670 METAL6_269000_3265000 METAL6_269000_3277000 0.024
R_VDD5_14671 METAL6_269000_3277000 METAL6_269000_3353000 0.152
R_VDD5_14672 METAL6_269000_3353000 METAL6_269000_3365000 0.024
R_VDD5_14673 METAL6_269000_3365000 METAL6_269000_3377000 0.024
R_VDD5_14674 METAL6_269000_3377000 METAL6_269000_3493000 0.232
R_VDD5_14675 METAL6_269000_3493000 METAL6_269000_3507000 0.028
R_VDD5_14676 METAL6_269000_3507000 METAL6_269000_3653000 0.292
R_VDD5_14677 METAL6_269000_3653000 METAL6_269000_3665000 0.024
R_VDD5_14678 METAL6_269000_3665000 METAL6_269000_3677000 0.024
R_VDD5_14679 METAL6_269000_3677000 METAL6_269000_3753000 0.152
R_VDD5_14680 METAL6_269000_3753000 METAL6_269000_3765000 0.024
R_VDD5_14681 METAL6_269000_3765000 METAL6_269000_3777000 0.024
R_VDD5_14682 METAL6_269000_3777000 METAL6_269000_3853000 0.152
R_VDD5_14683 METAL6_269000_3853000 METAL6_269000_3865000 0.024
R_VDD5_14684 METAL6_269000_3865000 METAL6_269000_3877000 0.024
R_VDD5_14685 METAL6_269000_3877000 METAL6_269000_3953000 0.152
R_VDD5_14686 METAL6_269000_3953000 METAL6_269000_3965000 0.024
R_VDD5_14687 METAL6_269000_3965000 METAL6_269000_3977000 0.024
R_VDD5_14688 METAL6_269000_3977000 METAL6_269000_4053000 0.152
R_VDD5_14689 METAL6_269000_4053000 METAL6_269000_4065000 0.024
R_VDD5_14690 METAL6_269000_4065000 METAL6_269000_4077000 0.024
R_VDD5_14691 METAL6_269000_4077000 METAL6_269000_4193000 0.232
R_VDD5_14692 METAL6_269000_4193000 METAL6_269000_4207000 0.028
R_VDD5_14693 METAL6_269000_4207000 METAL6_269000_4353000 0.292
R_VDD5_14694 METAL6_269000_4353000 METAL6_269000_4365000 0.024
R_VDD5_14695 METAL6_269000_4365000 METAL6_269000_4377000 0.024
R_VDD5_14696 METAL6_269000_4377000 METAL6_269000_4453000 0.152
R_VDD5_14697 METAL6_269000_4453000 METAL6_269000_4465000 0.024
R_VDD5_14698 METAL6_269000_4465000 METAL6_269000_4477000 0.024
R_VDD5_14699 METAL6_269000_4477000 METAL6_269000_4553000 0.152
R_VDD5_14700 METAL6_269000_4553000 METAL6_269000_4565000 0.024
R_VDD5_14701 METAL6_269000_4565000 METAL6_269000_4577000 0.024
R_VDD5_14702 METAL6_269000_4577000 METAL6_269000_4653000 0.152
R_VDD5_14703 METAL6_269000_4653000 METAL6_269000_4665000 0.024
R_VDD5_14704 METAL6_269000_4665000 METAL6_269000_4677000 0.024
R_VDD5_14705 METAL6_269000_4677000 METAL6_269000_4753000 0.152
R_VDD5_14706 METAL6_269000_4753000 METAL6_269000_4765000 0.024
R_VDD5_14707 METAL6_269000_4765000 METAL6_269000_4777000 0.024
R_VDD5_14708 METAL6_269000_4777000 METAL6_269000_4893000 0.232
R_VDD5_14709 METAL6_269000_4893000 METAL6_269000_4907000 0.028
R_VDD5_14710 METAL6_269000_4907000 METAL6_269000_5053000 0.292
R_VDD5_14711 METAL6_269000_5053000 METAL6_269000_5065000 0.024
R_VDD5_14712 METAL6_269000_5065000 METAL6_269000_5077000 0.024
R_VDD5_14713 METAL6_269000_5077000 METAL6_269000_5153000 0.152
R_VDD5_14714 METAL6_269000_5153000 METAL6_269000_5165000 0.024
R_VDD5_14715 METAL6_269000_5165000 METAL6_269000_5177000 0.024
R_VDD5_14716 METAL6_269000_5177000 METAL6_269000_5253000 0.152
R_VDD5_14717 METAL6_269000_5253000 METAL6_269000_5265000 0.024
R_VDD5_14718 METAL6_269000_5265000 METAL6_269000_5277000 0.024
R_VDD5_14719 METAL6_269000_5277000 METAL6_269000_5353000 0.152
R_VDD5_14720 METAL6_269000_5353000 METAL6_269000_5365000 0.024
R_VDD5_14721 METAL6_269000_5365000 METAL6_269000_5377000 0.024
R_VDD5_14722 METAL6_269000_5377000 METAL6_269000_5453000 0.152
R_VDD5_14723 METAL6_269000_5453000 METAL6_269000_5465000 0.024
R_VDD5_14724 METAL6_269000_5465000 METAL6_269000_5477000 0.024
R_VDD5_14725 METAL6_269000_5477000 METAL6_269000_5593000 0.232
R_VDD5_14726 METAL6_269000_5593000 METAL6_269000_5607000 0.028
R_VDD5_14727 METAL6_269000_5607000 METAL6_269000_5753000 0.292
R_VDD5_14728 METAL6_269000_5753000 METAL6_269000_5765000 0.024
R_VDD5_14729 METAL6_269000_5765000 METAL6_269000_5777000 0.024
R_VDD5_14730 METAL6_269000_5777000 METAL6_269000_5853000 0.152
R_VDD5_14731 METAL6_269000_5853000 METAL6_269000_5865000 0.024
R_VDD5_14732 METAL6_269000_5865000 METAL6_269000_5877000 0.024
R_VDD5_14733 METAL6_269000_5877000 METAL6_269000_5953000 0.152
R_VDD5_14734 METAL6_269000_5953000 METAL6_269000_5965000 0.024
R_VDD5_14735 METAL6_269000_5965000 METAL6_269000_5977000 0.024
R_VDD5_14736 METAL6_269000_5977000 METAL6_269000_6053000 0.152
R_VDD5_14737 METAL6_269000_6053000 METAL6_269000_6065000 0.024
R_VDD5_14738 METAL6_269000_6065000 METAL6_269000_6077000 0.024
R_VDD5_14739 METAL6_269000_6077000 METAL6_269000_6153000 0.152
R_VDD5_14740 METAL6_269000_6153000 METAL6_269000_6165000 0.024
R_VDD5_14741 METAL6_269000_6165000 METAL6_269000_6177000 0.024
R_VDD5_14742 METAL6_269000_6177000 METAL6_269000_6293000 0.232
R_VDD5_14743 METAL6_269000_6293000 METAL6_269000_6307000 0.028
R_VDD5_14744 METAL6_269000_6307000 METAL6_269000_6453000 0.292
R_VDD5_14745 METAL6_269000_6453000 METAL6_269000_6465000 0.024
R_VDD5_14746 METAL6_269000_6465000 METAL6_269000_6477000 0.024
R_VDD5_14747 METAL6_269000_6477000 METAL6_269000_6553000 0.152
R_VDD5_14748 METAL6_269000_6553000 METAL6_269000_6565000 0.024
R_VDD5_14749 METAL6_269000_6565000 METAL6_269000_6577000 0.024
R_VDD5_14750 METAL6_269000_6577000 METAL6_269000_6653000 0.152
R_VDD5_14751 METAL6_269000_6653000 METAL6_269000_6665000 0.024
R_VDD5_14752 METAL6_269000_6665000 METAL6_269000_6677000 0.024
R_VDD5_14753 METAL6_269000_6677000 METAL6_269000_6753000 0.152
R_VDD5_14754 METAL6_269000_6753000 METAL6_269000_6765000 0.024
R_VDD5_14755 METAL6_269000_6765000 METAL6_269000_6777000 0.024
R_VDD5_14756 METAL6_269000_6777000 METAL6_269000_6853000 0.152
R_VDD5_14757 METAL6_269000_6853000 METAL6_257000_6853000 0.024
R_VDD5_14758 METAL6_257000_6853000 METAL6_257000_6865000 0.024
R_VDD5_14759 METAL6_245000_6865000 METAL6_257000_6865000 0.024
R_VDD5_14760 METAL6_555000_6865000 METAL6_543000_6865000 0.024
R_VDD5_14761 METAL6_500000_8000 METAL6_512000_8000 0.024
R_VDD5_14762 METAL6_512000_8000 METAL6_531000_8000 0.038
R_VDD5_14763 METAL6_531000_8000 METAL6_531000_20000 0.024
R_VDD5_14764 METAL6_531000_20000 METAL6_531000_141000 0.242
R_VDD5_14765 METAL6_531000_141000 METAL6_531000_153000 0.024
R_VDD5_14766 METAL6_531000_153000 METAL6_531000_165000 0.024
R_VDD5_14767 METAL6_531000_165000 METAL6_531000_177000 0.024
R_VDD5_14768 METAL6_531000_177000 METAL6_531000_241000 0.128
R_VDD5_14769 METAL6_531000_241000 METAL6_531000_253000 0.024
R_VDD5_14770 METAL6_531000_253000 METAL6_531000_265000 0.024
R_VDD5_14771 METAL6_531000_265000 METAL6_531000_277000 0.024
R_VDD5_14772 METAL6_531000_277000 METAL6_531000_341000 0.128
R_VDD5_14773 METAL6_531000_341000 METAL6_531000_353000 0.024
R_VDD5_14774 METAL6_531000_353000 METAL6_531000_365000 0.024
R_VDD5_14775 METAL6_531000_365000 METAL6_531000_377000 0.024
R_VDD5_14776 METAL6_531000_377000 METAL6_531000_453000 0.152
R_VDD5_14777 METAL6_531000_453000 METAL6_531000_465000 0.024
R_VDD5_14778 METAL6_531000_465000 METAL6_531000_477000 0.024
R_VDD5_14779 METAL6_531000_477000 METAL6_531000_553000 0.152
R_VDD5_14780 METAL6_531000_553000 METAL6_531000_565000 0.024
R_VDD5_14781 METAL6_531000_565000 METAL6_531000_577000 0.024
R_VDD5_14782 METAL6_531000_577000 METAL6_531000_693000 0.232
R_VDD5_14783 METAL6_531000_693000 METAL6_531000_707000 0.028
R_VDD5_14784 METAL6_531000_707000 METAL6_531000_853000 0.292
R_VDD5_14785 METAL6_531000_853000 METAL6_531000_865000 0.024
R_VDD5_14786 METAL6_531000_865000 METAL6_531000_877000 0.024
R_VDD5_14787 METAL6_531000_877000 METAL6_531000_941000 0.128
R_VDD5_14788 METAL6_531000_941000 METAL6_531000_953000 0.024
R_VDD5_14789 METAL6_531000_953000 METAL6_531000_965000 0.024
R_VDD5_14790 METAL6_531000_965000 METAL6_531000_977000 0.024
R_VDD5_14791 METAL6_531000_977000 METAL6_531000_1053000 0.152
R_VDD5_14792 METAL6_531000_1053000 METAL6_531000_1065000 0.024
R_VDD5_14793 METAL6_531000_1065000 METAL6_531000_1077000 0.024
R_VDD5_14794 METAL6_531000_1077000 METAL6_531000_1153000 0.152
R_VDD5_14795 METAL6_531000_1153000 METAL6_531000_1165000 0.024
R_VDD5_14796 METAL6_531000_1165000 METAL6_531000_1177000 0.024
R_VDD5_14797 METAL6_531000_1177000 METAL6_531000_1253000 0.152
R_VDD5_14798 METAL6_531000_1253000 METAL6_531000_1265000 0.024
R_VDD5_14799 METAL6_531000_1265000 METAL6_531000_1277000 0.024
R_VDD5_14800 METAL6_531000_1277000 METAL6_531000_1393000 0.232
R_VDD5_14801 METAL6_531000_1393000 METAL6_531000_1407000 0.028
R_VDD5_14802 METAL6_531000_1407000 METAL6_531000_1553000 0.292
R_VDD5_14803 METAL6_531000_1553000 METAL6_531000_1565000 0.024
R_VDD5_14804 METAL6_531000_1565000 METAL6_531000_1577000 0.024
R_VDD5_14805 METAL6_531000_1577000 METAL6_531000_1653000 0.152
R_VDD5_14806 METAL6_531000_1653000 METAL6_531000_1665000 0.024
R_VDD5_14807 METAL6_531000_1665000 METAL6_531000_1677000 0.024
R_VDD5_14808 METAL6_531000_1677000 METAL6_531000_1753000 0.152
R_VDD5_14809 METAL6_531000_1753000 METAL6_531000_1765000 0.024
R_VDD5_14810 METAL6_531000_1765000 METAL6_531000_1777000 0.024
R_VDD5_14811 METAL6_531000_1777000 METAL6_531000_1853000 0.152
R_VDD5_14812 METAL6_531000_1853000 METAL6_531000_1865000 0.024
R_VDD5_14813 METAL6_531000_1865000 METAL6_531000_1877000 0.024
R_VDD5_14814 METAL6_531000_1877000 METAL6_531000_1953000 0.152
R_VDD5_14815 METAL6_531000_1953000 METAL6_531000_1965000 0.024
R_VDD5_14816 METAL6_531000_1965000 METAL6_531000_1977000 0.024
R_VDD5_14817 METAL6_531000_1977000 METAL6_531000_2093000 0.232
R_VDD5_14818 METAL6_531000_2093000 METAL6_531000_2107000 0.028
R_VDD5_14819 METAL6_531000_2107000 METAL6_531000_2253000 0.292
R_VDD5_14820 METAL6_531000_2253000 METAL6_531000_2265000 0.024
R_VDD5_14821 METAL6_531000_2265000 METAL6_531000_2277000 0.024
R_VDD5_14822 METAL6_531000_2277000 METAL6_531000_2353000 0.152
R_VDD5_14823 METAL6_531000_2353000 METAL6_531000_2365000 0.024
R_VDD5_14824 METAL6_531000_2365000 METAL6_531000_2377000 0.024
R_VDD5_14825 METAL6_531000_2377000 METAL6_531000_2453000 0.152
R_VDD5_14826 METAL6_531000_2453000 METAL6_531000_2465000 0.024
R_VDD5_14827 METAL6_531000_2465000 METAL6_531000_2477000 0.024
R_VDD5_14828 METAL6_531000_2477000 METAL6_531000_2553000 0.152
R_VDD5_14829 METAL6_531000_2553000 METAL6_531000_2565000 0.024
R_VDD5_14830 METAL6_531000_2565000 METAL6_531000_2577000 0.024
R_VDD5_14831 METAL6_531000_2577000 METAL6_531000_2653000 0.152
R_VDD5_14832 METAL6_531000_2653000 METAL6_531000_2665000 0.024
R_VDD5_14833 METAL6_531000_2665000 METAL6_531000_2677000 0.024
R_VDD5_14834 METAL6_531000_2677000 METAL6_531000_2793000 0.232
R_VDD5_14835 METAL6_531000_2793000 METAL6_531000_2807000 0.028
R_VDD5_14836 METAL6_531000_2807000 METAL6_531000_2953000 0.292
R_VDD5_14837 METAL6_531000_2953000 METAL6_531000_2965000 0.024
R_VDD5_14838 METAL6_531000_2965000 METAL6_531000_2977000 0.024
R_VDD5_14839 METAL6_531000_2977000 METAL6_531000_3053000 0.152
R_VDD5_14840 METAL6_531000_3053000 METAL6_531000_3065000 0.024
R_VDD5_14841 METAL6_531000_3065000 METAL6_531000_3077000 0.024
R_VDD5_14842 METAL6_531000_3077000 METAL6_531000_3153000 0.152
R_VDD5_14843 METAL6_531000_3153000 METAL6_531000_3165000 0.024
R_VDD5_14844 METAL6_531000_3165000 METAL6_531000_3177000 0.024
R_VDD5_14845 METAL6_531000_3177000 METAL6_531000_3253000 0.152
R_VDD5_14846 METAL6_531000_3253000 METAL6_531000_3265000 0.024
R_VDD5_14847 METAL6_531000_3265000 METAL6_531000_3277000 0.024
R_VDD5_14848 METAL6_531000_3277000 METAL6_531000_3353000 0.152
R_VDD5_14849 METAL6_531000_3353000 METAL6_531000_3365000 0.024
R_VDD5_14850 METAL6_531000_3365000 METAL6_531000_3377000 0.024
R_VDD5_14851 METAL6_531000_3377000 METAL6_531000_3493000 0.232
R_VDD5_14852 METAL6_531000_3493000 METAL6_531000_3507000 0.028
R_VDD5_14853 METAL6_531000_3507000 METAL6_531000_3653000 0.292
R_VDD5_14854 METAL6_531000_3653000 METAL6_531000_3665000 0.024
R_VDD5_14855 METAL6_531000_3665000 METAL6_531000_3677000 0.024
R_VDD5_14856 METAL6_531000_3677000 METAL6_531000_3753000 0.152
R_VDD5_14857 METAL6_531000_3753000 METAL6_531000_3765000 0.024
R_VDD5_14858 METAL6_531000_3765000 METAL6_531000_3777000 0.024
R_VDD5_14859 METAL6_531000_3777000 METAL6_531000_3853000 0.152
R_VDD5_14860 METAL6_531000_3853000 METAL6_531000_3865000 0.024
R_VDD5_14861 METAL6_531000_3865000 METAL6_531000_3877000 0.024
R_VDD5_14862 METAL6_531000_3877000 METAL6_531000_3953000 0.152
R_VDD5_14863 METAL6_531000_3953000 METAL6_531000_3965000 0.024
R_VDD5_14864 METAL6_531000_3965000 METAL6_531000_3977000 0.024
R_VDD5_14865 METAL6_531000_3977000 METAL6_531000_4053000 0.152
R_VDD5_14866 METAL6_531000_4053000 METAL6_531000_4065000 0.024
R_VDD5_14867 METAL6_531000_4065000 METAL6_531000_4077000 0.024
R_VDD5_14868 METAL6_531000_4077000 METAL6_531000_4193000 0.232
R_VDD5_14869 METAL6_531000_4193000 METAL6_531000_4207000 0.028
R_VDD5_14870 METAL6_531000_4207000 METAL6_531000_4353000 0.292
R_VDD5_14871 METAL6_531000_4353000 METAL6_531000_4365000 0.024
R_VDD5_14872 METAL6_531000_4365000 METAL6_531000_4377000 0.024
R_VDD5_14873 METAL6_531000_4377000 METAL6_531000_4453000 0.152
R_VDD5_14874 METAL6_531000_4453000 METAL6_531000_4465000 0.024
R_VDD5_14875 METAL6_531000_4465000 METAL6_531000_4477000 0.024
R_VDD5_14876 METAL6_531000_4477000 METAL6_531000_4553000 0.152
R_VDD5_14877 METAL6_531000_4553000 METAL6_531000_4565000 0.024
R_VDD5_14878 METAL6_531000_4565000 METAL6_531000_4577000 0.024
R_VDD5_14879 METAL6_531000_4577000 METAL6_531000_4653000 0.152
R_VDD5_14880 METAL6_531000_4653000 METAL6_531000_4665000 0.024
R_VDD5_14881 METAL6_531000_4665000 METAL6_531000_4677000 0.024
R_VDD5_14882 METAL6_531000_4677000 METAL6_531000_4753000 0.152
R_VDD5_14883 METAL6_531000_4753000 METAL6_531000_4765000 0.024
R_VDD5_14884 METAL6_531000_4765000 METAL6_531000_4777000 0.024
R_VDD5_14885 METAL6_531000_4777000 METAL6_531000_4893000 0.232
R_VDD5_14886 METAL6_531000_4893000 METAL6_531000_4907000 0.028
R_VDD5_14887 METAL6_531000_4907000 METAL6_531000_5053000 0.292
R_VDD5_14888 METAL6_531000_5053000 METAL6_531000_5065000 0.024
R_VDD5_14889 METAL6_531000_5065000 METAL6_531000_5077000 0.024
R_VDD5_14890 METAL6_531000_5077000 METAL6_531000_5153000 0.152
R_VDD5_14891 METAL6_531000_5153000 METAL6_531000_5165000 0.024
R_VDD5_14892 METAL6_531000_5165000 METAL6_531000_5177000 0.024
R_VDD5_14893 METAL6_531000_5177000 METAL6_531000_5253000 0.152
R_VDD5_14894 METAL6_531000_5253000 METAL6_531000_5265000 0.024
R_VDD5_14895 METAL6_531000_5265000 METAL6_531000_5277000 0.024
R_VDD5_14896 METAL6_531000_5277000 METAL6_531000_5353000 0.152
R_VDD5_14897 METAL6_531000_5353000 METAL6_531000_5365000 0.024
R_VDD5_14898 METAL6_531000_5365000 METAL6_531000_5377000 0.024
R_VDD5_14899 METAL6_531000_5377000 METAL6_531000_5453000 0.152
R_VDD5_14900 METAL6_531000_5453000 METAL6_531000_5465000 0.024
R_VDD5_14901 METAL6_531000_5465000 METAL6_531000_5477000 0.024
R_VDD5_14902 METAL6_531000_5477000 METAL6_531000_5593000 0.232
R_VDD5_14903 METAL6_531000_5593000 METAL6_531000_5607000 0.028
R_VDD5_14904 METAL6_531000_5607000 METAL6_531000_5753000 0.292
R_VDD5_14905 METAL6_531000_5753000 METAL6_531000_5765000 0.024
R_VDD5_14906 METAL6_531000_5765000 METAL6_531000_5777000 0.024
R_VDD5_14907 METAL6_531000_5777000 METAL6_531000_5853000 0.152
R_VDD5_14908 METAL6_531000_5853000 METAL6_531000_5865000 0.024
R_VDD5_14909 METAL6_531000_5865000 METAL6_531000_5877000 0.024
R_VDD5_14910 METAL6_531000_5877000 METAL6_531000_5953000 0.152
R_VDD5_14911 METAL6_531000_5953000 METAL6_531000_5965000 0.024
R_VDD5_14912 METAL6_531000_5965000 METAL6_531000_5977000 0.024
R_VDD5_14913 METAL6_531000_5977000 METAL6_531000_6053000 0.152
R_VDD5_14914 METAL6_531000_6053000 METAL6_531000_6065000 0.024
R_VDD5_14915 METAL6_531000_6065000 METAL6_531000_6077000 0.024
R_VDD5_14916 METAL6_531000_6077000 METAL6_531000_6153000 0.152
R_VDD5_14917 METAL6_531000_6153000 METAL6_531000_6165000 0.024
R_VDD5_14918 METAL6_531000_6165000 METAL6_531000_6177000 0.024
R_VDD5_14919 METAL6_531000_6177000 METAL6_531000_6293000 0.232
R_VDD5_14920 METAL6_531000_6293000 METAL6_531000_6307000 0.028
R_VDD5_14921 METAL6_531000_6307000 METAL6_531000_6453000 0.292
R_VDD5_14922 METAL6_531000_6453000 METAL6_531000_6465000 0.024
R_VDD5_14923 METAL6_531000_6465000 METAL6_531000_6477000 0.024
R_VDD5_14924 METAL6_531000_6477000 METAL6_531000_6553000 0.152
R_VDD5_14925 METAL6_531000_6553000 METAL6_531000_6565000 0.024
R_VDD5_14926 METAL6_531000_6565000 METAL6_531000_6577000 0.024
R_VDD5_14927 METAL6_531000_6577000 METAL6_531000_6653000 0.152
R_VDD5_14928 METAL6_531000_6653000 METAL6_531000_6665000 0.024
R_VDD5_14929 METAL6_531000_6665000 METAL6_531000_6677000 0.024
R_VDD5_14930 METAL6_531000_6677000 METAL6_531000_6753000 0.152
R_VDD5_14931 METAL6_531000_6753000 METAL6_531000_6765000 0.024
R_VDD5_14932 METAL6_531000_6765000 METAL6_531000_6777000 0.024
R_VDD5_14933 METAL6_531000_6777000 METAL6_531000_6841000 0.128
R_VDD5_14934 METAL6_531000_6841000 METAL6_543000_6841000 0.024
R_VDD5_14935 METAL6_543000_6841000 METAL6_543000_6853000 0.024
R_VDD5_14936 METAL6_543000_6853000 METAL6_543000_6865000 0.024
R_VDD5_14937 METAL6_245000_6165000 METAL6_257000_6165000 0.024
R_VDD5_14938 METAL6_500000_8000 METAL6_488000_8000 0.024
R_VDD5_14939 METAL6_488000_8000 METAL6_474000_8000 0.028
R_VDD5_14940 METAL6_474000_8000 METAL6_474000_20000 0.024
R_VDD5_14941 METAL6_474000_20000 METAL6_474000_141000 0.242
R_VDD5_14942 METAL6_474000_141000 METAL5_474000_141000 0.1
R_VDD5_14943 METAL5_474000_141000 METAL5_474000_153000 0.048
R_VDD5_14944 METAL5_474000_153000 METAL5_474000_165000 0.048
R_VDD5_14945 METAL5_474000_165000 METAL6_474000_165000 0.1
R_VDD5_14946 METAL6_474000_165000 METAL6_474000_177000 0.024
R_VDD5_14947 METAL6_474000_177000 METAL6_474000_241000 0.128
R_VDD5_14948 METAL6_474000_241000 METAL6_474000_253000 0.024
R_VDD5_14949 METAL6_474000_253000 METAL6_474000_265000 0.024
R_VDD5_14950 METAL6_474000_265000 METAL6_462000_265000 0.024
R_VDD5_14951 METAL6_462000_265000 METAL6_462000_277000 0.024
R_VDD5_14952 METAL6_462000_277000 METAL6_462000_341000 0.128
R_VDD5_14953 METAL6_462000_341000 METAL6_462000_353000 0.024
R_VDD5_14954 METAL6_462000_353000 METAL6_462000_365000 0.024
R_VDD5_14955 METAL6_462000_365000 METAL6_462000_377000 0.024
R_VDD5_14956 METAL6_462000_377000 METAL6_462000_453000 0.152
R_VDD5_14957 METAL6_462000_453000 METAL6_450000_453000 0.024
R_VDD5_14958 METAL6_450000_453000 METAL6_450000_465000 0.024
R_VDD5_14959 METAL6_450000_465000 METAL6_450000_477000 0.024
R_VDD5_14960 METAL6_450000_477000 METAL6_450000_553000 0.152
R_VDD5_14961 METAL6_450000_553000 METAL6_450000_565000 0.024
R_VDD5_14962 METAL6_450000_565000 METAL6_438000_565000 0.024
R_VDD5_14963 METAL6_438000_565000 METAL6_412000_565000 0.052
R_VDD5_14964 METAL6_412000_565000 METAL6_412000_577000 0.024
R_VDD5_14965 METAL6_412000_577000 METAL6_412000_693000 0.232
R_VDD5_14966 METAL6_412000_693000 METAL6_412000_707000 0.028
R_VDD5_14967 METAL6_412000_707000 METAL6_412000_853000 0.292
R_VDD5_14968 METAL6_412000_853000 METAL6_400000_853000 0.024
R_VDD5_14969 METAL6_400000_853000 METAL6_400000_865000 0.024
R_VDD5_14970 METAL6_400000_865000 METAL6_388000_865000 0.024
R_VDD5_14971 METAL6_388000_865000 METAL6_374000_865000 0.028
R_VDD5_14972 METAL6_374000_865000 METAL6_362000_865000 0.024
R_VDD5_14973 METAL6_362000_865000 METAL6_362000_877000 0.024
R_VDD5_14974 METAL6_362000_877000 METAL6_362000_941000 0.128
R_VDD5_14975 METAL6_362000_941000 METAL6_350000_941000 0.024
R_VDD5_14976 METAL6_350000_941000 METAL6_338000_941000 0.024
R_VDD5_14977 METAL6_338000_941000 METAL6_324000_941000 0.028
R_VDD5_14978 METAL6_324000_941000 METAL6_312000_941000 0.024
R_VDD5_14979 METAL6_312000_941000 METAL6_312000_953000 0.024
R_VDD5_14980 METAL6_312000_953000 METAL6_312000_965000 0.024
R_VDD5_14981 METAL6_312000_965000 METAL6_312000_977000 0.024
R_VDD5_14982 METAL6_312000_977000 METAL6_312000_1053000 0.152
R_VDD5_14983 METAL6_312000_1053000 METAL6_300000_1053000 0.024
R_VDD5_14984 METAL6_300000_1053000 METAL6_300000_1065000 0.024
R_VDD5_14985 METAL6_300000_1065000 METAL6_300000_1077000 0.024
R_VDD5_14986 METAL6_300000_1077000 METAL6_300000_1153000 0.152
R_VDD5_14987 METAL6_300000_1153000 METAL6_300000_1165000 0.024
R_VDD5_14988 METAL6_300000_1165000 METAL6_300000_1177000 0.024
R_VDD5_14989 METAL6_300000_1177000 METAL6_300000_1253000 0.152
R_VDD5_14990 METAL6_300000_1253000 METAL6_300000_1265000 0.024
R_VDD5_14991 METAL6_300000_1265000 METAL6_300000_1277000 0.024
R_VDD5_14992 METAL6_300000_1277000 METAL6_300000_1393000 0.232
R_VDD5_14993 METAL6_300000_1393000 METAL6_300000_1407000 0.028
R_VDD5_14994 METAL6_300000_1407000 METAL6_300000_1553000 0.292
R_VDD5_14995 METAL6_300000_1553000 METAL6_300000_1565000 0.024
R_VDD5_14996 METAL6_300000_1565000 METAL6_300000_1577000 0.024
R_VDD5_14997 METAL6_300000_1577000 METAL6_300000_1653000 0.152
R_VDD5_14998 METAL6_300000_1653000 METAL6_300000_1665000 0.024
R_VDD5_14999 METAL6_300000_1665000 METAL6_300000_1677000 0.024
R_VDD5_15000 METAL6_300000_1677000 METAL6_300000_1753000 0.152
R_VDD5_15001 METAL6_300000_1753000 METAL6_300000_1765000 0.024
R_VDD5_15002 METAL6_300000_1765000 METAL6_300000_1777000 0.024
R_VDD5_15003 METAL6_300000_1777000 METAL6_300000_1853000 0.152
R_VDD5_15004 METAL6_300000_1853000 METAL6_288000_1853000 0.024
R_VDD5_15005 METAL6_288000_1853000 METAL6_288000_1865000 0.024
R_VDD5_15006 METAL6_288000_1865000 METAL6_288000_1877000 0.024
R_VDD5_15007 METAL6_288000_1877000 METAL6_288000_1953000 0.152
R_VDD5_15008 METAL6_288000_1953000 METAL6_288000_1965000 0.024
R_VDD5_15009 METAL6_288000_1965000 METAL6_288000_1977000 0.024
R_VDD5_15010 METAL6_288000_1977000 METAL6_288000_2093000 0.232
R_VDD5_15011 METAL6_288000_2093000 METAL6_288000_2107000 0.028
R_VDD5_15012 METAL6_288000_2107000 METAL6_288000_2253000 0.292
R_VDD5_15013 METAL6_288000_2253000 METAL6_288000_2265000 0.024
R_VDD5_15014 METAL6_288000_2265000 METAL6_288000_2277000 0.024
R_VDD5_15015 METAL6_288000_2277000 METAL6_288000_2353000 0.152
R_VDD5_15016 METAL6_288000_2353000 METAL6_288000_2365000 0.024
R_VDD5_15017 METAL6_288000_2365000 METAL6_288000_2377000 0.024
R_VDD5_15018 METAL6_288000_2377000 METAL6_288000_2453000 0.152
R_VDD5_15019 METAL6_288000_2453000 METAL6_288000_2465000 0.024
R_VDD5_15020 METAL6_288000_2465000 METAL6_288000_2477000 0.024
R_VDD5_15021 METAL6_288000_2477000 METAL6_288000_2553000 0.152
R_VDD5_15022 METAL6_288000_2553000 METAL6_288000_2565000 0.024
R_VDD5_15023 METAL6_288000_2565000 METAL6_288000_2577000 0.024
R_VDD5_15024 METAL6_288000_2577000 METAL6_288000_2653000 0.152
R_VDD5_15025 METAL6_288000_2653000 METAL6_288000_2665000 0.024
R_VDD5_15026 METAL6_288000_2665000 METAL6_288000_2677000 0.024
R_VDD5_15027 METAL6_288000_2677000 METAL6_288000_2793000 0.232
R_VDD5_15028 METAL6_288000_2793000 METAL6_288000_2807000 0.028
R_VDD5_15029 METAL6_288000_2807000 METAL6_288000_2953000 0.292
R_VDD5_15030 METAL6_288000_2953000 METAL6_288000_2965000 0.024
R_VDD5_15031 METAL6_288000_2965000 METAL6_288000_2977000 0.024
R_VDD5_15032 METAL6_288000_2977000 METAL6_288000_3053000 0.152
R_VDD5_15033 METAL6_288000_3053000 METAL6_288000_3065000 0.024
R_VDD5_15034 METAL6_288000_3065000 METAL6_288000_3077000 0.024
R_VDD5_15035 METAL6_288000_3077000 METAL6_288000_3153000 0.152
R_VDD5_15036 METAL6_288000_3153000 METAL6_288000_3165000 0.024
R_VDD5_15037 METAL6_288000_3165000 METAL6_288000_3177000 0.024
R_VDD5_15038 METAL6_288000_3177000 METAL6_288000_3253000 0.152
R_VDD5_15039 METAL6_288000_3253000 METAL6_288000_3265000 0.024
R_VDD5_15040 METAL6_288000_3265000 METAL6_288000_3277000 0.024
R_VDD5_15041 METAL6_288000_3277000 METAL6_288000_3353000 0.152
R_VDD5_15042 METAL6_288000_3353000 METAL6_288000_3365000 0.024
R_VDD5_15043 METAL6_288000_3365000 METAL6_288000_3377000 0.024
R_VDD5_15044 METAL6_288000_3377000 METAL6_288000_3493000 0.232
R_VDD5_15045 METAL6_288000_3493000 METAL6_288000_3507000 0.028
R_VDD5_15046 METAL6_288000_3507000 METAL6_288000_3653000 0.292
R_VDD5_15047 METAL6_288000_3653000 METAL6_288000_3665000 0.024
R_VDD5_15048 METAL6_288000_3665000 METAL6_288000_3677000 0.024
R_VDD5_15049 METAL6_288000_3677000 METAL6_288000_3753000 0.152
R_VDD5_15050 METAL6_288000_3753000 METAL6_288000_3765000 0.024
R_VDD5_15051 METAL6_288000_3765000 METAL6_288000_3777000 0.024
R_VDD5_15052 METAL6_288000_3777000 METAL6_288000_3853000 0.152
R_VDD5_15053 METAL6_288000_3853000 METAL6_288000_3865000 0.024
R_VDD5_15054 METAL6_288000_3865000 METAL6_288000_3877000 0.024
R_VDD5_15055 METAL6_288000_3877000 METAL6_288000_3953000 0.152
R_VDD5_15056 METAL6_288000_3953000 METAL6_288000_3965000 0.024
R_VDD5_15057 METAL6_288000_3965000 METAL6_288000_3977000 0.024
R_VDD5_15058 METAL6_288000_3977000 METAL6_288000_4053000 0.152
R_VDD5_15059 METAL6_288000_4053000 METAL6_288000_4065000 0.024
R_VDD5_15060 METAL6_288000_4065000 METAL6_288000_4077000 0.024
R_VDD5_15061 METAL6_288000_4077000 METAL6_288000_4193000 0.232
R_VDD5_15062 METAL6_288000_4193000 METAL6_288000_4207000 0.028
R_VDD5_15063 METAL6_288000_4207000 METAL6_288000_4353000 0.292
R_VDD5_15064 METAL6_288000_4353000 METAL6_288000_4365000 0.024
R_VDD5_15065 METAL6_288000_4365000 METAL6_288000_4377000 0.024
R_VDD5_15066 METAL6_288000_4377000 METAL6_288000_4453000 0.152
R_VDD5_15067 METAL6_288000_4453000 METAL6_288000_4465000 0.024
R_VDD5_15068 METAL6_288000_4465000 METAL6_288000_4477000 0.024
R_VDD5_15069 METAL6_288000_4477000 METAL6_288000_4553000 0.152
R_VDD5_15070 METAL6_288000_4553000 METAL6_288000_4565000 0.024
R_VDD5_15071 METAL6_288000_4565000 METAL6_288000_4577000 0.024
R_VDD5_15072 METAL6_288000_4577000 METAL6_288000_4653000 0.152
R_VDD5_15073 METAL6_288000_4653000 METAL6_288000_4665000 0.024
R_VDD5_15074 METAL6_288000_4665000 METAL6_288000_4677000 0.024
R_VDD5_15075 METAL6_288000_4677000 METAL6_288000_4753000 0.152
R_VDD5_15076 METAL6_288000_4753000 METAL6_288000_4765000 0.024
R_VDD5_15077 METAL6_288000_4765000 METAL6_288000_4777000 0.024
R_VDD5_15078 METAL6_288000_4777000 METAL6_288000_4893000 0.232
R_VDD5_15079 METAL6_288000_4893000 METAL6_288000_4907000 0.028
R_VDD5_15080 METAL6_288000_4907000 METAL6_288000_5053000 0.292
R_VDD5_15081 METAL6_288000_5053000 METAL6_288000_5065000 0.024
R_VDD5_15082 METAL6_288000_5065000 METAL6_288000_5077000 0.024
R_VDD5_15083 METAL6_288000_5077000 METAL6_288000_5153000 0.152
R_VDD5_15084 METAL6_288000_5153000 METAL6_288000_5165000 0.024
R_VDD5_15085 METAL6_288000_5165000 METAL6_288000_5177000 0.024
R_VDD5_15086 METAL6_288000_5177000 METAL6_288000_5253000 0.152
R_VDD5_15087 METAL6_288000_5253000 METAL6_288000_5265000 0.024
R_VDD5_15088 METAL6_288000_5265000 METAL6_288000_5277000 0.024
R_VDD5_15089 METAL6_288000_5277000 METAL6_288000_5353000 0.152
R_VDD5_15090 METAL6_288000_5353000 METAL6_288000_5365000 0.024
R_VDD5_15091 METAL6_288000_5365000 METAL6_288000_5377000 0.024
R_VDD5_15092 METAL6_288000_5377000 METAL6_288000_5453000 0.152
R_VDD5_15093 METAL6_288000_5453000 METAL6_288000_5465000 0.024
R_VDD5_15094 METAL6_288000_5465000 METAL6_288000_5477000 0.024
R_VDD5_15095 METAL6_288000_5477000 METAL6_288000_5593000 0.232
R_VDD5_15096 METAL6_288000_5593000 METAL6_288000_5607000 0.028
R_VDD5_15097 METAL6_288000_5607000 METAL6_288000_5753000 0.292
R_VDD5_15098 METAL6_288000_5753000 METAL6_288000_5765000 0.024
R_VDD5_15099 METAL6_288000_5765000 METAL6_288000_5777000 0.024
R_VDD5_15100 METAL6_288000_5777000 METAL6_288000_5853000 0.152
R_VDD5_15101 METAL6_288000_5853000 METAL6_288000_5865000 0.024
R_VDD5_15102 METAL6_288000_5865000 METAL6_288000_5877000 0.024
R_VDD5_15103 METAL6_288000_5877000 METAL6_288000_5953000 0.152
R_VDD5_15104 METAL6_288000_5953000 METAL6_288000_5965000 0.024
R_VDD5_15105 METAL6_288000_5965000 METAL6_288000_5977000 0.024
R_VDD5_15106 METAL6_288000_5977000 METAL6_288000_6053000 0.152
R_VDD5_15107 METAL6_288000_6053000 METAL6_288000_6065000 0.024
R_VDD5_15108 METAL6_288000_6065000 METAL6_288000_6077000 0.024
R_VDD5_15109 METAL6_288000_6077000 METAL6_288000_6153000 0.152
R_VDD5_15110 METAL6_288000_6153000 METAL6_288000_6165000 0.024
R_VDD5_15111 METAL6_288000_6165000 METAL6_281000_6165000 0.014
R_VDD5_15112 METAL6_281000_6165000 METAL5_281000_6165000 0.1
R_VDD5_15113 METAL5_281000_6165000 METAL5_269000_6165000 0.048
R_VDD5_15114 METAL5_269000_6165000 METAL5_257000_6165000 0.048
R_VDD5_15115 METAL5_257000_6165000 METAL6_257000_6165000 0.1
R_VDD5_15116 METAL6_555000_6165000 METAL6_543000_6165000 0.024
R_VDD5_15117 METAL6_500000_8000 METAL5_500000_8000 0.1
R_VDD5_15118 METAL5_500000_8000 METAL5_512000_8000 0.048
R_VDD5_15119 METAL5_512000_8000 METAL5_512000_20000 0.048
R_VDD5_15120 METAL5_512000_20000 METAL6_512000_20000 0.1
R_VDD5_15121 METAL6_512000_20000 METAL6_512000_129000 0.218
R_VDD5_15122 METAL6_512000_129000 METAL6_512000_141000 0.024
R_VDD5_15123 METAL6_512000_141000 METAL6_512000_153000 0.024
R_VDD5_15124 METAL6_512000_153000 METAL6_512000_165000 0.024
R_VDD5_15125 METAL6_512000_165000 METAL6_512000_177000 0.024
R_VDD5_15126 METAL6_512000_177000 METAL6_512000_241000 0.128
R_VDD5_15127 METAL6_512000_241000 METAL6_512000_253000 0.024
R_VDD5_15128 METAL6_512000_253000 METAL6_512000_265000 0.024
R_VDD5_15129 METAL6_512000_265000 METAL6_512000_277000 0.024
R_VDD5_15130 METAL6_512000_277000 METAL6_512000_341000 0.128
R_VDD5_15131 METAL6_512000_341000 METAL6_512000_353000 0.024
R_VDD5_15132 METAL6_512000_353000 METAL6_512000_365000 0.024
R_VDD5_15133 METAL6_512000_365000 METAL6_512000_377000 0.024
R_VDD5_15134 METAL6_512000_377000 METAL6_512000_441000 0.128
R_VDD5_15135 METAL6_512000_441000 METAL6_512000_453000 0.024
R_VDD5_15136 METAL6_512000_453000 METAL6_512000_465000 0.024
R_VDD5_15137 METAL6_512000_465000 METAL6_512000_477000 0.024
R_VDD5_15138 METAL6_512000_477000 METAL6_512000_553000 0.152
R_VDD5_15139 METAL6_512000_553000 METAL6_512000_565000 0.024
R_VDD5_15140 METAL6_512000_565000 METAL6_512000_577000 0.024
R_VDD5_15141 METAL6_512000_577000 METAL6_512000_693000 0.232
R_VDD5_15142 METAL6_512000_693000 METAL6_512000_707000 0.028
R_VDD5_15143 METAL6_512000_707000 METAL6_512000_841000 0.268
R_VDD5_15144 METAL6_512000_841000 METAL6_512000_853000 0.024
R_VDD5_15145 METAL6_512000_853000 METAL6_512000_865000 0.024
R_VDD5_15146 METAL6_512000_865000 METAL6_512000_877000 0.024
R_VDD5_15147 METAL6_512000_877000 METAL6_512000_929000 0.104
R_VDD5_15148 METAL6_512000_929000 METAL6_512000_941000 0.024
R_VDD5_15149 METAL6_512000_941000 METAL6_512000_953000 0.024
R_VDD5_15150 METAL6_512000_953000 METAL6_512000_965000 0.024
R_VDD5_15151 METAL6_512000_965000 METAL6_512000_977000 0.024
R_VDD5_15152 METAL6_512000_977000 METAL6_512000_1041000 0.128
R_VDD5_15153 METAL6_512000_1041000 METAL6_512000_1053000 0.024
R_VDD5_15154 METAL6_512000_1053000 METAL6_512000_1065000 0.024
R_VDD5_15155 METAL6_512000_1065000 METAL6_512000_1077000 0.024
R_VDD5_15156 METAL6_512000_1077000 METAL6_512000_1153000 0.152
R_VDD5_15157 METAL6_512000_1153000 METAL6_512000_1165000 0.024
R_VDD5_15158 METAL6_512000_1165000 METAL6_512000_1177000 0.024
R_VDD5_15159 METAL6_512000_1177000 METAL6_512000_1253000 0.152
R_VDD5_15160 METAL6_512000_1253000 METAL6_512000_1265000 0.024
R_VDD5_15161 METAL6_512000_1265000 METAL6_512000_1277000 0.024
R_VDD5_15162 METAL6_512000_1277000 METAL6_512000_1393000 0.232
R_VDD5_15163 METAL6_512000_1393000 METAL6_512000_1407000 0.028
R_VDD5_15164 METAL6_512000_1407000 METAL6_512000_1553000 0.292
R_VDD5_15165 METAL6_512000_1553000 METAL6_512000_1565000 0.024
R_VDD5_15166 METAL6_512000_1565000 METAL6_512000_1577000 0.024
R_VDD5_15167 METAL6_512000_1577000 METAL6_512000_1653000 0.152
R_VDD5_15168 METAL6_512000_1653000 METAL6_512000_1665000 0.024
R_VDD5_15169 METAL6_512000_1665000 METAL6_512000_1677000 0.024
R_VDD5_15170 METAL6_512000_1677000 METAL6_512000_1753000 0.152
R_VDD5_15171 METAL6_512000_1753000 METAL6_512000_1765000 0.024
R_VDD5_15172 METAL6_512000_1765000 METAL6_512000_1777000 0.024
R_VDD5_15173 METAL6_512000_1777000 METAL6_512000_1841000 0.128
R_VDD5_15174 METAL6_512000_1841000 METAL6_512000_1853000 0.024
R_VDD5_15175 METAL6_512000_1853000 METAL6_512000_1865000 0.024
R_VDD5_15176 METAL6_512000_1865000 METAL6_512000_1877000 0.024
R_VDD5_15177 METAL6_512000_1877000 METAL6_512000_1953000 0.152
R_VDD5_15178 METAL6_512000_1953000 METAL6_512000_1965000 0.024
R_VDD5_15179 METAL6_512000_1965000 METAL6_512000_1977000 0.024
R_VDD5_15180 METAL6_512000_1977000 METAL6_512000_2093000 0.232
R_VDD5_15181 METAL6_512000_2093000 METAL6_512000_2107000 0.028
R_VDD5_15182 METAL6_512000_2107000 METAL6_512000_2253000 0.292
R_VDD5_15183 METAL6_512000_2253000 METAL6_512000_2265000 0.024
R_VDD5_15184 METAL6_512000_2265000 METAL6_512000_2277000 0.024
R_VDD5_15185 METAL6_512000_2277000 METAL6_512000_2353000 0.152
R_VDD5_15186 METAL6_512000_2353000 METAL6_512000_2365000 0.024
R_VDD5_15187 METAL6_512000_2365000 METAL6_512000_2377000 0.024
R_VDD5_15188 METAL6_512000_2377000 METAL6_512000_2453000 0.152
R_VDD5_15189 METAL6_512000_2453000 METAL6_512000_2465000 0.024
R_VDD5_15190 METAL6_512000_2465000 METAL6_512000_2477000 0.024
R_VDD5_15191 METAL6_512000_2477000 METAL6_512000_2553000 0.152
R_VDD5_15192 METAL6_512000_2553000 METAL6_512000_2565000 0.024
R_VDD5_15193 METAL6_512000_2565000 METAL6_512000_2577000 0.024
R_VDD5_15194 METAL6_512000_2577000 METAL6_512000_2653000 0.152
R_VDD5_15195 METAL6_512000_2653000 METAL6_512000_2665000 0.024
R_VDD5_15196 METAL6_512000_2665000 METAL6_512000_2677000 0.024
R_VDD5_15197 METAL6_512000_2677000 METAL6_512000_2793000 0.232
R_VDD5_15198 METAL6_512000_2793000 METAL6_512000_2807000 0.028
R_VDD5_15199 METAL6_512000_2807000 METAL6_512000_2953000 0.292
R_VDD5_15200 METAL6_512000_2953000 METAL6_512000_2965000 0.024
R_VDD5_15201 METAL6_512000_2965000 METAL6_512000_2977000 0.024
R_VDD5_15202 METAL6_512000_2977000 METAL6_512000_3053000 0.152
R_VDD5_15203 METAL6_512000_3053000 METAL6_512000_3065000 0.024
R_VDD5_15204 METAL6_512000_3065000 METAL6_512000_3077000 0.024
R_VDD5_15205 METAL6_512000_3077000 METAL6_512000_3153000 0.152
R_VDD5_15206 METAL6_512000_3153000 METAL6_512000_3165000 0.024
R_VDD5_15207 METAL6_512000_3165000 METAL6_512000_3177000 0.024
R_VDD5_15208 METAL6_512000_3177000 METAL6_512000_3253000 0.152
R_VDD5_15209 METAL6_512000_3253000 METAL6_512000_3265000 0.024
R_VDD5_15210 METAL6_512000_3265000 METAL6_512000_3277000 0.024
R_VDD5_15211 METAL6_512000_3277000 METAL6_512000_3353000 0.152
R_VDD5_15212 METAL6_512000_3353000 METAL6_512000_3365000 0.024
R_VDD5_15213 METAL6_512000_3365000 METAL6_512000_3377000 0.024
R_VDD5_15214 METAL6_512000_3377000 METAL6_512000_3493000 0.232
R_VDD5_15215 METAL6_512000_3493000 METAL6_512000_3507000 0.028
R_VDD5_15216 METAL6_512000_3507000 METAL6_512000_3653000 0.292
R_VDD5_15217 METAL6_512000_3653000 METAL6_512000_3665000 0.024
R_VDD5_15218 METAL6_512000_3665000 METAL6_512000_3677000 0.024
R_VDD5_15219 METAL6_512000_3677000 METAL6_512000_3753000 0.152
R_VDD5_15220 METAL6_512000_3753000 METAL6_512000_3765000 0.024
R_VDD5_15221 METAL6_512000_3765000 METAL6_512000_3777000 0.024
R_VDD5_15222 METAL6_512000_3777000 METAL6_512000_3853000 0.152
R_VDD5_15223 METAL6_512000_3853000 METAL6_512000_3865000 0.024
R_VDD5_15224 METAL6_512000_3865000 METAL6_512000_3877000 0.024
R_VDD5_15225 METAL6_512000_3877000 METAL6_512000_3953000 0.152
R_VDD5_15226 METAL6_512000_3953000 METAL6_512000_3965000 0.024
R_VDD5_15227 METAL6_512000_3965000 METAL6_512000_3977000 0.024
R_VDD5_15228 METAL6_512000_3977000 METAL6_512000_4053000 0.152
R_VDD5_15229 METAL6_512000_4053000 METAL6_512000_4065000 0.024
R_VDD5_15230 METAL6_512000_4065000 METAL6_512000_4077000 0.024
R_VDD5_15231 METAL6_512000_4077000 METAL6_512000_4193000 0.232
R_VDD5_15232 METAL6_512000_4193000 METAL6_512000_4207000 0.028
R_VDD5_15233 METAL6_512000_4207000 METAL6_512000_4353000 0.292
R_VDD5_15234 METAL6_512000_4353000 METAL6_512000_4365000 0.024
R_VDD5_15235 METAL6_512000_4365000 METAL6_512000_4377000 0.024
R_VDD5_15236 METAL6_512000_4377000 METAL6_512000_4453000 0.152
R_VDD5_15237 METAL6_512000_4453000 METAL6_512000_4465000 0.024
R_VDD5_15238 METAL6_512000_4465000 METAL6_512000_4477000 0.024
R_VDD5_15239 METAL6_512000_4477000 METAL6_512000_4553000 0.152
R_VDD5_15240 METAL6_512000_4553000 METAL6_512000_4565000 0.024
R_VDD5_15241 METAL6_512000_4565000 METAL6_512000_4577000 0.024
R_VDD5_15242 METAL6_512000_4577000 METAL6_512000_4653000 0.152
R_VDD5_15243 METAL6_512000_4653000 METAL6_512000_4665000 0.024
R_VDD5_15244 METAL6_512000_4665000 METAL6_512000_4677000 0.024
R_VDD5_15245 METAL6_512000_4677000 METAL6_512000_4753000 0.152
R_VDD5_15246 METAL6_512000_4753000 METAL6_512000_4765000 0.024
R_VDD5_15247 METAL6_512000_4765000 METAL6_512000_4777000 0.024
R_VDD5_15248 METAL6_512000_4777000 METAL6_512000_4893000 0.232
R_VDD5_15249 METAL6_512000_4893000 METAL6_512000_4907000 0.028
R_VDD5_15250 METAL6_512000_4907000 METAL6_512000_5053000 0.292
R_VDD5_15251 METAL6_512000_5053000 METAL6_512000_5065000 0.024
R_VDD5_15252 METAL6_512000_5065000 METAL6_512000_5077000 0.024
R_VDD5_15253 METAL6_512000_5077000 METAL6_512000_5153000 0.152
R_VDD5_15254 METAL6_512000_5153000 METAL6_512000_5165000 0.024
R_VDD5_15255 METAL6_512000_5165000 METAL6_512000_5177000 0.024
R_VDD5_15256 METAL6_512000_5177000 METAL6_512000_5253000 0.152
R_VDD5_15257 METAL6_512000_5253000 METAL6_512000_5265000 0.024
R_VDD5_15258 METAL6_512000_5265000 METAL6_512000_5277000 0.024
R_VDD5_15259 METAL6_512000_5277000 METAL6_512000_5353000 0.152
R_VDD5_15260 METAL6_512000_5353000 METAL6_512000_5365000 0.024
R_VDD5_15261 METAL6_512000_5365000 METAL6_512000_5377000 0.024
R_VDD5_15262 METAL6_512000_5377000 METAL6_512000_5453000 0.152
R_VDD5_15263 METAL6_512000_5453000 METAL6_512000_5465000 0.024
R_VDD5_15264 METAL6_512000_5465000 METAL6_512000_5477000 0.024
R_VDD5_15265 METAL6_512000_5477000 METAL6_512000_5593000 0.232
R_VDD5_15266 METAL6_512000_5593000 METAL6_512000_5607000 0.028
R_VDD5_15267 METAL6_512000_5607000 METAL6_512000_5753000 0.292
R_VDD5_15268 METAL6_512000_5753000 METAL6_512000_5765000 0.024
R_VDD5_15269 METAL6_512000_5765000 METAL6_512000_5777000 0.024
R_VDD5_15270 METAL6_512000_5777000 METAL6_512000_5853000 0.152
R_VDD5_15271 METAL6_512000_5853000 METAL6_512000_5865000 0.024
R_VDD5_15272 METAL6_512000_5865000 METAL6_512000_5877000 0.024
R_VDD5_15273 METAL6_512000_5877000 METAL6_512000_5953000 0.152
R_VDD5_15274 METAL6_512000_5953000 METAL6_512000_5965000 0.024
R_VDD5_15275 METAL6_512000_5965000 METAL6_512000_5977000 0.024
R_VDD5_15276 METAL6_512000_5977000 METAL6_512000_6053000 0.152
R_VDD5_15277 METAL6_512000_6053000 METAL6_512000_6065000 0.024
R_VDD5_15278 METAL6_512000_6065000 METAL6_512000_6077000 0.024
R_VDD5_15279 METAL6_512000_6077000 METAL6_512000_6153000 0.152
R_VDD5_15280 METAL6_512000_6153000 METAL6_512000_6165000 0.024
R_VDD5_15281 METAL6_512000_6165000 METAL6_519000_6165000 0.014
R_VDD5_15282 METAL6_519000_6165000 METAL5_519000_6165000 0.1
R_VDD5_15283 METAL5_519000_6165000 METAL5_531000_6165000 0.048
R_VDD5_15284 METAL5_531000_6165000 METAL5_543000_6165000 0.048
R_VDD5_15285 METAL5_543000_6165000 METAL6_543000_6165000 0.1
R_VDD5_15286 METAL6_245000_5465000 METAL6_257000_5465000 0.024
R_VDD5_15287 METAL5_500000_8000 METAL5_488000_8000 0.048
R_VDD5_15288 METAL5_488000_8000 METAL5_488000_20000 0.048
R_VDD5_15289 METAL5_488000_20000 METAL6_488000_20000 0.1
R_VDD5_15290 METAL6_488000_20000 METAL6_488000_32000 0.024
R_VDD5_15291 METAL6_488000_32000 METAL6_488000_129000 0.194
R_VDD5_15292 METAL6_488000_129000 METAL6_488000_141000 0.024
R_VDD5_15293 METAL6_488000_141000 METAL5_488000_141000 0.1
R_VDD5_15294 METAL5_488000_141000 METAL5_488000_153000 0.048
R_VDD5_15295 METAL5_488000_153000 METAL5_488000_165000 0.048
R_VDD5_15296 METAL5_488000_165000 METAL6_488000_165000 0.1
R_VDD5_15297 METAL6_488000_165000 METAL6_488000_177000 0.024
R_VDD5_15298 METAL6_488000_177000 METAL6_488000_241000 0.128
R_VDD5_15299 METAL6_488000_241000 METAL6_488000_253000 0.024
R_VDD5_15300 METAL6_488000_253000 METAL6_488000_265000 0.024
R_VDD5_15301 METAL6_488000_265000 METAL6_488000_277000 0.024
R_VDD5_15302 METAL6_488000_277000 METAL6_488000_341000 0.128
R_VDD5_15303 METAL6_488000_341000 METAL6_488000_353000 0.024
R_VDD5_15304 METAL6_488000_353000 METAL6_488000_365000 0.024
R_VDD5_15305 METAL6_488000_365000 METAL6_488000_377000 0.024
R_VDD5_15306 METAL6_488000_377000 METAL6_488000_441000 0.128
R_VDD5_15307 METAL6_488000_441000 METAL6_488000_453000 0.024
R_VDD5_15308 METAL6_488000_453000 METAL6_488000_465000 0.024
R_VDD5_15309 METAL6_488000_465000 METAL6_488000_477000 0.024
R_VDD5_15310 METAL6_488000_477000 METAL6_488000_553000 0.152
R_VDD5_15311 METAL6_488000_553000 METAL6_488000_565000 0.024
R_VDD5_15312 METAL6_488000_565000 METAL6_488000_577000 0.024
R_VDD5_15313 METAL6_488000_577000 METAL6_488000_693000 0.232
R_VDD5_15314 METAL6_488000_693000 METAL6_488000_707000 0.028
R_VDD5_15315 METAL6_488000_707000 METAL6_488000_841000 0.268
R_VDD5_15316 METAL6_488000_841000 METAL6_488000_853000 0.024
R_VDD5_15317 METAL6_488000_853000 METAL6_488000_865000 0.024
R_VDD5_15318 METAL6_488000_865000 METAL6_488000_877000 0.024
R_VDD5_15319 METAL6_488000_877000 METAL6_488000_929000 0.104
R_VDD5_15320 METAL6_488000_929000 METAL6_488000_941000 0.024
R_VDD5_15321 METAL6_488000_941000 METAL6_488000_953000 0.024
R_VDD5_15322 METAL6_488000_953000 METAL6_488000_965000 0.024
R_VDD5_15323 METAL6_488000_965000 METAL6_488000_977000 0.024
R_VDD5_15324 METAL6_488000_977000 METAL6_488000_1041000 0.128
R_VDD5_15325 METAL6_488000_1041000 METAL6_488000_1053000 0.024
R_VDD5_15326 METAL6_488000_1053000 METAL6_488000_1065000 0.024
R_VDD5_15327 METAL6_488000_1065000 METAL6_488000_1077000 0.024
R_VDD5_15328 METAL6_488000_1077000 METAL6_488000_1153000 0.152
R_VDD5_15329 METAL6_488000_1153000 METAL6_488000_1165000 0.024
R_VDD5_15330 METAL6_488000_1165000 METAL6_488000_1177000 0.024
R_VDD5_15331 METAL6_488000_1177000 METAL6_488000_1253000 0.152
R_VDD5_15332 METAL6_488000_1253000 METAL6_488000_1265000 0.024
R_VDD5_15333 METAL6_488000_1265000 METAL6_488000_1277000 0.024
R_VDD5_15334 METAL6_488000_1277000 METAL6_488000_1393000 0.232
R_VDD5_15335 METAL6_488000_1393000 METAL6_488000_1407000 0.028
R_VDD5_15336 METAL6_488000_1407000 METAL6_488000_1553000 0.292
R_VDD5_15337 METAL6_488000_1553000 METAL6_488000_1565000 0.024
R_VDD5_15338 METAL6_488000_1565000 METAL6_488000_1577000 0.024
R_VDD5_15339 METAL6_488000_1577000 METAL6_488000_1653000 0.152
R_VDD5_15340 METAL6_488000_1653000 METAL6_488000_1665000 0.024
R_VDD5_15341 METAL6_488000_1665000 METAL6_488000_1677000 0.024
R_VDD5_15342 METAL6_488000_1677000 METAL6_488000_1753000 0.152
R_VDD5_15343 METAL6_488000_1753000 METAL6_488000_1765000 0.024
R_VDD5_15344 METAL6_488000_1765000 METAL6_488000_1777000 0.024
R_VDD5_15345 METAL6_488000_1777000 METAL6_488000_1841000 0.128
R_VDD5_15346 METAL6_488000_1841000 METAL6_488000_1853000 0.024
R_VDD5_15347 METAL6_488000_1853000 METAL6_488000_1865000 0.024
R_VDD5_15348 METAL6_488000_1865000 METAL6_488000_1877000 0.024
R_VDD5_15349 METAL6_488000_1877000 METAL6_488000_1953000 0.152
R_VDD5_15350 METAL6_488000_1953000 METAL6_488000_1965000 0.024
R_VDD5_15351 METAL6_488000_1965000 METAL6_488000_1977000 0.024
R_VDD5_15352 METAL6_488000_1977000 METAL6_488000_2093000 0.232
R_VDD5_15353 METAL6_488000_2093000 METAL6_488000_2107000 0.028
R_VDD5_15354 METAL6_488000_2107000 METAL6_488000_2253000 0.292
R_VDD5_15355 METAL6_488000_2253000 METAL6_488000_2265000 0.024
R_VDD5_15356 METAL6_488000_2265000 METAL6_488000_2277000 0.024
R_VDD5_15357 METAL6_488000_2277000 METAL6_488000_2353000 0.152
R_VDD5_15358 METAL6_488000_2353000 METAL6_488000_2365000 0.024
R_VDD5_15359 METAL6_488000_2365000 METAL6_488000_2377000 0.024
R_VDD5_15360 METAL6_488000_2377000 METAL6_488000_2453000 0.152
R_VDD5_15361 METAL6_488000_2453000 METAL6_488000_2465000 0.024
R_VDD5_15362 METAL6_488000_2465000 METAL6_488000_2477000 0.024
R_VDD5_15363 METAL6_488000_2477000 METAL6_488000_2553000 0.152
R_VDD5_15364 METAL6_488000_2553000 METAL6_488000_2565000 0.024
R_VDD5_15365 METAL6_488000_2565000 METAL6_488000_2577000 0.024
R_VDD5_15366 METAL6_488000_2577000 METAL6_488000_2653000 0.152
R_VDD5_15367 METAL6_488000_2653000 METAL6_488000_2665000 0.024
R_VDD5_15368 METAL6_488000_2665000 METAL6_488000_2677000 0.024
R_VDD5_15369 METAL6_488000_2677000 METAL6_488000_2793000 0.232
R_VDD5_15370 METAL6_488000_2793000 METAL6_488000_2807000 0.028
R_VDD5_15371 METAL6_488000_2807000 METAL6_488000_2953000 0.292
R_VDD5_15372 METAL6_488000_2953000 METAL6_488000_2965000 0.024
R_VDD5_15373 METAL6_488000_2965000 METAL6_488000_2977000 0.024
R_VDD5_15374 METAL6_488000_2977000 METAL6_488000_3053000 0.152
R_VDD5_15375 METAL6_488000_3053000 METAL6_488000_3065000 0.024
R_VDD5_15376 METAL6_488000_3065000 METAL6_488000_3077000 0.024
R_VDD5_15377 METAL6_488000_3077000 METAL6_488000_3153000 0.152
R_VDD5_15378 METAL6_488000_3153000 METAL6_488000_3165000 0.024
R_VDD5_15379 METAL6_488000_3165000 METAL6_488000_3177000 0.024
R_VDD5_15380 METAL6_488000_3177000 METAL6_488000_3253000 0.152
R_VDD5_15381 METAL6_488000_3253000 METAL6_488000_3265000 0.024
R_VDD5_15382 METAL6_488000_3265000 METAL6_488000_3277000 0.024
R_VDD5_15383 METAL6_488000_3277000 METAL6_488000_3353000 0.152
R_VDD5_15384 METAL6_488000_3353000 METAL6_488000_3365000 0.024
R_VDD5_15385 METAL6_488000_3365000 METAL6_488000_3377000 0.024
R_VDD5_15386 METAL6_488000_3377000 METAL6_488000_3493000 0.232
R_VDD5_15387 METAL6_488000_3493000 METAL6_488000_3507000 0.028
R_VDD5_15388 METAL6_488000_3507000 METAL6_488000_3653000 0.292
R_VDD5_15389 METAL6_488000_3653000 METAL6_488000_3665000 0.024
R_VDD5_15390 METAL6_488000_3665000 METAL6_488000_3677000 0.024
R_VDD5_15391 METAL6_488000_3677000 METAL6_488000_3753000 0.152
R_VDD5_15392 METAL6_488000_3753000 METAL6_488000_3765000 0.024
R_VDD5_15393 METAL6_488000_3765000 METAL6_488000_3777000 0.024
R_VDD5_15394 METAL6_488000_3777000 METAL6_488000_3853000 0.152
R_VDD5_15395 METAL6_488000_3853000 METAL6_488000_3865000 0.024
R_VDD5_15396 METAL6_488000_3865000 METAL6_488000_3877000 0.024
R_VDD5_15397 METAL6_488000_3877000 METAL6_488000_3953000 0.152
R_VDD5_15398 METAL6_488000_3953000 METAL6_488000_3965000 0.024
R_VDD5_15399 METAL6_488000_3965000 METAL6_488000_3977000 0.024
R_VDD5_15400 METAL6_488000_3977000 METAL6_488000_4053000 0.152
R_VDD5_15401 METAL6_488000_4053000 METAL6_488000_4065000 0.024
R_VDD5_15402 METAL6_488000_4065000 METAL6_488000_4077000 0.024
R_VDD5_15403 METAL6_488000_4077000 METAL6_488000_4193000 0.232
R_VDD5_15404 METAL6_488000_4193000 METAL6_488000_4207000 0.028
R_VDD5_15405 METAL6_488000_4207000 METAL6_488000_4353000 0.292
R_VDD5_15406 METAL6_488000_4353000 METAL6_488000_4365000 0.024
R_VDD5_15407 METAL6_488000_4365000 METAL6_488000_4377000 0.024
R_VDD5_15408 METAL6_488000_4377000 METAL6_488000_4453000 0.152
R_VDD5_15409 METAL6_488000_4453000 METAL6_488000_4465000 0.024
R_VDD5_15410 METAL6_488000_4465000 METAL6_488000_4477000 0.024
R_VDD5_15411 METAL6_488000_4477000 METAL6_488000_4553000 0.152
R_VDD5_15412 METAL6_488000_4553000 METAL6_488000_4565000 0.024
R_VDD5_15413 METAL6_488000_4565000 METAL6_488000_4577000 0.024
R_VDD5_15414 METAL6_488000_4577000 METAL6_488000_4653000 0.152
R_VDD5_15415 METAL6_488000_4653000 METAL6_488000_4665000 0.024
R_VDD5_15416 METAL6_488000_4665000 METAL6_488000_4677000 0.024
R_VDD5_15417 METAL6_488000_4677000 METAL6_488000_4753000 0.152
R_VDD5_15418 METAL6_488000_4753000 METAL6_488000_4765000 0.024
R_VDD5_15419 METAL6_488000_4765000 METAL6_488000_4777000 0.024
R_VDD5_15420 METAL6_488000_4777000 METAL6_488000_4893000 0.232
R_VDD5_15421 METAL6_488000_4893000 METAL6_488000_4907000 0.028
R_VDD5_15422 METAL6_488000_4907000 METAL6_488000_5053000 0.292
R_VDD5_15423 METAL6_488000_5053000 METAL6_488000_5065000 0.024
R_VDD5_15424 METAL6_488000_5065000 METAL6_488000_5077000 0.024
R_VDD5_15425 METAL6_488000_5077000 METAL6_488000_5153000 0.152
R_VDD5_15426 METAL6_488000_5153000 METAL6_488000_5165000 0.024
R_VDD5_15427 METAL6_488000_5165000 METAL6_488000_5177000 0.024
R_VDD5_15428 METAL6_488000_5177000 METAL6_488000_5253000 0.152
R_VDD5_15429 METAL6_488000_5253000 METAL6_488000_5265000 0.024
R_VDD5_15430 METAL6_488000_5265000 METAL6_488000_5277000 0.024
R_VDD5_15431 METAL6_488000_5277000 METAL6_488000_5353000 0.152
R_VDD5_15432 METAL6_488000_5353000 METAL6_488000_5365000 0.024
R_VDD5_15433 METAL6_488000_5365000 METAL6_488000_5377000 0.024
R_VDD5_15434 METAL6_488000_5377000 METAL6_488000_5453000 0.152
R_VDD5_15435 METAL6_488000_5453000 METAL6_488000_5465000 0.024
R_VDD5_15436 METAL6_488000_5465000 METAL6_486000_5465000 0.004
R_VDD5_15437 METAL6_486000_5465000 METAL6_474000_5465000 0.024
R_VDD5_15438 METAL6_474000_5465000 METAL6_462000_5465000 0.024
R_VDD5_15439 METAL6_462000_5465000 METAL6_450000_5465000 0.024
R_VDD5_15440 METAL6_450000_5465000 METAL6_438000_5465000 0.024
R_VDD5_15441 METAL6_438000_5465000 METAL6_424000_5465000 0.028
R_VDD5_15442 METAL6_424000_5465000 METAL6_412000_5465000 0.024
R_VDD5_15443 METAL6_412000_5465000 METAL6_400000_5465000 0.024
R_VDD5_15444 METAL6_400000_5465000 METAL6_388000_5465000 0.024
R_VDD5_15445 METAL6_388000_5465000 METAL6_374000_5465000 0.028
R_VDD5_15446 METAL6_374000_5465000 METAL6_362000_5465000 0.024
R_VDD5_15447 METAL6_362000_5465000 METAL6_350000_5465000 0.024
R_VDD5_15448 METAL6_350000_5465000 METAL6_338000_5465000 0.024
R_VDD5_15449 METAL6_338000_5465000 METAL6_324000_5465000 0.028
R_VDD5_15450 METAL6_324000_5465000 METAL6_312000_5465000 0.024
R_VDD5_15451 METAL6_312000_5465000 METAL6_300000_5465000 0.024
R_VDD5_15452 METAL6_300000_5465000 METAL5_300000_5465000 0.1
R_VDD5_15453 METAL5_300000_5465000 METAL5_293000_5465000 0.028
R_VDD5_15454 METAL5_293000_5465000 METAL5_288000_5465000 0.02
R_VDD5_15455 METAL5_288000_5465000 METAL5_281000_5465000 0.028
R_VDD5_15456 METAL5_281000_5465000 METAL5_276000_5465000 0.02
R_VDD5_15457 METAL5_276000_5465000 METAL5_269000_5465000 0.028
R_VDD5_15458 METAL5_269000_5465000 METAL5_257000_5465000 0.048
R_VDD5_15459 METAL5_257000_5465000 METAL6_257000_5465000 0.1
R_VDD5_15460 METAL6_555000_5465000 METAL6_543000_5465000 0.024
R_VDD5_15461 METAL5_500000_8000 METAL5_500000_20000 0.048
R_VDD5_15462 METAL5_500000_20000 METAL5_500000_32000 0.048
R_VDD5_15463 METAL5_500000_32000 METAL5_500000_129000 0.388
R_VDD5_15464 METAL5_500000_129000 METAL5_500000_141000 0.048
R_VDD5_15465 METAL5_500000_141000 METAL5_500000_153000 0.048
R_VDD5_15466 METAL5_500000_153000 METAL5_500000_165000 0.048
R_VDD5_15467 METAL5_500000_165000 METAL6_500000_165000 0.1
R_VDD5_15468 METAL6_500000_165000 METAL6_500000_177000 0.024
R_VDD5_15469 METAL6_500000_177000 METAL6_500000_241000 0.128
R_VDD5_15470 METAL6_500000_241000 METAL6_500000_253000 0.024
R_VDD5_15471 METAL6_500000_253000 METAL6_500000_265000 0.024
R_VDD5_15472 METAL6_500000_265000 METAL6_500000_277000 0.024
R_VDD5_15473 METAL6_500000_277000 METAL6_500000_341000 0.128
R_VDD5_15474 METAL6_500000_341000 METAL6_500000_353000 0.024
R_VDD5_15475 METAL6_500000_353000 METAL6_500000_365000 0.024
R_VDD5_15476 METAL6_500000_365000 METAL6_500000_377000 0.024
R_VDD5_15477 METAL6_500000_377000 METAL6_500000_441000 0.128
R_VDD5_15478 METAL6_500000_441000 METAL6_500000_453000 0.024
R_VDD5_15479 METAL6_500000_453000 METAL6_500000_465000 0.024
R_VDD5_15480 METAL6_500000_465000 METAL6_500000_477000 0.024
R_VDD5_15481 METAL6_500000_477000 METAL6_500000_553000 0.152
R_VDD5_15482 METAL6_500000_553000 METAL6_500000_565000 0.024
R_VDD5_15483 METAL6_500000_565000 METAL6_500000_577000 0.024
R_VDD5_15484 METAL6_500000_577000 METAL6_500000_693000 0.232
R_VDD5_15485 METAL6_500000_693000 METAL6_500000_707000 0.028
R_VDD5_15486 METAL6_500000_707000 METAL6_500000_841000 0.268
R_VDD5_15487 METAL6_500000_841000 METAL6_500000_853000 0.024
R_VDD5_15488 METAL6_500000_853000 METAL6_500000_865000 0.024
R_VDD5_15489 METAL6_500000_865000 METAL6_500000_877000 0.024
R_VDD5_15490 METAL6_500000_877000 METAL6_500000_929000 0.104
R_VDD5_15491 METAL6_500000_929000 METAL6_500000_941000 0.024
R_VDD5_15492 METAL6_500000_941000 METAL6_500000_953000 0.024
R_VDD5_15493 METAL6_500000_953000 METAL6_500000_965000 0.024
R_VDD5_15494 METAL6_500000_965000 METAL6_500000_977000 0.024
R_VDD5_15495 METAL6_500000_977000 METAL6_500000_1041000 0.128
R_VDD5_15496 METAL6_500000_1041000 METAL6_500000_1053000 0.024
R_VDD5_15497 METAL6_500000_1053000 METAL6_500000_1065000 0.024
R_VDD5_15498 METAL6_500000_1065000 METAL6_500000_1077000 0.024
R_VDD5_15499 METAL6_500000_1077000 METAL6_500000_1153000 0.152
R_VDD5_15500 METAL6_500000_1153000 METAL6_500000_1165000 0.024
R_VDD5_15501 METAL6_500000_1165000 METAL6_500000_1177000 0.024
R_VDD5_15502 METAL6_500000_1177000 METAL6_500000_1253000 0.152
R_VDD5_15503 METAL6_500000_1253000 METAL6_500000_1265000 0.024
R_VDD5_15504 METAL6_500000_1265000 METAL6_500000_1277000 0.024
R_VDD5_15505 METAL6_500000_1277000 METAL6_500000_1393000 0.232
R_VDD5_15506 METAL6_500000_1393000 METAL6_500000_1407000 0.028
R_VDD5_15507 METAL6_500000_1407000 METAL6_500000_1553000 0.292
R_VDD5_15508 METAL6_500000_1553000 METAL6_500000_1565000 0.024
R_VDD5_15509 METAL6_500000_1565000 METAL6_500000_1577000 0.024
R_VDD5_15510 METAL6_500000_1577000 METAL6_500000_1653000 0.152
R_VDD5_15511 METAL6_500000_1653000 METAL6_500000_1665000 0.024
R_VDD5_15512 METAL6_500000_1665000 METAL6_500000_1677000 0.024
R_VDD5_15513 METAL6_500000_1677000 METAL6_500000_1753000 0.152
R_VDD5_15514 METAL6_500000_1753000 METAL6_500000_1765000 0.024
R_VDD5_15515 METAL6_500000_1765000 METAL6_500000_1777000 0.024
R_VDD5_15516 METAL6_500000_1777000 METAL6_500000_1841000 0.128
R_VDD5_15517 METAL6_500000_1841000 METAL6_500000_1853000 0.024
R_VDD5_15518 METAL6_500000_1853000 METAL6_500000_1865000 0.024
R_VDD5_15519 METAL6_500000_1865000 METAL6_500000_1877000 0.024
R_VDD5_15520 METAL6_500000_1877000 METAL6_500000_1953000 0.152
R_VDD5_15521 METAL6_500000_1953000 METAL6_500000_1965000 0.024
R_VDD5_15522 METAL6_500000_1965000 METAL6_500000_1977000 0.024
R_VDD5_15523 METAL6_500000_1977000 METAL6_500000_2093000 0.232
R_VDD5_15524 METAL6_500000_2093000 METAL6_500000_2107000 0.028
R_VDD5_15525 METAL6_500000_2107000 METAL6_500000_2253000 0.292
R_VDD5_15526 METAL6_500000_2253000 METAL6_500000_2265000 0.024
R_VDD5_15527 METAL6_500000_2265000 METAL6_500000_2277000 0.024
R_VDD5_15528 METAL6_500000_2277000 METAL6_500000_2353000 0.152
R_VDD5_15529 METAL6_500000_2353000 METAL6_500000_2365000 0.024
R_VDD5_15530 METAL6_500000_2365000 METAL6_500000_2377000 0.024
R_VDD5_15531 METAL6_500000_2377000 METAL6_500000_2453000 0.152
R_VDD5_15532 METAL6_500000_2453000 METAL6_500000_2465000 0.024
R_VDD5_15533 METAL6_500000_2465000 METAL6_500000_2477000 0.024
R_VDD5_15534 METAL6_500000_2477000 METAL6_500000_2553000 0.152
R_VDD5_15535 METAL6_500000_2553000 METAL6_500000_2565000 0.024
R_VDD5_15536 METAL6_500000_2565000 METAL6_500000_2577000 0.024
R_VDD5_15537 METAL6_500000_2577000 METAL6_500000_2653000 0.152
R_VDD5_15538 METAL6_500000_2653000 METAL6_500000_2665000 0.024
R_VDD5_15539 METAL6_500000_2665000 METAL6_500000_2677000 0.024
R_VDD5_15540 METAL6_500000_2677000 METAL6_500000_2793000 0.232
R_VDD5_15541 METAL6_500000_2793000 METAL6_500000_2807000 0.028
R_VDD5_15542 METAL6_500000_2807000 METAL6_500000_2953000 0.292
R_VDD5_15543 METAL6_500000_2953000 METAL6_500000_2965000 0.024
R_VDD5_15544 METAL6_500000_2965000 METAL6_500000_2977000 0.024
R_VDD5_15545 METAL6_500000_2977000 METAL6_500000_3053000 0.152
R_VDD5_15546 METAL6_500000_3053000 METAL6_500000_3065000 0.024
R_VDD5_15547 METAL6_500000_3065000 METAL6_500000_3077000 0.024
R_VDD5_15548 METAL6_500000_3077000 METAL6_500000_3153000 0.152
R_VDD5_15549 METAL6_500000_3153000 METAL6_500000_3165000 0.024
R_VDD5_15550 METAL6_500000_3165000 METAL6_500000_3177000 0.024
R_VDD5_15551 METAL6_500000_3177000 METAL6_500000_3253000 0.152
R_VDD5_15552 METAL6_500000_3253000 METAL6_500000_3265000 0.024
R_VDD5_15553 METAL6_500000_3265000 METAL6_500000_3277000 0.024
R_VDD5_15554 METAL6_500000_3277000 METAL6_500000_3353000 0.152
R_VDD5_15555 METAL6_500000_3353000 METAL6_500000_3365000 0.024
R_VDD5_15556 METAL6_500000_3365000 METAL6_500000_3377000 0.024
R_VDD5_15557 METAL6_500000_3377000 METAL6_500000_3493000 0.232
R_VDD5_15558 METAL6_500000_3493000 METAL6_500000_3507000 0.028
R_VDD5_15559 METAL6_500000_3507000 METAL6_500000_3653000 0.292
R_VDD5_15560 METAL6_500000_3653000 METAL6_500000_3665000 0.024
R_VDD5_15561 METAL6_500000_3665000 METAL6_500000_3677000 0.024
R_VDD5_15562 METAL6_500000_3677000 METAL6_500000_3753000 0.152
R_VDD5_15563 METAL6_500000_3753000 METAL6_500000_3765000 0.024
R_VDD5_15564 METAL6_500000_3765000 METAL6_500000_3777000 0.024
R_VDD5_15565 METAL6_500000_3777000 METAL6_500000_3853000 0.152
R_VDD5_15566 METAL6_500000_3853000 METAL6_500000_3865000 0.024
R_VDD5_15567 METAL6_500000_3865000 METAL6_500000_3877000 0.024
R_VDD5_15568 METAL6_500000_3877000 METAL6_500000_3953000 0.152
R_VDD5_15569 METAL6_500000_3953000 METAL6_500000_3965000 0.024
R_VDD5_15570 METAL6_500000_3965000 METAL6_500000_3977000 0.024
R_VDD5_15571 METAL6_500000_3977000 METAL6_500000_4053000 0.152
R_VDD5_15572 METAL6_500000_4053000 METAL6_500000_4065000 0.024
R_VDD5_15573 METAL6_500000_4065000 METAL6_500000_4077000 0.024
R_VDD5_15574 METAL6_500000_4077000 METAL6_500000_4193000 0.232
R_VDD5_15575 METAL6_500000_4193000 METAL6_500000_4207000 0.028
R_VDD5_15576 METAL6_500000_4207000 METAL6_500000_4353000 0.292
R_VDD5_15577 METAL6_500000_4353000 METAL6_500000_4365000 0.024
R_VDD5_15578 METAL6_500000_4365000 METAL6_500000_4377000 0.024
R_VDD5_15579 METAL6_500000_4377000 METAL6_500000_4453000 0.152
R_VDD5_15580 METAL6_500000_4453000 METAL6_500000_4465000 0.024
R_VDD5_15581 METAL6_500000_4465000 METAL6_500000_4477000 0.024
R_VDD5_15582 METAL6_500000_4477000 METAL6_500000_4553000 0.152
R_VDD5_15583 METAL6_500000_4553000 METAL6_500000_4565000 0.024
R_VDD5_15584 METAL6_500000_4565000 METAL6_500000_4577000 0.024
R_VDD5_15585 METAL6_500000_4577000 METAL6_500000_4653000 0.152
R_VDD5_15586 METAL6_500000_4653000 METAL6_500000_4665000 0.024
R_VDD5_15587 METAL6_500000_4665000 METAL6_500000_4677000 0.024
R_VDD5_15588 METAL6_500000_4677000 METAL6_500000_4753000 0.152
R_VDD5_15589 METAL6_500000_4753000 METAL6_500000_4765000 0.024
R_VDD5_15590 METAL6_500000_4765000 METAL6_500000_4777000 0.024
R_VDD5_15591 METAL6_500000_4777000 METAL6_500000_4893000 0.232
R_VDD5_15592 METAL6_500000_4893000 METAL6_500000_4907000 0.028
R_VDD5_15593 METAL6_500000_4907000 METAL6_500000_5053000 0.292
R_VDD5_15594 METAL6_500000_5053000 METAL6_500000_5065000 0.024
R_VDD5_15595 METAL6_500000_5065000 METAL6_500000_5077000 0.024
R_VDD5_15596 METAL6_500000_5077000 METAL6_500000_5153000 0.152
R_VDD5_15597 METAL6_500000_5153000 METAL6_500000_5165000 0.024
R_VDD5_15598 METAL6_500000_5165000 METAL6_500000_5177000 0.024
R_VDD5_15599 METAL6_500000_5177000 METAL6_500000_5253000 0.152
R_VDD5_15600 METAL6_500000_5253000 METAL6_500000_5265000 0.024
R_VDD5_15601 METAL6_500000_5265000 METAL6_500000_5277000 0.024
R_VDD5_15602 METAL6_500000_5277000 METAL6_500000_5353000 0.152
R_VDD5_15603 METAL6_500000_5353000 METAL6_500000_5365000 0.024
R_VDD5_15604 METAL6_500000_5365000 METAL6_500000_5377000 0.024
R_VDD5_15605 METAL6_500000_5377000 METAL6_500000_5453000 0.152
R_VDD5_15606 METAL6_500000_5453000 METAL5_500000_5453000 0.1
R_VDD5_15607 METAL5_500000_5453000 METAL5_507000_5453000 0.028
R_VDD5_15608 METAL5_507000_5453000 METAL5_512000_5453000 0.02
R_VDD5_15609 METAL5_512000_5453000 METAL5_519000_5453000 0.028
R_VDD5_15610 METAL5_519000_5453000 METAL5_524000_5453000 0.02
R_VDD5_15611 METAL5_524000_5453000 METAL5_531000_5453000 0.028
R_VDD5_15612 METAL5_531000_5453000 METAL5_543000_5453000 0.048
R_VDD5_15613 METAL5_543000_5453000 METAL6_543000_5453000 0.1
R_VDD5_15614 METAL6_543000_5453000 METAL6_543000_5465000 0.024
R_VDD5_15615 METAL6_245000_4765000 METAL6_257000_4765000 0.024
R_VDD5_15616 METAL6_450000_277000 METAL5_450000_277000 0.1
R_VDD5_15617 METAL5_450000_277000 METAL5_462000_277000 0.048
R_VDD5_15618 METAL5_462000_277000 METAL5_474000_277000 0.048
R_VDD5_15619 METAL5_474000_277000 METAL6_474000_277000 0.1
R_VDD5_15620 METAL6_474000_277000 METAL6_474000_341000 0.128
R_VDD5_15621 METAL6_474000_341000 METAL6_474000_353000 0.024
R_VDD5_15622 METAL6_474000_353000 METAL6_474000_365000 0.024
R_VDD5_15623 METAL6_474000_365000 METAL6_474000_377000 0.024
R_VDD5_15624 METAL6_474000_377000 METAL6_474000_441000 0.128
R_VDD5_15625 METAL6_474000_441000 METAL6_474000_453000 0.024
R_VDD5_15626 METAL6_474000_453000 METAL6_474000_465000 0.024
R_VDD5_15627 METAL6_474000_465000 METAL6_474000_477000 0.024
R_VDD5_15628 METAL6_474000_477000 METAL6_474000_553000 0.152
R_VDD5_15629 METAL6_474000_553000 METAL6_462000_553000 0.024
R_VDD5_15630 METAL6_462000_553000 METAL6_462000_565000 0.024
R_VDD5_15631 METAL6_462000_565000 METAL6_462000_577000 0.024
R_VDD5_15632 METAL6_462000_577000 METAL6_462000_693000 0.232
R_VDD5_15633 METAL6_462000_693000 METAL6_462000_707000 0.028
R_VDD5_15634 METAL6_462000_707000 METAL6_462000_841000 0.268
R_VDD5_15635 METAL6_462000_841000 METAL6_450000_841000 0.024
R_VDD5_15636 METAL6_450000_841000 METAL6_438000_841000 0.024
R_VDD5_15637 METAL6_438000_841000 METAL6_424000_841000 0.028
R_VDD5_15638 METAL6_424000_841000 METAL6_424000_853000 0.024
R_VDD5_15639 METAL6_424000_853000 METAL6_424000_865000 0.024
R_VDD5_15640 METAL6_424000_865000 METAL6_412000_865000 0.024
R_VDD5_15641 METAL6_412000_865000 METAL6_412000_877000 0.024
R_VDD5_15642 METAL6_412000_877000 METAL6_412000_929000 0.104
R_VDD5_15643 METAL6_412000_929000 METAL6_400000_929000 0.024
R_VDD5_15644 METAL6_400000_929000 METAL6_388000_929000 0.024
R_VDD5_15645 METAL6_388000_929000 METAL6_374000_929000 0.028
R_VDD5_15646 METAL6_374000_929000 METAL6_374000_941000 0.024
R_VDD5_15647 METAL6_374000_941000 METAL6_374000_953000 0.024
R_VDD5_15648 METAL6_374000_953000 METAL6_362000_953000 0.024
R_VDD5_15649 METAL6_362000_953000 METAL6_350000_953000 0.024
R_VDD5_15650 METAL6_350000_953000 METAL6_338000_953000 0.024
R_VDD5_15651 METAL6_338000_953000 METAL6_324000_953000 0.028
R_VDD5_15652 METAL6_324000_953000 METAL6_324000_965000 0.024
R_VDD5_15653 METAL6_324000_965000 METAL6_324000_977000 0.024
R_VDD5_15654 METAL6_324000_977000 METAL6_324000_1041000 0.128
R_VDD5_15655 METAL6_324000_1041000 METAL6_324000_1053000 0.024
R_VDD5_15656 METAL6_324000_1053000 METAL6_324000_1065000 0.024
R_VDD5_15657 METAL6_324000_1065000 METAL6_324000_1077000 0.024
R_VDD5_15658 METAL6_324000_1077000 METAL6_324000_1153000 0.152
R_VDD5_15659 METAL6_324000_1153000 METAL6_324000_1165000 0.024
R_VDD5_15660 METAL6_324000_1165000 METAL6_324000_1177000 0.024
R_VDD5_15661 METAL6_324000_1177000 METAL6_324000_1253000 0.152
R_VDD5_15662 METAL6_324000_1253000 METAL6_324000_1265000 0.024
R_VDD5_15663 METAL6_324000_1265000 METAL6_312000_1265000 0.024
R_VDD5_15664 METAL6_312000_1265000 METAL6_312000_1277000 0.024
R_VDD5_15665 METAL6_312000_1277000 METAL6_312000_1393000 0.232
R_VDD5_15666 METAL6_312000_1393000 METAL6_312000_1407000 0.028
R_VDD5_15667 METAL6_312000_1407000 METAL6_312000_1553000 0.292
R_VDD5_15668 METAL6_312000_1553000 METAL6_312000_1565000 0.024
R_VDD5_15669 METAL6_312000_1565000 METAL6_312000_1577000 0.024
R_VDD5_15670 METAL6_312000_1577000 METAL6_312000_1653000 0.152
R_VDD5_15671 METAL6_312000_1653000 METAL6_312000_1665000 0.024
R_VDD5_15672 METAL6_312000_1665000 METAL6_312000_1677000 0.024
R_VDD5_15673 METAL6_312000_1677000 METAL6_312000_1753000 0.152
R_VDD5_15674 METAL6_312000_1753000 METAL6_312000_1765000 0.024
R_VDD5_15675 METAL6_312000_1765000 METAL6_312000_1777000 0.024
R_VDD5_15676 METAL6_312000_1777000 METAL6_312000_1841000 0.128
R_VDD5_15677 METAL6_312000_1841000 METAL6_312000_1853000 0.024
R_VDD5_15678 METAL6_312000_1853000 METAL6_312000_1865000 0.024
R_VDD5_15679 METAL6_312000_1865000 METAL6_312000_1877000 0.024
R_VDD5_15680 METAL6_312000_1877000 METAL6_312000_1953000 0.152
R_VDD5_15681 METAL6_312000_1953000 METAL6_312000_1965000 0.024
R_VDD5_15682 METAL6_312000_1965000 METAL6_312000_1977000 0.024
R_VDD5_15683 METAL6_312000_1977000 METAL6_312000_2093000 0.232
R_VDD5_15684 METAL6_312000_2093000 METAL6_312000_2107000 0.028
R_VDD5_15685 METAL6_312000_2107000 METAL6_312000_2253000 0.292
R_VDD5_15686 METAL6_312000_2253000 METAL6_300000_2253000 0.024
R_VDD5_15687 METAL6_300000_2253000 METAL6_300000_2265000 0.024
R_VDD5_15688 METAL6_300000_2265000 METAL6_300000_2277000 0.024
R_VDD5_15689 METAL6_300000_2277000 METAL6_300000_2353000 0.152
R_VDD5_15690 METAL6_300000_2353000 METAL6_300000_2365000 0.024
R_VDD5_15691 METAL6_300000_2365000 METAL6_300000_2377000 0.024
R_VDD5_15692 METAL6_300000_2377000 METAL6_300000_2453000 0.152
R_VDD5_15693 METAL6_300000_2453000 METAL6_300000_2465000 0.024
R_VDD5_15694 METAL6_300000_2465000 METAL6_300000_2477000 0.024
R_VDD5_15695 METAL6_300000_2477000 METAL6_300000_2553000 0.152
R_VDD5_15696 METAL6_300000_2553000 METAL6_300000_2565000 0.024
R_VDD5_15697 METAL6_300000_2565000 METAL6_300000_2577000 0.024
R_VDD5_15698 METAL6_300000_2577000 METAL6_300000_2653000 0.152
R_VDD5_15699 METAL6_300000_2653000 METAL6_300000_2665000 0.024
R_VDD5_15700 METAL6_300000_2665000 METAL6_300000_2677000 0.024
R_VDD5_15701 METAL6_300000_2677000 METAL6_300000_2793000 0.232
R_VDD5_15702 METAL6_300000_2793000 METAL6_300000_2807000 0.028
R_VDD5_15703 METAL6_300000_2807000 METAL6_300000_2953000 0.292
R_VDD5_15704 METAL6_300000_2953000 METAL6_300000_2965000 0.024
R_VDD5_15705 METAL6_300000_2965000 METAL6_300000_2977000 0.024
R_VDD5_15706 METAL6_300000_2977000 METAL6_300000_3053000 0.152
R_VDD5_15707 METAL6_300000_3053000 METAL6_300000_3065000 0.024
R_VDD5_15708 METAL6_300000_3065000 METAL6_300000_3077000 0.024
R_VDD5_15709 METAL6_300000_3077000 METAL6_300000_3153000 0.152
R_VDD5_15710 METAL6_300000_3153000 METAL6_300000_3165000 0.024
R_VDD5_15711 METAL6_300000_3165000 METAL6_300000_3177000 0.024
R_VDD5_15712 METAL6_300000_3177000 METAL6_300000_3253000 0.152
R_VDD5_15713 METAL6_300000_3253000 METAL6_300000_3265000 0.024
R_VDD5_15714 METAL6_300000_3265000 METAL6_300000_3277000 0.024
R_VDD5_15715 METAL6_300000_3277000 METAL6_300000_3353000 0.152
R_VDD5_15716 METAL6_300000_3353000 METAL6_300000_3365000 0.024
R_VDD5_15717 METAL6_300000_3365000 METAL6_300000_3377000 0.024
R_VDD5_15718 METAL6_300000_3377000 METAL6_300000_3493000 0.232
R_VDD5_15719 METAL6_300000_3493000 METAL6_300000_3507000 0.028
R_VDD5_15720 METAL6_300000_3507000 METAL6_300000_3653000 0.292
R_VDD5_15721 METAL6_300000_3653000 METAL6_300000_3665000 0.024
R_VDD5_15722 METAL6_300000_3665000 METAL6_300000_3677000 0.024
R_VDD5_15723 METAL6_300000_3677000 METAL6_300000_3753000 0.152
R_VDD5_15724 METAL6_300000_3753000 METAL6_300000_3765000 0.024
R_VDD5_15725 METAL6_300000_3765000 METAL6_300000_3777000 0.024
R_VDD5_15726 METAL6_300000_3777000 METAL6_300000_3853000 0.152
R_VDD5_15727 METAL6_300000_3853000 METAL6_300000_3865000 0.024
R_VDD5_15728 METAL6_300000_3865000 METAL6_300000_3877000 0.024
R_VDD5_15729 METAL6_300000_3877000 METAL6_300000_3953000 0.152
R_VDD5_15730 METAL6_300000_3953000 METAL6_300000_3965000 0.024
R_VDD5_15731 METAL6_300000_3965000 METAL6_300000_3977000 0.024
R_VDD5_15732 METAL6_300000_3977000 METAL6_300000_4053000 0.152
R_VDD5_15733 METAL6_300000_4053000 METAL6_300000_4065000 0.024
R_VDD5_15734 METAL6_300000_4065000 METAL6_300000_4077000 0.024
R_VDD5_15735 METAL6_300000_4077000 METAL6_300000_4193000 0.232
R_VDD5_15736 METAL6_300000_4193000 METAL6_300000_4207000 0.028
R_VDD5_15737 METAL6_300000_4207000 METAL6_300000_4353000 0.292
R_VDD5_15738 METAL6_300000_4353000 METAL6_300000_4365000 0.024
R_VDD5_15739 METAL6_300000_4365000 METAL6_300000_4377000 0.024
R_VDD5_15740 METAL6_300000_4377000 METAL6_300000_4453000 0.152
R_VDD5_15741 METAL6_300000_4453000 METAL6_300000_4465000 0.024
R_VDD5_15742 METAL6_300000_4465000 METAL6_300000_4477000 0.024
R_VDD5_15743 METAL6_300000_4477000 METAL6_300000_4553000 0.152
R_VDD5_15744 METAL6_300000_4553000 METAL6_300000_4565000 0.024
R_VDD5_15745 METAL6_300000_4565000 METAL6_300000_4577000 0.024
R_VDD5_15746 METAL6_300000_4577000 METAL6_300000_4653000 0.152
R_VDD5_15747 METAL6_300000_4653000 METAL6_300000_4665000 0.024
R_VDD5_15748 METAL6_300000_4665000 METAL6_300000_4677000 0.024
R_VDD5_15749 METAL6_300000_4677000 METAL6_300000_4753000 0.152
R_VDD5_15750 METAL6_300000_4753000 METAL5_300000_4753000 0.1
R_VDD5_15751 METAL5_300000_4753000 METAL5_293000_4753000 0.028
R_VDD5_15752 METAL5_293000_4753000 METAL5_288000_4753000 0.02
R_VDD5_15753 METAL5_288000_4753000 METAL5_281000_4753000 0.028
R_VDD5_15754 METAL5_281000_4753000 METAL5_276000_4753000 0.02
R_VDD5_15755 METAL5_276000_4753000 METAL5_269000_4753000 0.028
R_VDD5_15756 METAL5_269000_4753000 METAL5_257000_4753000 0.048
R_VDD5_15757 METAL5_257000_4753000 METAL6_257000_4753000 0.1
R_VDD5_15758 METAL6_257000_4753000 METAL6_257000_4765000 0.024
R_VDD5_15759 METAL6_555000_4765000 METAL6_543000_4765000 0.024
R_VDD5_15760 METAL6_531000_341000 METAL5_531000_341000 0.1
R_VDD5_15761 METAL5_531000_341000 METAL5_531000_353000 0.048
R_VDD5_15762 METAL5_531000_353000 METAL5_531000_365000 0.048
R_VDD5_15763 METAL5_531000_365000 METAL5_531000_377000 0.048
R_VDD5_15764 METAL5_531000_377000 METAL5_531000_441000 0.256
R_VDD5_15765 METAL5_531000_441000 METAL5_531000_453000 0.048
R_VDD5_15766 METAL5_531000_453000 METAL5_531000_465000 0.048
R_VDD5_15767 METAL5_531000_465000 METAL5_531000_477000 0.048
R_VDD5_15768 METAL5_531000_477000 METAL5_531000_541000 0.256
R_VDD5_15769 METAL5_531000_541000 METAL5_531000_553000 0.048
R_VDD5_15770 METAL5_531000_553000 METAL5_531000_565000 0.048
R_VDD5_15771 METAL5_531000_565000 METAL5_524000_565000 0.028
R_VDD5_15772 METAL5_524000_565000 METAL5_519000_565000 0.02
R_VDD5_15773 METAL5_519000_565000 METAL5_512000_565000 0.028
R_VDD5_15774 METAL5_512000_565000 METAL5_507000_565000 0.02
R_VDD5_15775 METAL5_507000_565000 METAL5_500000_565000 0.028
R_VDD5_15776 METAL5_500000_565000 METAL5_488000_565000 0.048
R_VDD5_15777 METAL5_488000_565000 METAL5_486000_565000 0.008
R_VDD5_15778 METAL5_486000_565000 METAL5_476000_565000 0.04
R_VDD5_15779 METAL5_476000_565000 METAL6_476000_565000 0.1
R_VDD5_15780 METAL6_476000_565000 METAL6_476000_577000 0.024
R_VDD5_15781 METAL6_476000_577000 METAL6_476000_693000 0.232
R_VDD5_15782 METAL6_476000_693000 METAL6_476000_707000 0.028
R_VDD5_15783 METAL6_476000_707000 METAL6_476000_829000 0.244
R_VDD5_15784 METAL6_476000_829000 METAL6_476000_841000 0.024
R_VDD5_15785 METAL6_476000_841000 METAL6_476000_853000 0.024
R_VDD5_15786 METAL6_476000_853000 METAL6_476000_865000 0.024
R_VDD5_15787 METAL6_476000_865000 METAL6_476000_877000 0.024
R_VDD5_15788 METAL6_476000_877000 METAL6_476000_917000 0.08
R_VDD5_15789 METAL6_476000_917000 METAL6_476000_929000 0.024
R_VDD5_15790 METAL6_476000_929000 METAL6_476000_941000 0.024
R_VDD5_15791 METAL6_476000_941000 METAL6_476000_953000 0.024
R_VDD5_15792 METAL6_476000_953000 METAL6_476000_965000 0.024
R_VDD5_15793 METAL6_476000_965000 METAL6_476000_977000 0.024
R_VDD5_15794 METAL6_476000_977000 METAL6_476000_1041000 0.128
R_VDD5_15795 METAL6_476000_1041000 METAL6_476000_1053000 0.024
R_VDD5_15796 METAL6_476000_1053000 METAL6_476000_1065000 0.024
R_VDD5_15797 METAL6_476000_1065000 METAL6_476000_1077000 0.024
R_VDD5_15798 METAL6_476000_1077000 METAL6_476000_1153000 0.152
R_VDD5_15799 METAL6_476000_1153000 METAL6_476000_1165000 0.024
R_VDD5_15800 METAL6_476000_1165000 METAL6_476000_1177000 0.024
R_VDD5_15801 METAL6_476000_1177000 METAL6_476000_1253000 0.152
R_VDD5_15802 METAL6_476000_1253000 METAL6_476000_1265000 0.024
R_VDD5_15803 METAL6_476000_1265000 METAL6_476000_1277000 0.024
R_VDD5_15804 METAL6_476000_1277000 METAL6_476000_1393000 0.232
R_VDD5_15805 METAL6_476000_1393000 METAL6_476000_1407000 0.028
R_VDD5_15806 METAL6_476000_1407000 METAL6_476000_1553000 0.292
R_VDD5_15807 METAL6_476000_1553000 METAL6_476000_1565000 0.024
R_VDD5_15808 METAL6_476000_1565000 METAL6_476000_1577000 0.024
R_VDD5_15809 METAL6_476000_1577000 METAL6_476000_1653000 0.152
R_VDD5_15810 METAL6_476000_1653000 METAL6_476000_1665000 0.024
R_VDD5_15811 METAL6_476000_1665000 METAL6_476000_1677000 0.024
R_VDD5_15812 METAL6_476000_1677000 METAL6_476000_1753000 0.152
R_VDD5_15813 METAL6_476000_1753000 METAL6_476000_1765000 0.024
R_VDD5_15814 METAL6_476000_1765000 METAL6_476000_1777000 0.024
R_VDD5_15815 METAL6_476000_1777000 METAL6_476000_1841000 0.128
R_VDD5_15816 METAL6_476000_1841000 METAL6_476000_1853000 0.024
R_VDD5_15817 METAL6_476000_1853000 METAL6_476000_1865000 0.024
R_VDD5_15818 METAL6_476000_1865000 METAL6_476000_1877000 0.024
R_VDD5_15819 METAL6_476000_1877000 METAL6_476000_1953000 0.152
R_VDD5_15820 METAL6_476000_1953000 METAL6_476000_1965000 0.024
R_VDD5_15821 METAL6_476000_1965000 METAL6_476000_1977000 0.024
R_VDD5_15822 METAL6_476000_1977000 METAL6_476000_2093000 0.232
R_VDD5_15823 METAL6_476000_2093000 METAL6_476000_2107000 0.028
R_VDD5_15824 METAL6_476000_2107000 METAL6_476000_2241000 0.268
R_VDD5_15825 METAL6_476000_2241000 METAL6_476000_2253000 0.024
R_VDD5_15826 METAL6_476000_2253000 METAL6_476000_2265000 0.024
R_VDD5_15827 METAL6_476000_2265000 METAL6_476000_2277000 0.024
R_VDD5_15828 METAL6_476000_2277000 METAL6_476000_2353000 0.152
R_VDD5_15829 METAL6_476000_2353000 METAL6_476000_2365000 0.024
R_VDD5_15830 METAL6_476000_2365000 METAL6_476000_2377000 0.024
R_VDD5_15831 METAL6_476000_2377000 METAL6_476000_2453000 0.152
R_VDD5_15832 METAL6_476000_2453000 METAL6_476000_2465000 0.024
R_VDD5_15833 METAL6_476000_2465000 METAL6_476000_2477000 0.024
R_VDD5_15834 METAL6_476000_2477000 METAL6_476000_2553000 0.152
R_VDD5_15835 METAL6_476000_2553000 METAL6_476000_2565000 0.024
R_VDD5_15836 METAL6_476000_2565000 METAL6_476000_2577000 0.024
R_VDD5_15837 METAL6_476000_2577000 METAL6_476000_2653000 0.152
R_VDD5_15838 METAL6_476000_2653000 METAL6_476000_2665000 0.024
R_VDD5_15839 METAL6_476000_2665000 METAL6_476000_2677000 0.024
R_VDD5_15840 METAL6_476000_2677000 METAL6_476000_2793000 0.232
R_VDD5_15841 METAL6_476000_2793000 METAL6_476000_2807000 0.028
R_VDD5_15842 METAL6_476000_2807000 METAL6_476000_2953000 0.292
R_VDD5_15843 METAL6_476000_2953000 METAL6_476000_2965000 0.024
R_VDD5_15844 METAL6_476000_2965000 METAL6_476000_2977000 0.024
R_VDD5_15845 METAL6_476000_2977000 METAL6_476000_3053000 0.152
R_VDD5_15846 METAL6_476000_3053000 METAL6_476000_3065000 0.024
R_VDD5_15847 METAL6_476000_3065000 METAL6_476000_3077000 0.024
R_VDD5_15848 METAL6_476000_3077000 METAL6_476000_3153000 0.152
R_VDD5_15849 METAL6_476000_3153000 METAL6_476000_3165000 0.024
R_VDD5_15850 METAL6_476000_3165000 METAL6_476000_3177000 0.024
R_VDD5_15851 METAL6_476000_3177000 METAL6_476000_3253000 0.152
R_VDD5_15852 METAL6_476000_3253000 METAL6_476000_3265000 0.024
R_VDD5_15853 METAL6_476000_3265000 METAL6_476000_3277000 0.024
R_VDD5_15854 METAL6_476000_3277000 METAL6_476000_3353000 0.152
R_VDD5_15855 METAL6_476000_3353000 METAL6_476000_3365000 0.024
R_VDD5_15856 METAL6_476000_3365000 METAL6_476000_3377000 0.024
R_VDD5_15857 METAL6_476000_3377000 METAL6_476000_3493000 0.232
R_VDD5_15858 METAL6_476000_3493000 METAL6_476000_3507000 0.028
R_VDD5_15859 METAL6_476000_3507000 METAL6_476000_3653000 0.292
R_VDD5_15860 METAL6_476000_3653000 METAL6_476000_3665000 0.024
R_VDD5_15861 METAL6_476000_3665000 METAL6_476000_3677000 0.024
R_VDD5_15862 METAL6_476000_3677000 METAL6_476000_3753000 0.152
R_VDD5_15863 METAL6_476000_3753000 METAL6_476000_3765000 0.024
R_VDD5_15864 METAL6_476000_3765000 METAL6_476000_3777000 0.024
R_VDD5_15865 METAL6_476000_3777000 METAL6_476000_3853000 0.152
R_VDD5_15866 METAL6_476000_3853000 METAL6_476000_3865000 0.024
R_VDD5_15867 METAL6_476000_3865000 METAL6_476000_3877000 0.024
R_VDD5_15868 METAL6_476000_3877000 METAL6_476000_3953000 0.152
R_VDD5_15869 METAL6_476000_3953000 METAL6_476000_3965000 0.024
R_VDD5_15870 METAL6_476000_3965000 METAL6_476000_3977000 0.024
R_VDD5_15871 METAL6_476000_3977000 METAL6_476000_4053000 0.152
R_VDD5_15872 METAL6_476000_4053000 METAL6_476000_4065000 0.024
R_VDD5_15873 METAL6_476000_4065000 METAL6_476000_4077000 0.024
R_VDD5_15874 METAL6_476000_4077000 METAL6_476000_4193000 0.232
R_VDD5_15875 METAL6_476000_4193000 METAL6_476000_4207000 0.028
R_VDD5_15876 METAL6_476000_4207000 METAL6_476000_4353000 0.292
R_VDD5_15877 METAL6_476000_4353000 METAL6_476000_4365000 0.024
R_VDD5_15878 METAL6_476000_4365000 METAL6_476000_4377000 0.024
R_VDD5_15879 METAL6_476000_4377000 METAL6_476000_4453000 0.152
R_VDD5_15880 METAL6_476000_4453000 METAL6_476000_4465000 0.024
R_VDD5_15881 METAL6_476000_4465000 METAL6_476000_4477000 0.024
R_VDD5_15882 METAL6_476000_4477000 METAL6_476000_4553000 0.152
R_VDD5_15883 METAL6_476000_4553000 METAL6_476000_4565000 0.024
R_VDD5_15884 METAL6_476000_4565000 METAL6_476000_4577000 0.024
R_VDD5_15885 METAL6_476000_4577000 METAL6_476000_4653000 0.152
R_VDD5_15886 METAL6_476000_4653000 METAL6_476000_4665000 0.024
R_VDD5_15887 METAL6_476000_4665000 METAL6_476000_4677000 0.024
R_VDD5_15888 METAL6_476000_4677000 METAL6_476000_4741000 0.128
R_VDD5_15889 METAL6_476000_4741000 METAL5_476000_4741000 0.1
R_VDD5_15890 METAL5_476000_4741000 METAL5_486000_4741000 0.04
R_VDD5_15891 METAL5_486000_4741000 METAL5_488000_4741000 0.008
R_VDD5_15892 METAL5_488000_4741000 METAL5_500000_4741000 0.048
R_VDD5_15893 METAL5_500000_4741000 METAL5_507000_4741000 0.028
R_VDD5_15894 METAL5_507000_4741000 METAL5_512000_4741000 0.02
R_VDD5_15895 METAL5_512000_4741000 METAL5_519000_4741000 0.028
R_VDD5_15896 METAL5_519000_4741000 METAL5_524000_4741000 0.02
R_VDD5_15897 METAL5_524000_4741000 METAL5_531000_4741000 0.028
R_VDD5_15898 METAL5_531000_4741000 METAL5_543000_4741000 0.048
R_VDD5_15899 METAL5_543000_4741000 METAL6_543000_4741000 0.1
R_VDD5_15900 METAL6_543000_4741000 METAL6_543000_4753000 0.024
R_VDD5_15901 METAL6_543000_4753000 METAL6_543000_4765000 0.024
R_VDD5_15902 METAL6_245000_4065000 METAL6_257000_4065000 0.024
R_VDD5_15903 METAL6_450000_277000 METAL6_438000_277000 0.024
R_VDD5_15904 METAL6_438000_277000 METAL6_438000_289000 0.024
R_VDD5_15905 METAL6_438000_289000 METAL6_438000_329000 0.08
R_VDD5_15906 METAL6_438000_329000 METAL6_438000_341000 0.024
R_VDD5_15907 METAL6_438000_341000 METAL5_438000_341000 0.1
R_VDD5_15908 METAL5_438000_341000 METAL5_438000_353000 0.048
R_VDD5_15909 METAL5_438000_353000 METAL5_438000_365000 0.048
R_VDD5_15910 METAL5_438000_365000 METAL6_438000_365000 0.1
R_VDD5_15911 METAL6_438000_365000 METAL6_438000_377000 0.024
R_VDD5_15912 METAL6_438000_377000 METAL6_438000_441000 0.128
R_VDD5_15913 METAL6_438000_441000 METAL6_438000_453000 0.024
R_VDD5_15914 METAL6_438000_453000 METAL6_438000_465000 0.024
R_VDD5_15915 METAL6_438000_465000 METAL6_438000_477000 0.024
R_VDD5_15916 METAL6_438000_477000 METAL6_438000_541000 0.128
R_VDD5_15917 METAL6_438000_541000 METAL6_438000_553000 0.024
R_VDD5_15918 METAL6_438000_553000 METAL6_436000_553000 0.004
R_VDD5_15919 METAL6_436000_553000 METAL6_424000_553000 0.024
R_VDD5_15920 METAL6_424000_553000 METAL6_412000_553000 0.024
R_VDD5_15921 METAL6_412000_553000 METAL6_400000_553000 0.024
R_VDD5_15922 METAL6_400000_553000 METAL6_400000_565000 0.024
R_VDD5_15923 METAL6_400000_565000 METAL6_400000_577000 0.024
R_VDD5_15924 METAL6_400000_577000 METAL6_400000_693000 0.232
R_VDD5_15925 METAL6_400000_693000 METAL6_400000_707000 0.028
R_VDD5_15926 METAL6_400000_707000 METAL6_400000_829000 0.244
R_VDD5_15927 METAL6_400000_829000 METAL6_400000_841000 0.024
R_VDD5_15928 METAL6_400000_841000 METAL6_388000_841000 0.024
R_VDD5_15929 METAL6_388000_841000 METAL6_388000_853000 0.024
R_VDD5_15930 METAL6_388000_853000 METAL6_386000_853000 0.004
R_VDD5_15931 METAL6_386000_853000 METAL6_374000_853000 0.024
R_VDD5_15932 METAL6_374000_853000 METAL6_362000_853000 0.024
R_VDD5_15933 METAL6_362000_853000 METAL6_350000_853000 0.024
R_VDD5_15934 METAL6_350000_853000 METAL6_338000_853000 0.024
R_VDD5_15935 METAL6_338000_853000 METAL6_338000_865000 0.024
R_VDD5_15936 METAL6_338000_865000 METAL6_338000_877000 0.024
R_VDD5_15937 METAL6_338000_877000 METAL6_338000_917000 0.08
R_VDD5_15938 METAL6_338000_917000 METAL6_338000_929000 0.024
R_VDD5_15939 METAL6_338000_929000 METAL5_338000_929000 0.1
R_VDD5_15940 METAL5_338000_929000 METAL5_338000_941000 0.048
R_VDD5_15941 METAL5_338000_941000 METAL5_338000_953000 0.048
R_VDD5_15942 METAL5_338000_953000 METAL5_338000_965000 0.048
R_VDD5_15943 METAL5_338000_965000 METAL6_338000_965000 0.1
R_VDD5_15944 METAL6_338000_965000 METAL6_338000_977000 0.024
R_VDD5_15945 METAL6_338000_977000 METAL6_338000_1041000 0.128
R_VDD5_15946 METAL6_338000_1041000 METAL6_338000_1053000 0.024
R_VDD5_15947 METAL6_338000_1053000 METAL6_338000_1065000 0.024
R_VDD5_15948 METAL6_338000_1065000 METAL6_338000_1077000 0.024
R_VDD5_15949 METAL6_338000_1077000 METAL6_338000_1153000 0.152
R_VDD5_15950 METAL6_338000_1153000 METAL6_338000_1165000 0.024
R_VDD5_15951 METAL6_338000_1165000 METAL6_338000_1177000 0.024
R_VDD5_15952 METAL6_338000_1177000 METAL6_338000_1253000 0.152
R_VDD5_15953 METAL6_338000_1253000 METAL6_338000_1265000 0.024
R_VDD5_15954 METAL6_338000_1265000 METAL6_338000_1277000 0.024
R_VDD5_15955 METAL6_338000_1277000 METAL6_338000_1393000 0.232
R_VDD5_15956 METAL6_338000_1393000 METAL6_338000_1407000 0.028
R_VDD5_15957 METAL6_338000_1407000 METAL6_338000_1553000 0.292
R_VDD5_15958 METAL6_338000_1553000 METAL6_338000_1565000 0.024
R_VDD5_15959 METAL6_338000_1565000 METAL6_338000_1577000 0.024
R_VDD5_15960 METAL6_338000_1577000 METAL6_338000_1653000 0.152
R_VDD5_15961 METAL6_338000_1653000 METAL6_338000_1665000 0.024
R_VDD5_15962 METAL6_338000_1665000 METAL6_338000_1677000 0.024
R_VDD5_15963 METAL6_338000_1677000 METAL6_338000_1753000 0.152
R_VDD5_15964 METAL6_338000_1753000 METAL6_338000_1765000 0.024
R_VDD5_15965 METAL6_338000_1765000 METAL6_338000_1777000 0.024
R_VDD5_15966 METAL6_338000_1777000 METAL6_338000_1841000 0.128
R_VDD5_15967 METAL6_338000_1841000 METAL6_338000_1853000 0.024
R_VDD5_15968 METAL6_338000_1853000 METAL6_338000_1865000 0.024
R_VDD5_15969 METAL6_338000_1865000 METAL6_338000_1877000 0.024
R_VDD5_15970 METAL6_338000_1877000 METAL6_338000_1953000 0.152
R_VDD5_15971 METAL6_338000_1953000 METAL6_338000_1965000 0.024
R_VDD5_15972 METAL6_338000_1965000 METAL6_338000_1977000 0.024
R_VDD5_15973 METAL6_338000_1977000 METAL6_338000_2093000 0.232
R_VDD5_15974 METAL6_338000_2093000 METAL6_338000_2107000 0.028
R_VDD5_15975 METAL6_338000_2107000 METAL6_338000_2241000 0.268
R_VDD5_15976 METAL6_338000_2241000 METAL6_338000_2253000 0.024
R_VDD5_15977 METAL6_338000_2253000 METAL6_338000_2265000 0.024
R_VDD5_15978 METAL6_338000_2265000 METAL6_338000_2277000 0.024
R_VDD5_15979 METAL6_338000_2277000 METAL6_338000_2353000 0.152
R_VDD5_15980 METAL6_338000_2353000 METAL6_338000_2365000 0.024
R_VDD5_15981 METAL6_338000_2365000 METAL6_338000_2377000 0.024
R_VDD5_15982 METAL6_338000_2377000 METAL6_338000_2453000 0.152
R_VDD5_15983 METAL6_338000_2453000 METAL6_338000_2465000 0.024
R_VDD5_15984 METAL6_338000_2465000 METAL6_338000_2477000 0.024
R_VDD5_15985 METAL6_338000_2477000 METAL6_338000_2553000 0.152
R_VDD5_15986 METAL6_338000_2553000 METAL6_338000_2565000 0.024
R_VDD5_15987 METAL6_338000_2565000 METAL6_338000_2577000 0.024
R_VDD5_15988 METAL6_338000_2577000 METAL6_338000_2653000 0.152
R_VDD5_15989 METAL6_338000_2653000 METAL6_338000_2665000 0.024
R_VDD5_15990 METAL6_338000_2665000 METAL6_338000_2677000 0.024
R_VDD5_15991 METAL6_338000_2677000 METAL6_338000_2793000 0.232
R_VDD5_15992 METAL6_338000_2793000 METAL6_338000_2807000 0.028
R_VDD5_15993 METAL6_338000_2807000 METAL6_338000_2953000 0.292
R_VDD5_15994 METAL6_338000_2953000 METAL6_338000_2965000 0.024
R_VDD5_15995 METAL6_338000_2965000 METAL6_338000_2977000 0.024
R_VDD5_15996 METAL6_338000_2977000 METAL6_338000_3053000 0.152
R_VDD5_15997 METAL6_338000_3053000 METAL6_338000_3065000 0.024
R_VDD5_15998 METAL6_338000_3065000 METAL6_338000_3077000 0.024
R_VDD5_15999 METAL6_338000_3077000 METAL6_338000_3153000 0.152
R_VDD5_16000 METAL6_338000_3153000 METAL6_338000_3165000 0.024
R_VDD5_16001 METAL6_338000_3165000 METAL6_338000_3177000 0.024
R_VDD5_16002 METAL6_338000_3177000 METAL6_338000_3253000 0.152
R_VDD5_16003 METAL6_338000_3253000 METAL6_338000_3265000 0.024
R_VDD5_16004 METAL6_338000_3265000 METAL6_338000_3277000 0.024
R_VDD5_16005 METAL6_338000_3277000 METAL6_338000_3353000 0.152
R_VDD5_16006 METAL6_338000_3353000 METAL6_338000_3365000 0.024
R_VDD5_16007 METAL6_338000_3365000 METAL6_338000_3377000 0.024
R_VDD5_16008 METAL6_338000_3377000 METAL6_338000_3493000 0.232
R_VDD5_16009 METAL6_338000_3493000 METAL6_338000_3507000 0.028
R_VDD5_16010 METAL6_338000_3507000 METAL6_338000_3653000 0.292
R_VDD5_16011 METAL6_338000_3653000 METAL6_338000_3665000 0.024
R_VDD5_16012 METAL6_338000_3665000 METAL6_338000_3677000 0.024
R_VDD5_16013 METAL6_338000_3677000 METAL6_338000_3753000 0.152
R_VDD5_16014 METAL6_338000_3753000 METAL6_338000_3765000 0.024
R_VDD5_16015 METAL6_338000_3765000 METAL6_338000_3777000 0.024
R_VDD5_16016 METAL6_338000_3777000 METAL6_338000_3853000 0.152
R_VDD5_16017 METAL6_338000_3853000 METAL6_338000_3865000 0.024
R_VDD5_16018 METAL6_338000_3865000 METAL6_338000_3877000 0.024
R_VDD5_16019 METAL6_338000_3877000 METAL6_338000_3953000 0.152
R_VDD5_16020 METAL6_338000_3953000 METAL6_338000_3965000 0.024
R_VDD5_16021 METAL6_338000_3965000 METAL6_338000_3977000 0.024
R_VDD5_16022 METAL6_338000_3977000 METAL6_338000_4053000 0.152
R_VDD5_16023 METAL6_338000_4053000 METAL6_338000_4065000 0.024
R_VDD5_16024 METAL6_338000_4065000 METAL6_336000_4065000 0.004
R_VDD5_16025 METAL6_336000_4065000 METAL6_324000_4065000 0.024
R_VDD5_16026 METAL6_324000_4065000 METAL6_312000_4065000 0.024
R_VDD5_16027 METAL6_312000_4065000 METAL5_312000_4065000 0.1
R_VDD5_16028 METAL5_312000_4065000 METAL5_300000_4065000 0.048
R_VDD5_16029 METAL5_300000_4065000 METAL5_293000_4065000 0.028
R_VDD5_16030 METAL5_293000_4065000 METAL5_288000_4065000 0.02
R_VDD5_16031 METAL5_288000_4065000 METAL5_281000_4065000 0.028
R_VDD5_16032 METAL5_281000_4065000 METAL5_276000_4065000 0.02
R_VDD5_16033 METAL5_276000_4065000 METAL5_269000_4065000 0.028
R_VDD5_16034 METAL5_269000_4065000 METAL5_257000_4065000 0.048
R_VDD5_16035 METAL5_257000_4065000 METAL6_257000_4065000 0.1
R_VDD5_16036 METAL6_555000_4065000 METAL6_543000_4065000 0.024
R_VDD5_16037 METAL6_531000_341000 METAL6_543000_341000 0.024
R_VDD5_16038 METAL6_543000_341000 METAL6_543000_329000 0.024
R_VDD5_16039 METAL6_543000_329000 METAL5_543000_329000 0.1
R_VDD5_16040 METAL5_543000_329000 METAL5_531000_329000 0.048
R_VDD5_16041 METAL5_531000_329000 METAL5_524000_329000 0.028
R_VDD5_16042 METAL5_524000_329000 METAL5_519000_329000 0.02
R_VDD5_16043 METAL5_519000_329000 METAL5_512000_329000 0.028
R_VDD5_16044 METAL5_512000_329000 METAL5_507000_329000 0.02
R_VDD5_16045 METAL5_507000_329000 METAL5_500000_329000 0.028
R_VDD5_16046 METAL5_500000_329000 METAL5_488000_329000 0.048
R_VDD5_16047 METAL5_488000_329000 METAL5_486000_329000 0.008
R_VDD5_16048 METAL5_486000_329000 METAL5_476000_329000 0.04
R_VDD5_16049 METAL5_476000_329000 METAL5_474000_329000 0.008
R_VDD5_16050 METAL5_474000_329000 METAL5_464000_329000 0.04
R_VDD5_16051 METAL5_464000_329000 METAL5_462000_329000 0.008
R_VDD5_16052 METAL5_462000_329000 METAL5_450000_329000 0.048
R_VDD5_16053 METAL5_450000_329000 METAL5_438000_329000 0.048
R_VDD5_16054 METAL5_438000_329000 METAL5_436000_329000 0.008
R_VDD5_16055 METAL5_436000_329000 METAL5_426000_329000 0.04
R_VDD5_16056 METAL5_426000_329000 METAL5_426000_341000 0.048
R_VDD5_16057 METAL5_426000_341000 METAL5_426000_353000 0.048
R_VDD5_16058 METAL5_426000_353000 METAL5_426000_365000 0.048
R_VDD5_16059 METAL5_426000_365000 METAL6_426000_365000 0.1
R_VDD5_16060 METAL6_426000_365000 METAL6_426000_377000 0.024
R_VDD5_16061 METAL6_426000_377000 METAL6_426000_441000 0.128
R_VDD5_16062 METAL6_426000_441000 METAL6_426000_453000 0.024
R_VDD5_16063 METAL6_426000_453000 METAL6_426000_465000 0.024
R_VDD5_16064 METAL6_426000_465000 METAL6_426000_477000 0.024
R_VDD5_16065 METAL6_426000_477000 METAL6_426000_541000 0.128
R_VDD5_16066 METAL6_426000_541000 METAL6_424000_541000 0.004
R_VDD5_16067 METAL6_424000_541000 METAL6_412000_541000 0.024
R_VDD5_16068 METAL6_412000_541000 METAL6_400000_541000 0.024
R_VDD5_16069 METAL6_400000_541000 METAL6_388000_541000 0.024
R_VDD5_16070 METAL6_388000_541000 METAL6_388000_553000 0.024
R_VDD5_16071 METAL6_388000_553000 METAL6_388000_565000 0.024
R_VDD5_16072 METAL6_388000_565000 METAL6_388000_577000 0.024
R_VDD5_16073 METAL6_388000_577000 METAL6_388000_693000 0.232
R_VDD5_16074 METAL6_388000_693000 METAL6_388000_707000 0.028
R_VDD5_16075 METAL6_388000_707000 METAL6_388000_829000 0.244
R_VDD5_16076 METAL6_388000_829000 METAL5_388000_829000 0.1
R_VDD5_16077 METAL5_388000_829000 METAL5_400000_829000 0.048
R_VDD5_16078 METAL5_400000_829000 METAL5_412000_829000 0.048
R_VDD5_16079 METAL5_412000_829000 METAL5_424000_829000 0.048
R_VDD5_16080 METAL5_424000_829000 METAL5_424000_841000 0.048
R_VDD5_16081 METAL5_424000_841000 METAL5_424000_853000 0.048
R_VDD5_16082 METAL5_424000_853000 METAL5_426000_853000 0.008
R_VDD5_16083 METAL5_426000_853000 METAL5_436000_853000 0.04
R_VDD5_16084 METAL5_436000_853000 METAL6_436000_853000 0.1
R_VDD5_16085 METAL6_436000_853000 METAL6_436000_865000 0.024
R_VDD5_16086 METAL6_436000_865000 METAL6_436000_877000 0.024
R_VDD5_16087 METAL6_436000_877000 METAL6_436000_917000 0.08
R_VDD5_16088 METAL6_436000_917000 METAL6_436000_929000 0.024
R_VDD5_16089 METAL6_436000_929000 METAL6_436000_941000 0.024
R_VDD5_16090 METAL6_436000_941000 METAL6_436000_953000 0.024
R_VDD5_16091 METAL6_436000_953000 METAL6_436000_965000 0.024
R_VDD5_16092 METAL6_436000_965000 METAL6_436000_977000 0.024
R_VDD5_16093 METAL6_436000_977000 METAL6_436000_1041000 0.128
R_VDD5_16094 METAL6_436000_1041000 METAL6_436000_1053000 0.024
R_VDD5_16095 METAL6_436000_1053000 METAL6_436000_1065000 0.024
R_VDD5_16096 METAL6_436000_1065000 METAL6_436000_1077000 0.024
R_VDD5_16097 METAL6_436000_1077000 METAL6_436000_1153000 0.152
R_VDD5_16098 METAL6_436000_1153000 METAL6_436000_1165000 0.024
R_VDD5_16099 METAL6_436000_1165000 METAL6_436000_1177000 0.024
R_VDD5_16100 METAL6_436000_1177000 METAL6_436000_1253000 0.152
R_VDD5_16101 METAL6_436000_1253000 METAL6_436000_1265000 0.024
R_VDD5_16102 METAL6_436000_1265000 METAL6_436000_1277000 0.024
R_VDD5_16103 METAL6_436000_1277000 METAL6_436000_1393000 0.232
R_VDD5_16104 METAL6_436000_1393000 METAL6_436000_1407000 0.028
R_VDD5_16105 METAL6_436000_1407000 METAL6_436000_1553000 0.292
R_VDD5_16106 METAL6_436000_1553000 METAL6_436000_1565000 0.024
R_VDD5_16107 METAL6_436000_1565000 METAL6_436000_1577000 0.024
R_VDD5_16108 METAL6_436000_1577000 METAL6_436000_1653000 0.152
R_VDD5_16109 METAL6_436000_1653000 METAL6_436000_1665000 0.024
R_VDD5_16110 METAL6_436000_1665000 METAL6_436000_1677000 0.024
R_VDD5_16111 METAL6_436000_1677000 METAL6_436000_1753000 0.152
R_VDD5_16112 METAL6_436000_1753000 METAL6_436000_1765000 0.024
R_VDD5_16113 METAL6_436000_1765000 METAL6_436000_1777000 0.024
R_VDD5_16114 METAL6_436000_1777000 METAL6_436000_1841000 0.128
R_VDD5_16115 METAL6_436000_1841000 METAL6_436000_1853000 0.024
R_VDD5_16116 METAL6_436000_1853000 METAL6_436000_1865000 0.024
R_VDD5_16117 METAL6_436000_1865000 METAL6_436000_1877000 0.024
R_VDD5_16118 METAL6_436000_1877000 METAL6_436000_1953000 0.152
R_VDD5_16119 METAL6_436000_1953000 METAL6_436000_1965000 0.024
R_VDD5_16120 METAL6_436000_1965000 METAL6_436000_1977000 0.024
R_VDD5_16121 METAL6_436000_1977000 METAL6_436000_2093000 0.232
R_VDD5_16122 METAL6_436000_2093000 METAL6_436000_2107000 0.028
R_VDD5_16123 METAL6_436000_2107000 METAL6_436000_2241000 0.268
R_VDD5_16124 METAL6_436000_2241000 METAL6_436000_2253000 0.024
R_VDD5_16125 METAL6_436000_2253000 METAL6_436000_2265000 0.024
R_VDD5_16126 METAL6_436000_2265000 METAL6_436000_2277000 0.024
R_VDD5_16127 METAL6_436000_2277000 METAL6_436000_2353000 0.152
R_VDD5_16128 METAL6_436000_2353000 METAL6_436000_2365000 0.024
R_VDD5_16129 METAL6_436000_2365000 METAL6_436000_2377000 0.024
R_VDD5_16130 METAL6_436000_2377000 METAL6_436000_2453000 0.152
R_VDD5_16131 METAL6_436000_2453000 METAL6_436000_2465000 0.024
R_VDD5_16132 METAL6_436000_2465000 METAL6_436000_2477000 0.024
R_VDD5_16133 METAL6_436000_2477000 METAL6_436000_2553000 0.152
R_VDD5_16134 METAL6_436000_2553000 METAL6_436000_2565000 0.024
R_VDD5_16135 METAL6_436000_2565000 METAL6_436000_2577000 0.024
R_VDD5_16136 METAL6_436000_2577000 METAL6_436000_2653000 0.152
R_VDD5_16137 METAL6_436000_2653000 METAL6_436000_2665000 0.024
R_VDD5_16138 METAL6_436000_2665000 METAL6_436000_2677000 0.024
R_VDD5_16139 METAL6_436000_2677000 METAL6_436000_2793000 0.232
R_VDD5_16140 METAL6_436000_2793000 METAL6_436000_2807000 0.028
R_VDD5_16141 METAL6_436000_2807000 METAL6_436000_2953000 0.292
R_VDD5_16142 METAL6_436000_2953000 METAL6_436000_2965000 0.024
R_VDD5_16143 METAL6_436000_2965000 METAL6_436000_2977000 0.024
R_VDD5_16144 METAL6_436000_2977000 METAL6_436000_3053000 0.152
R_VDD5_16145 METAL6_436000_3053000 METAL6_436000_3065000 0.024
R_VDD5_16146 METAL6_436000_3065000 METAL6_436000_3077000 0.024
R_VDD5_16147 METAL6_436000_3077000 METAL6_436000_3153000 0.152
R_VDD5_16148 METAL6_436000_3153000 METAL6_436000_3165000 0.024
R_VDD5_16149 METAL6_436000_3165000 METAL6_436000_3177000 0.024
R_VDD5_16150 METAL6_436000_3177000 METAL6_436000_3253000 0.152
R_VDD5_16151 METAL6_436000_3253000 METAL6_436000_3265000 0.024
R_VDD5_16152 METAL6_436000_3265000 METAL6_436000_3277000 0.024
R_VDD5_16153 METAL6_436000_3277000 METAL6_436000_3353000 0.152
R_VDD5_16154 METAL6_436000_3353000 METAL6_436000_3365000 0.024
R_VDD5_16155 METAL6_436000_3365000 METAL6_436000_3377000 0.024
R_VDD5_16156 METAL6_436000_3377000 METAL6_436000_3493000 0.232
R_VDD5_16157 METAL6_436000_3493000 METAL6_436000_3507000 0.028
R_VDD5_16158 METAL6_436000_3507000 METAL6_436000_3653000 0.292
R_VDD5_16159 METAL6_436000_3653000 METAL6_436000_3665000 0.024
R_VDD5_16160 METAL6_436000_3665000 METAL6_436000_3677000 0.024
R_VDD5_16161 METAL6_436000_3677000 METAL6_436000_3753000 0.152
R_VDD5_16162 METAL6_436000_3753000 METAL6_436000_3765000 0.024
R_VDD5_16163 METAL6_436000_3765000 METAL6_436000_3777000 0.024
R_VDD5_16164 METAL6_436000_3777000 METAL6_436000_3853000 0.152
R_VDD5_16165 METAL6_436000_3853000 METAL6_436000_3865000 0.024
R_VDD5_16166 METAL6_436000_3865000 METAL6_436000_3877000 0.024
R_VDD5_16167 METAL6_436000_3877000 METAL6_436000_3953000 0.152
R_VDD5_16168 METAL6_436000_3953000 METAL6_436000_3965000 0.024
R_VDD5_16169 METAL6_436000_3965000 METAL6_436000_3977000 0.024
R_VDD5_16170 METAL6_436000_3977000 METAL6_436000_4053000 0.152
R_VDD5_16171 METAL6_436000_4053000 METAL6_436000_4065000 0.024
R_VDD5_16172 METAL6_436000_4065000 METAL6_438000_4065000 0.004
R_VDD5_16173 METAL6_438000_4065000 METAL6_450000_4065000 0.024
R_VDD5_16174 METAL6_450000_4065000 METAL6_462000_4065000 0.024
R_VDD5_16175 METAL6_462000_4065000 METAL6_464000_4065000 0.004
R_VDD5_16176 METAL6_464000_4065000 METAL5_464000_4065000 0.1
R_VDD5_16177 METAL5_464000_4065000 METAL5_474000_4065000 0.04
R_VDD5_16178 METAL5_474000_4065000 METAL5_476000_4065000 0.008
R_VDD5_16179 METAL5_476000_4065000 METAL5_486000_4065000 0.04
R_VDD5_16180 METAL5_486000_4065000 METAL5_488000_4065000 0.008
R_VDD5_16181 METAL5_488000_4065000 METAL5_500000_4065000 0.048
R_VDD5_16182 METAL5_500000_4065000 METAL5_507000_4065000 0.028
R_VDD5_16183 METAL5_507000_4065000 METAL5_512000_4065000 0.02
R_VDD5_16184 METAL5_512000_4065000 METAL5_519000_4065000 0.028
R_VDD5_16185 METAL5_519000_4065000 METAL5_524000_4065000 0.02
R_VDD5_16186 METAL5_524000_4065000 METAL5_531000_4065000 0.028
R_VDD5_16187 METAL5_531000_4065000 METAL5_543000_4065000 0.048
R_VDD5_16188 METAL5_543000_4065000 METAL6_543000_4065000 0.1
R_VDD5_16189 METAL6_245000_3365000 METAL6_257000_3365000 0.024
R_VDD5_16190 METAL6_512000_277000 METAL5_512000_277000 0.1
R_VDD5_16191 METAL5_512000_277000 METAL5_512000_289000 0.048
R_VDD5_16192 METAL5_512000_289000 METAL5_507000_289000 0.02
R_VDD5_16193 METAL5_507000_289000 METAL5_500000_289000 0.028
R_VDD5_16194 METAL5_500000_289000 METAL5_488000_289000 0.048
R_VDD5_16195 METAL5_488000_289000 METAL5_486000_289000 0.008
R_VDD5_16196 METAL5_486000_289000 METAL5_476000_289000 0.04
R_VDD5_16197 METAL5_476000_289000 METAL5_474000_289000 0.008
R_VDD5_16198 METAL5_474000_289000 METAL5_464000_289000 0.04
R_VDD5_16199 METAL5_464000_289000 METAL5_462000_289000 0.008
R_VDD5_16200 METAL5_462000_289000 METAL5_452000_289000 0.04
R_VDD5_16201 METAL5_452000_289000 METAL5_450000_289000 0.008
R_VDD5_16202 METAL5_450000_289000 METAL5_448000_289000 0.008
R_VDD5_16203 METAL5_448000_289000 METAL5_438000_289000 0.04
R_VDD5_16204 METAL5_438000_289000 METAL5_436000_289000 0.008
R_VDD5_16205 METAL5_436000_289000 METAL5_426000_289000 0.04
R_VDD5_16206 METAL5_426000_289000 METAL6_426000_289000 0.1
R_VDD5_16207 METAL6_426000_289000 METAL6_426000_317000 0.056
R_VDD5_16208 METAL6_426000_317000 METAL6_426000_329000 0.024
R_VDD5_16209 METAL6_426000_329000 METAL6_426000_341000 0.024
R_VDD5_16210 METAL6_426000_341000 METAL6_424000_341000 0.004
R_VDD5_16211 METAL6_424000_341000 METAL6_414000_341000 0.02
R_VDD5_16212 METAL6_414000_341000 METAL6_412000_341000 0.004
R_VDD5_16213 METAL6_412000_341000 METAL6_400000_341000 0.024
R_VDD5_16214 METAL6_400000_341000 METAL6_388000_341000 0.024
R_VDD5_16215 METAL6_388000_341000 METAL6_386000_341000 0.004
R_VDD5_16216 METAL6_386000_341000 METAL6_376000_341000 0.02
R_VDD5_16217 METAL6_376000_341000 METAL6_374000_341000 0.004
R_VDD5_16218 METAL6_374000_341000 METAL6_362000_341000 0.024
R_VDD5_16219 METAL6_362000_341000 METAL6_350000_341000 0.024
R_VDD5_16220 METAL6_350000_341000 METAL6_350000_353000 0.024
R_VDD5_16221 METAL6_350000_353000 METAL6_338000_353000 0.024
R_VDD5_16222 METAL6_338000_353000 METAL6_336000_353000 0.004
R_VDD5_16223 METAL6_336000_353000 METAL6_326000_353000 0.02
R_VDD5_16224 METAL6_326000_353000 METAL6_324000_353000 0.004
R_VDD5_16225 METAL6_324000_353000 METAL6_312000_353000 0.024
R_VDD5_16226 METAL6_312000_353000 METAL6_300000_353000 0.024
R_VDD5_16227 METAL6_300000_353000 METAL6_300000_365000 0.024
R_VDD5_16228 METAL6_300000_365000 METAL6_300000_377000 0.024
R_VDD5_16229 METAL6_300000_377000 METAL6_300000_441000 0.128
R_VDD5_16230 METAL6_300000_441000 METAL6_300000_453000 0.024
R_VDD5_16231 METAL6_300000_453000 METAL6_300000_465000 0.024
R_VDD5_16232 METAL6_300000_465000 METAL6_300000_477000 0.024
R_VDD5_16233 METAL6_300000_477000 METAL6_300000_529000 0.104
R_VDD5_16234 METAL6_300000_529000 METAL6_300000_541000 0.024
R_VDD5_16235 METAL6_300000_541000 METAL6_300000_553000 0.024
R_VDD5_16236 METAL6_300000_553000 METAL6_293000_553000 0.014
R_VDD5_16237 METAL6_293000_553000 METAL6_288000_553000 0.01
R_VDD5_16238 METAL6_288000_553000 METAL6_288000_565000 0.024
R_VDD5_16239 METAL6_288000_565000 METAL6_288000_577000 0.024
R_VDD5_16240 METAL6_288000_577000 METAL6_288000_693000 0.232
R_VDD5_16241 METAL6_288000_693000 METAL6_288000_707000 0.028
R_VDD5_16242 METAL6_288000_707000 METAL6_288000_817000 0.22
R_VDD5_16243 METAL6_288000_817000 METAL6_288000_829000 0.024
R_VDD5_16244 METAL6_288000_829000 METAL6_288000_841000 0.024
R_VDD5_16245 METAL6_288000_841000 METAL6_288000_853000 0.024
R_VDD5_16246 METAL6_288000_853000 METAL6_288000_865000 0.024
R_VDD5_16247 METAL6_288000_865000 METAL6_288000_877000 0.024
R_VDD5_16248 METAL6_288000_877000 METAL6_288000_917000 0.08
R_VDD5_16249 METAL6_288000_917000 METAL6_288000_929000 0.024
R_VDD5_16250 METAL6_288000_929000 METAL6_288000_941000 0.024
R_VDD5_16251 METAL6_288000_941000 METAL5_288000_941000 0.1
R_VDD5_16252 METAL5_288000_941000 METAL5_288000_953000 0.048
R_VDD5_16253 METAL5_288000_953000 METAL5_288000_965000 0.048
R_VDD5_16254 METAL5_288000_965000 METAL6_288000_965000 0.1
R_VDD5_16255 METAL6_288000_965000 METAL6_288000_977000 0.024
R_VDD5_16256 METAL6_288000_977000 METAL6_288000_1041000 0.128
R_VDD5_16257 METAL6_288000_1041000 METAL6_288000_1053000 0.024
R_VDD5_16258 METAL6_288000_1053000 METAL6_288000_1065000 0.024
R_VDD5_16259 METAL6_288000_1065000 METAL6_288000_1077000 0.024
R_VDD5_16260 METAL6_288000_1077000 METAL6_288000_1153000 0.152
R_VDD5_16261 METAL6_288000_1153000 METAL6_288000_1165000 0.024
R_VDD5_16262 METAL6_288000_1165000 METAL6_288000_1177000 0.024
R_VDD5_16263 METAL6_288000_1177000 METAL6_288000_1253000 0.152
R_VDD5_16264 METAL6_288000_1253000 METAL6_288000_1265000 0.024
R_VDD5_16265 METAL6_288000_1265000 METAL6_288000_1277000 0.024
R_VDD5_16266 METAL6_288000_1277000 METAL6_288000_1393000 0.232
R_VDD5_16267 METAL6_288000_1393000 METAL5_288000_1393000 0.1
R_VDD5_16268 METAL5_288000_1393000 METAL5_293000_1393000 0.02
R_VDD5_16269 METAL5_293000_1393000 METAL5_300000_1393000 0.028
R_VDD5_16270 METAL5_300000_1393000 METAL5_312000_1393000 0.048
R_VDD5_16271 METAL5_312000_1393000 METAL5_324000_1393000 0.048
R_VDD5_16272 METAL5_324000_1393000 METAL6_324000_1393000 0.1
R_VDD5_16273 METAL6_324000_1393000 METAL6_324000_1407000 0.028
R_VDD5_16274 METAL6_324000_1407000 METAL6_324000_1553000 0.292
R_VDD5_16275 METAL6_324000_1553000 METAL6_324000_1565000 0.024
R_VDD5_16276 METAL6_324000_1565000 METAL6_324000_1577000 0.024
R_VDD5_16277 METAL6_324000_1577000 METAL6_324000_1653000 0.152
R_VDD5_16278 METAL6_324000_1653000 METAL6_324000_1665000 0.024
R_VDD5_16279 METAL6_324000_1665000 METAL6_324000_1677000 0.024
R_VDD5_16280 METAL6_324000_1677000 METAL6_324000_1753000 0.152
R_VDD5_16281 METAL6_324000_1753000 METAL6_324000_1765000 0.024
R_VDD5_16282 METAL6_324000_1765000 METAL6_324000_1777000 0.024
R_VDD5_16283 METAL6_324000_1777000 METAL6_324000_1841000 0.128
R_VDD5_16284 METAL6_324000_1841000 METAL6_324000_1853000 0.024
R_VDD5_16285 METAL6_324000_1853000 METAL6_324000_1865000 0.024
R_VDD5_16286 METAL6_324000_1865000 METAL6_324000_1877000 0.024
R_VDD5_16287 METAL6_324000_1877000 METAL6_324000_1953000 0.152
R_VDD5_16288 METAL6_324000_1953000 METAL6_324000_1965000 0.024
R_VDD5_16289 METAL6_324000_1965000 METAL6_324000_1977000 0.024
R_VDD5_16290 METAL6_324000_1977000 METAL6_324000_2093000 0.232
R_VDD5_16291 METAL6_324000_2093000 METAL6_324000_2107000 0.028
R_VDD5_16292 METAL6_324000_2107000 METAL6_324000_2241000 0.268
R_VDD5_16293 METAL6_324000_2241000 METAL6_324000_2253000 0.024
R_VDD5_16294 METAL6_324000_2253000 METAL6_324000_2265000 0.024
R_VDD5_16295 METAL6_324000_2265000 METAL6_324000_2277000 0.024
R_VDD5_16296 METAL6_324000_2277000 METAL6_324000_2353000 0.152
R_VDD5_16297 METAL6_324000_2353000 METAL6_324000_2365000 0.024
R_VDD5_16298 METAL6_324000_2365000 METAL6_324000_2377000 0.024
R_VDD5_16299 METAL6_324000_2377000 METAL6_324000_2453000 0.152
R_VDD5_16300 METAL6_324000_2453000 METAL6_324000_2465000 0.024
R_VDD5_16301 METAL6_324000_2465000 METAL6_324000_2477000 0.024
R_VDD5_16302 METAL6_324000_2477000 METAL6_324000_2553000 0.152
R_VDD5_16303 METAL6_324000_2553000 METAL6_324000_2565000 0.024
R_VDD5_16304 METAL6_324000_2565000 METAL6_324000_2577000 0.024
R_VDD5_16305 METAL6_324000_2577000 METAL6_324000_2653000 0.152
R_VDD5_16306 METAL6_324000_2653000 METAL6_312000_2653000 0.024
R_VDD5_16307 METAL6_312000_2653000 METAL6_312000_2665000 0.024
R_VDD5_16308 METAL6_312000_2665000 METAL6_312000_2677000 0.024
R_VDD5_16309 METAL6_312000_2677000 METAL6_312000_2793000 0.232
R_VDD5_16310 METAL6_312000_2793000 METAL6_312000_2807000 0.028
R_VDD5_16311 METAL6_312000_2807000 METAL6_312000_2953000 0.292
R_VDD5_16312 METAL6_312000_2953000 METAL6_312000_2965000 0.024
R_VDD5_16313 METAL6_312000_2965000 METAL6_312000_2977000 0.024
R_VDD5_16314 METAL6_312000_2977000 METAL6_312000_3053000 0.152
R_VDD5_16315 METAL6_312000_3053000 METAL6_312000_3065000 0.024
R_VDD5_16316 METAL6_312000_3065000 METAL6_312000_3077000 0.024
R_VDD5_16317 METAL6_312000_3077000 METAL6_312000_3153000 0.152
R_VDD5_16318 METAL6_312000_3153000 METAL6_312000_3165000 0.024
R_VDD5_16319 METAL6_312000_3165000 METAL6_312000_3177000 0.024
R_VDD5_16320 METAL6_312000_3177000 METAL6_312000_3253000 0.152
R_VDD5_16321 METAL6_312000_3253000 METAL6_312000_3265000 0.024
R_VDD5_16322 METAL6_312000_3265000 METAL6_312000_3277000 0.024
R_VDD5_16323 METAL6_312000_3277000 METAL6_312000_3353000 0.152
R_VDD5_16324 METAL6_312000_3353000 METAL5_312000_3353000 0.1
R_VDD5_16325 METAL5_312000_3353000 METAL5_300000_3353000 0.048
R_VDD5_16326 METAL5_300000_3353000 METAL5_293000_3353000 0.028
R_VDD5_16327 METAL5_293000_3353000 METAL5_288000_3353000 0.02
R_VDD5_16328 METAL5_288000_3353000 METAL5_281000_3353000 0.028
R_VDD5_16329 METAL5_281000_3353000 METAL5_276000_3353000 0.02
R_VDD5_16330 METAL5_276000_3353000 METAL5_269000_3353000 0.028
R_VDD5_16331 METAL5_269000_3353000 METAL5_257000_3353000 0.048
R_VDD5_16332 METAL5_257000_3353000 METAL6_257000_3353000 0.1
R_VDD5_16333 METAL6_257000_3353000 METAL6_257000_3365000 0.024
R_VDD5_16334 METAL6_555000_3365000 METAL6_543000_3365000 0.024
R_VDD5_16335 METAL6_412000_565000 METAL5_412000_565000 0.1
R_VDD5_16336 METAL5_412000_565000 METAL5_412000_577000 0.048
R_VDD5_16337 METAL5_412000_577000 METAL5_414000_577000 0.008
R_VDD5_16338 METAL5_414000_577000 METAL5_424000_577000 0.04
R_VDD5_16339 METAL5_424000_577000 METAL6_424000_577000 0.1
R_VDD5_16340 METAL6_424000_577000 METAL6_424000_693000 0.232
R_VDD5_16341 METAL6_424000_693000 METAL6_424000_707000 0.028
R_VDD5_16342 METAL6_424000_707000 METAL6_424000_817000 0.22
R_VDD5_16343 METAL6_424000_817000 METAL6_424000_829000 0.024
R_VDD5_16344 METAL6_424000_829000 METAL6_426000_829000 0.004
R_VDD5_16345 METAL6_426000_829000 METAL6_436000_829000 0.02
R_VDD5_16346 METAL6_436000_829000 METAL6_438000_829000 0.004
R_VDD5_16347 METAL6_438000_829000 METAL6_448000_829000 0.02
R_VDD5_16348 METAL6_448000_829000 METAL5_448000_829000 0.1
R_VDD5_16349 METAL5_448000_829000 METAL5_448000_841000 0.048
R_VDD5_16350 METAL5_448000_841000 METAL5_448000_853000 0.048
R_VDD5_16351 METAL5_448000_853000 METAL6_448000_853000 0.1
R_VDD5_16352 METAL6_448000_853000 METAL6_448000_865000 0.024
R_VDD5_16353 METAL6_448000_865000 METAL6_448000_877000 0.024
R_VDD5_16354 METAL6_448000_877000 METAL6_448000_917000 0.08
R_VDD5_16355 METAL6_448000_917000 METAL6_448000_929000 0.024
R_VDD5_16356 METAL6_448000_929000 METAL6_448000_941000 0.024
R_VDD5_16357 METAL6_448000_941000 METAL6_448000_953000 0.024
R_VDD5_16358 METAL6_448000_953000 METAL6_448000_965000 0.024
R_VDD5_16359 METAL6_448000_965000 METAL6_448000_977000 0.024
R_VDD5_16360 METAL6_448000_977000 METAL6_448000_1041000 0.128
R_VDD5_16361 METAL6_448000_1041000 METAL6_448000_1053000 0.024
R_VDD5_16362 METAL6_448000_1053000 METAL6_448000_1065000 0.024
R_VDD5_16363 METAL6_448000_1065000 METAL6_448000_1077000 0.024
R_VDD5_16364 METAL6_448000_1077000 METAL6_448000_1153000 0.152
R_VDD5_16365 METAL6_448000_1153000 METAL6_448000_1165000 0.024
R_VDD5_16366 METAL6_448000_1165000 METAL6_448000_1177000 0.024
R_VDD5_16367 METAL6_448000_1177000 METAL6_448000_1253000 0.152
R_VDD5_16368 METAL6_448000_1253000 METAL6_448000_1265000 0.024
R_VDD5_16369 METAL6_448000_1265000 METAL6_448000_1277000 0.024
R_VDD5_16370 METAL6_448000_1277000 METAL6_448000_1381000 0.208
R_VDD5_16371 METAL6_448000_1381000 METAL6_448000_1393000 0.024
R_VDD5_16372 METAL6_448000_1393000 METAL6_448000_1405000 0.024
R_VDD5_16373 METAL6_448000_1405000 METAL6_448000_1407000 0.004
R_VDD5_16374 METAL6_448000_1407000 METAL6_448000_1553000 0.292
R_VDD5_16375 METAL6_448000_1553000 METAL6_448000_1565000 0.024
R_VDD5_16376 METAL6_448000_1565000 METAL6_448000_1577000 0.024
R_VDD5_16377 METAL6_448000_1577000 METAL6_448000_1653000 0.152
R_VDD5_16378 METAL6_448000_1653000 METAL6_448000_1665000 0.024
R_VDD5_16379 METAL6_448000_1665000 METAL6_448000_1677000 0.024
R_VDD5_16380 METAL6_448000_1677000 METAL6_448000_1753000 0.152
R_VDD5_16381 METAL6_448000_1753000 METAL6_448000_1765000 0.024
R_VDD5_16382 METAL6_448000_1765000 METAL6_448000_1777000 0.024
R_VDD5_16383 METAL6_448000_1777000 METAL6_448000_1841000 0.128
R_VDD5_16384 METAL6_448000_1841000 METAL6_448000_1853000 0.024
R_VDD5_16385 METAL6_448000_1853000 METAL6_448000_1865000 0.024
R_VDD5_16386 METAL6_448000_1865000 METAL6_448000_1877000 0.024
R_VDD5_16387 METAL6_448000_1877000 METAL6_448000_1953000 0.152
R_VDD5_16388 METAL6_448000_1953000 METAL6_448000_1965000 0.024
R_VDD5_16389 METAL6_448000_1965000 METAL6_448000_1977000 0.024
R_VDD5_16390 METAL6_448000_1977000 METAL6_448000_2093000 0.232
R_VDD5_16391 METAL6_448000_2093000 METAL6_448000_2107000 0.028
R_VDD5_16392 METAL6_448000_2107000 METAL6_448000_2241000 0.268
R_VDD5_16393 METAL6_448000_2241000 METAL6_448000_2253000 0.024
R_VDD5_16394 METAL6_448000_2253000 METAL6_448000_2265000 0.024
R_VDD5_16395 METAL6_448000_2265000 METAL6_448000_2277000 0.024
R_VDD5_16396 METAL6_448000_2277000 METAL6_448000_2353000 0.152
R_VDD5_16397 METAL6_448000_2353000 METAL6_448000_2365000 0.024
R_VDD5_16398 METAL6_448000_2365000 METAL6_448000_2377000 0.024
R_VDD5_16399 METAL6_448000_2377000 METAL6_448000_2453000 0.152
R_VDD5_16400 METAL6_448000_2453000 METAL6_448000_2465000 0.024
R_VDD5_16401 METAL6_448000_2465000 METAL6_448000_2477000 0.024
R_VDD5_16402 METAL6_448000_2477000 METAL6_448000_2553000 0.152
R_VDD5_16403 METAL6_448000_2553000 METAL6_448000_2565000 0.024
R_VDD5_16404 METAL6_448000_2565000 METAL6_448000_2577000 0.024
R_VDD5_16405 METAL6_448000_2577000 METAL6_448000_2641000 0.128
R_VDD5_16406 METAL6_448000_2641000 METAL6_448000_2653000 0.024
R_VDD5_16407 METAL6_448000_2653000 METAL6_448000_2665000 0.024
R_VDD5_16408 METAL6_448000_2665000 METAL6_448000_2677000 0.024
R_VDD5_16409 METAL6_448000_2677000 METAL6_448000_2793000 0.232
R_VDD5_16410 METAL6_448000_2793000 METAL6_448000_2807000 0.028
R_VDD5_16411 METAL6_448000_2807000 METAL6_448000_2953000 0.292
R_VDD5_16412 METAL6_448000_2953000 METAL6_448000_2965000 0.024
R_VDD5_16413 METAL6_448000_2965000 METAL6_448000_2977000 0.024
R_VDD5_16414 METAL6_448000_2977000 METAL6_448000_3053000 0.152
R_VDD5_16415 METAL6_448000_3053000 METAL6_448000_3065000 0.024
R_VDD5_16416 METAL6_448000_3065000 METAL6_448000_3077000 0.024
R_VDD5_16417 METAL6_448000_3077000 METAL6_448000_3153000 0.152
R_VDD5_16418 METAL6_448000_3153000 METAL6_448000_3165000 0.024
R_VDD5_16419 METAL6_448000_3165000 METAL6_448000_3177000 0.024
R_VDD5_16420 METAL6_448000_3177000 METAL6_448000_3253000 0.152
R_VDD5_16421 METAL6_448000_3253000 METAL6_448000_3265000 0.024
R_VDD5_16422 METAL6_448000_3265000 METAL6_448000_3277000 0.024
R_VDD5_16423 METAL6_448000_3277000 METAL6_448000_3341000 0.128
R_VDD5_16424 METAL6_448000_3341000 METAL6_448000_3353000 0.024
R_VDD5_16425 METAL6_448000_3353000 METAL6_448000_3365000 0.024
R_VDD5_16426 METAL6_448000_3365000 METAL6_450000_3365000 0.004
R_VDD5_16427 METAL6_450000_3365000 METAL6_452000_3365000 0.004
R_VDD5_16428 METAL6_452000_3365000 METAL6_462000_3365000 0.02
R_VDD5_16429 METAL6_462000_3365000 METAL6_464000_3365000 0.004
R_VDD5_16430 METAL6_464000_3365000 METAL5_464000_3365000 0.1
R_VDD5_16431 METAL5_464000_3365000 METAL5_474000_3365000 0.04
R_VDD5_16432 METAL5_474000_3365000 METAL5_476000_3365000 0.008
R_VDD5_16433 METAL5_476000_3365000 METAL5_486000_3365000 0.04
R_VDD5_16434 METAL5_486000_3365000 METAL5_488000_3365000 0.008
R_VDD5_16435 METAL5_488000_3365000 METAL5_500000_3365000 0.048
R_VDD5_16436 METAL5_500000_3365000 METAL5_507000_3365000 0.028
R_VDD5_16437 METAL5_507000_3365000 METAL5_512000_3365000 0.02
R_VDD5_16438 METAL5_512000_3365000 METAL5_519000_3365000 0.028
R_VDD5_16439 METAL5_519000_3365000 METAL5_524000_3365000 0.02
R_VDD5_16440 METAL5_524000_3365000 METAL5_531000_3365000 0.028
R_VDD5_16441 METAL5_531000_3365000 METAL5_543000_3365000 0.048
R_VDD5_16442 METAL5_543000_3365000 METAL6_543000_3365000 0.1
R_VDD5_16443 METAL6_245000_2665000 METAL6_257000_2665000 0.024
R_VDD5_16444 METAL6_488000_277000 METAL5_488000_277000 0.1
R_VDD5_16445 METAL5_488000_277000 METAL5_488000_265000 0.048
R_VDD5_16446 METAL5_488000_265000 METAL5_486000_265000 0.008
R_VDD5_16447 METAL5_486000_265000 METAL5_476000_265000 0.04
R_VDD5_16448 METAL5_476000_265000 METAL5_474000_265000 0.008
R_VDD5_16449 METAL5_474000_265000 METAL5_464000_265000 0.04
R_VDD5_16450 METAL5_464000_265000 METAL5_462000_265000 0.008
R_VDD5_16451 METAL5_462000_265000 METAL5_460000_265000 0.008
R_VDD5_16452 METAL5_460000_265000 METAL5_452000_265000 0.032
R_VDD5_16453 METAL5_452000_265000 METAL5_450000_265000 0.008
R_VDD5_16454 METAL5_450000_265000 METAL5_448000_265000 0.008
R_VDD5_16455 METAL5_448000_265000 METAL5_438000_265000 0.04
R_VDD5_16456 METAL5_438000_265000 METAL5_438000_277000 0.048
R_VDD5_16457 METAL5_438000_277000 METAL5_436000_277000 0.008
R_VDD5_16458 METAL5_436000_277000 METAL5_426000_277000 0.04
R_VDD5_16459 METAL5_426000_277000 METAL5_424000_277000 0.008
R_VDD5_16460 METAL5_424000_277000 METAL5_414000_277000 0.04
R_VDD5_16461 METAL5_414000_277000 METAL5_414000_289000 0.048
R_VDD5_16462 METAL5_414000_289000 METAL5_414000_301000 0.048
R_VDD5_16463 METAL5_414000_301000 METAL5_414000_317000 0.064
R_VDD5_16464 METAL5_414000_317000 METAL5_414000_329000 0.048
R_VDD5_16465 METAL5_414000_329000 METAL5_414000_341000 0.048
R_VDD5_16466 METAL5_414000_341000 METAL5_414000_353000 0.048
R_VDD5_16467 METAL5_414000_353000 METAL5_414000_365000 0.048
R_VDD5_16468 METAL5_414000_365000 METAL6_414000_365000 0.1
R_VDD5_16469 METAL6_414000_365000 METAL6_414000_377000 0.024
R_VDD5_16470 METAL6_414000_377000 METAL6_414000_441000 0.128
R_VDD5_16471 METAL6_414000_441000 METAL6_414000_453000 0.024
R_VDD5_16472 METAL6_414000_453000 METAL6_414000_465000 0.024
R_VDD5_16473 METAL6_414000_465000 METAL6_414000_477000 0.024
R_VDD5_16474 METAL6_414000_477000 METAL6_414000_529000 0.104
R_VDD5_16475 METAL6_414000_529000 METAL6_412000_529000 0.004
R_VDD5_16476 METAL6_412000_529000 METAL6_400000_529000 0.024
R_VDD5_16477 METAL6_400000_529000 METAL6_388000_529000 0.024
R_VDD5_16478 METAL6_388000_529000 METAL6_386000_529000 0.004
R_VDD5_16479 METAL6_386000_529000 METAL6_376000_529000 0.02
R_VDD5_16480 METAL6_376000_529000 METAL6_376000_541000 0.024
R_VDD5_16481 METAL6_376000_541000 METAL6_376000_553000 0.024
R_VDD5_16482 METAL6_376000_553000 METAL6_376000_565000 0.024
R_VDD5_16483 METAL6_376000_565000 METAL6_376000_577000 0.024
R_VDD5_16484 METAL6_376000_577000 METAL6_376000_589000 0.024
R_VDD5_16485 METAL6_376000_589000 METAL6_376000_693000 0.208
R_VDD5_16486 METAL6_376000_693000 METAL6_376000_707000 0.028
R_VDD5_16487 METAL6_376000_707000 METAL6_376000_817000 0.22
R_VDD5_16488 METAL6_376000_817000 METAL6_376000_829000 0.024
R_VDD5_16489 METAL6_376000_829000 METAL6_376000_841000 0.024
R_VDD5_16490 METAL6_376000_841000 METAL6_374000_841000 0.004
R_VDD5_16491 METAL6_374000_841000 METAL6_362000_841000 0.024
R_VDD5_16492 METAL6_362000_841000 METAL6_350000_841000 0.024
R_VDD5_16493 METAL6_350000_841000 METAL6_338000_841000 0.024
R_VDD5_16494 METAL6_338000_841000 METAL6_336000_841000 0.004
R_VDD5_16495 METAL6_336000_841000 METAL6_326000_841000 0.02
R_VDD5_16496 METAL6_326000_841000 METAL6_326000_853000 0.024
R_VDD5_16497 METAL6_326000_853000 METAL6_326000_865000 0.024
R_VDD5_16498 METAL6_326000_865000 METAL6_326000_877000 0.024
R_VDD5_16499 METAL6_326000_877000 METAL6_326000_917000 0.08
R_VDD5_16500 METAL6_326000_917000 METAL5_326000_917000 0.1
R_VDD5_16501 METAL5_326000_917000 METAL5_336000_917000 0.04
R_VDD5_16502 METAL5_336000_917000 METAL5_338000_917000 0.008
R_VDD5_16503 METAL5_338000_917000 METAL5_350000_917000 0.048
R_VDD5_16504 METAL5_350000_917000 METAL5_350000_929000 0.048
R_VDD5_16505 METAL5_350000_929000 METAL5_350000_941000 0.048
R_VDD5_16506 METAL5_350000_941000 METAL5_350000_953000 0.048
R_VDD5_16507 METAL5_350000_953000 METAL5_350000_965000 0.048
R_VDD5_16508 METAL5_350000_965000 METAL6_350000_965000 0.1
R_VDD5_16509 METAL6_350000_965000 METAL6_350000_977000 0.024
R_VDD5_16510 METAL6_350000_977000 METAL6_350000_1041000 0.128
R_VDD5_16511 METAL6_350000_1041000 METAL6_350000_1053000 0.024
R_VDD5_16512 METAL6_350000_1053000 METAL6_350000_1065000 0.024
R_VDD5_16513 METAL6_350000_1065000 METAL6_350000_1077000 0.024
R_VDD5_16514 METAL6_350000_1077000 METAL6_350000_1153000 0.152
R_VDD5_16515 METAL6_350000_1153000 METAL6_350000_1165000 0.024
R_VDD5_16516 METAL6_350000_1165000 METAL6_350000_1177000 0.024
R_VDD5_16517 METAL6_350000_1177000 METAL6_350000_1253000 0.152
R_VDD5_16518 METAL6_350000_1253000 METAL6_350000_1265000 0.024
R_VDD5_16519 METAL6_350000_1265000 METAL6_350000_1277000 0.024
R_VDD5_16520 METAL6_350000_1277000 METAL6_350000_1381000 0.208
R_VDD5_16521 METAL6_350000_1381000 METAL6_350000_1393000 0.024
R_VDD5_16522 METAL6_350000_1393000 METAL6_350000_1405000 0.024
R_VDD5_16523 METAL6_350000_1405000 METAL6_350000_1407000 0.004
R_VDD5_16524 METAL6_350000_1407000 METAL6_350000_1553000 0.292
R_VDD5_16525 METAL6_350000_1553000 METAL6_350000_1565000 0.024
R_VDD5_16526 METAL6_350000_1565000 METAL6_350000_1577000 0.024
R_VDD5_16527 METAL6_350000_1577000 METAL6_350000_1653000 0.152
R_VDD5_16528 METAL6_350000_1653000 METAL6_350000_1665000 0.024
R_VDD5_16529 METAL6_350000_1665000 METAL6_350000_1677000 0.024
R_VDD5_16530 METAL6_350000_1677000 METAL6_350000_1753000 0.152
R_VDD5_16531 METAL6_350000_1753000 METAL6_350000_1765000 0.024
R_VDD5_16532 METAL6_350000_1765000 METAL6_350000_1777000 0.024
R_VDD5_16533 METAL6_350000_1777000 METAL6_350000_1841000 0.128
R_VDD5_16534 METAL6_350000_1841000 METAL6_350000_1853000 0.024
R_VDD5_16535 METAL6_350000_1853000 METAL6_350000_1865000 0.024
R_VDD5_16536 METAL6_350000_1865000 METAL6_350000_1877000 0.024
R_VDD5_16537 METAL6_350000_1877000 METAL6_350000_1953000 0.152
R_VDD5_16538 METAL6_350000_1953000 METAL6_350000_1965000 0.024
R_VDD5_16539 METAL6_350000_1965000 METAL6_350000_1977000 0.024
R_VDD5_16540 METAL6_350000_1977000 METAL6_350000_2093000 0.232
R_VDD5_16541 METAL6_350000_2093000 METAL6_350000_2107000 0.028
R_VDD5_16542 METAL6_350000_2107000 METAL6_350000_2241000 0.268
R_VDD5_16543 METAL6_350000_2241000 METAL6_350000_2253000 0.024
R_VDD5_16544 METAL6_350000_2253000 METAL6_350000_2265000 0.024
R_VDD5_16545 METAL6_350000_2265000 METAL6_350000_2277000 0.024
R_VDD5_16546 METAL6_350000_2277000 METAL6_350000_2353000 0.152
R_VDD5_16547 METAL6_350000_2353000 METAL6_350000_2365000 0.024
R_VDD5_16548 METAL6_350000_2365000 METAL6_350000_2377000 0.024
R_VDD5_16549 METAL6_350000_2377000 METAL6_350000_2453000 0.152
R_VDD5_16550 METAL6_350000_2453000 METAL6_350000_2465000 0.024
R_VDD5_16551 METAL6_350000_2465000 METAL6_350000_2477000 0.024
R_VDD5_16552 METAL6_350000_2477000 METAL6_350000_2553000 0.152
R_VDD5_16553 METAL6_350000_2553000 METAL6_350000_2565000 0.024
R_VDD5_16554 METAL6_350000_2565000 METAL6_350000_2577000 0.024
R_VDD5_16555 METAL6_350000_2577000 METAL6_350000_2641000 0.128
R_VDD5_16556 METAL6_350000_2641000 METAL5_350000_2641000 0.1
R_VDD5_16557 METAL5_350000_2641000 METAL5_338000_2641000 0.048
R_VDD5_16558 METAL5_338000_2641000 METAL5_336000_2641000 0.008
R_VDD5_16559 METAL5_336000_2641000 METAL5_326000_2641000 0.04
R_VDD5_16560 METAL5_326000_2641000 METAL5_324000_2641000 0.008
R_VDD5_16561 METAL5_324000_2641000 METAL5_312000_2641000 0.048
R_VDD5_16562 METAL5_312000_2641000 METAL5_300000_2641000 0.048
R_VDD5_16563 METAL5_300000_2641000 METAL5_293000_2641000 0.028
R_VDD5_16564 METAL5_293000_2641000 METAL5_288000_2641000 0.02
R_VDD5_16565 METAL5_288000_2641000 METAL5_281000_2641000 0.028
R_VDD5_16566 METAL5_281000_2641000 METAL5_276000_2641000 0.02
R_VDD5_16567 METAL5_276000_2641000 METAL5_269000_2641000 0.028
R_VDD5_16568 METAL5_269000_2641000 METAL5_257000_2641000 0.048
R_VDD5_16569 METAL5_257000_2641000 METAL6_257000_2641000 0.1
R_VDD5_16570 METAL6_257000_2641000 METAL6_257000_2653000 0.024
R_VDD5_16571 METAL6_257000_2653000 METAL6_257000_2665000 0.024
R_VDD5_16572 METAL6_555000_2665000 METAL6_543000_2665000 0.024
R_VDD5_16573 METAL6_500000_277000 METAL5_500000_277000 0.1
R_VDD5_16574 METAL5_500000_277000 METAL5_500000_265000 0.048
R_VDD5_16575 METAL5_500000_265000 METAL5_500000_253000 0.048
R_VDD5_16576 METAL5_500000_253000 METAL5_488000_253000 0.048
R_VDD5_16577 METAL5_488000_253000 METAL5_486000_253000 0.008
R_VDD5_16578 METAL5_486000_253000 METAL5_476000_253000 0.04
R_VDD5_16579 METAL5_476000_253000 METAL5_474000_253000 0.008
R_VDD5_16580 METAL5_474000_253000 METAL5_464000_253000 0.04
R_VDD5_16581 METAL5_464000_253000 METAL5_462000_253000 0.008
R_VDD5_16582 METAL5_462000_253000 METAL5_460000_253000 0.008
R_VDD5_16583 METAL5_460000_253000 METAL5_452000_253000 0.032
R_VDD5_16584 METAL5_452000_253000 METAL5_450000_253000 0.008
R_VDD5_16585 METAL5_450000_253000 METAL5_448000_253000 0.008
R_VDD5_16586 METAL5_448000_253000 METAL5_438000_253000 0.04
R_VDD5_16587 METAL5_438000_253000 METAL6_438000_253000 0.1
R_VDD5_16588 METAL6_438000_253000 METAL6_438000_265000 0.024
R_VDD5_16589 METAL6_438000_265000 METAL6_436000_265000 0.004
R_VDD5_16590 METAL6_436000_265000 METAL6_426000_265000 0.02
R_VDD5_16591 METAL6_426000_265000 METAL6_426000_277000 0.024
R_VDD5_16592 METAL6_426000_277000 METAL6_424000_277000 0.004
R_VDD5_16593 METAL6_424000_277000 METAL6_414000_277000 0.02
R_VDD5_16594 METAL6_414000_277000 METAL6_414000_289000 0.024
R_VDD5_16595 METAL6_414000_289000 METAL6_414000_301000 0.024
R_VDD5_16596 METAL6_414000_301000 METAL6_414000_317000 0.032
R_VDD5_16597 METAL6_414000_317000 METAL6_414000_329000 0.024
R_VDD5_16598 METAL6_414000_329000 METAL6_412000_329000 0.004
R_VDD5_16599 METAL6_412000_329000 METAL6_402000_329000 0.02
R_VDD5_16600 METAL6_402000_329000 METAL5_402000_329000 0.1
R_VDD5_16601 METAL5_402000_329000 METAL5_402000_341000 0.048
R_VDD5_16602 METAL5_402000_341000 METAL5_402000_353000 0.048
R_VDD5_16603 METAL5_402000_353000 METAL5_402000_365000 0.048
R_VDD5_16604 METAL5_402000_365000 METAL6_402000_365000 0.1
R_VDD5_16605 METAL6_402000_365000 METAL6_402000_377000 0.024
R_VDD5_16606 METAL6_402000_377000 METAL6_402000_441000 0.128
R_VDD5_16607 METAL6_402000_441000 METAL6_402000_453000 0.024
R_VDD5_16608 METAL6_402000_453000 METAL6_402000_465000 0.024
R_VDD5_16609 METAL6_402000_465000 METAL6_402000_477000 0.024
R_VDD5_16610 METAL6_402000_477000 METAL6_402000_517000 0.08
R_VDD5_16611 METAL6_402000_517000 METAL6_400000_517000 0.004
R_VDD5_16612 METAL6_400000_517000 METAL6_388000_517000 0.024
R_VDD5_16613 METAL6_388000_517000 METAL6_386000_517000 0.004
R_VDD5_16614 METAL6_386000_517000 METAL6_376000_517000 0.02
R_VDD5_16615 METAL6_376000_517000 METAL6_374000_517000 0.004
R_VDD5_16616 METAL6_374000_517000 METAL6_364000_517000 0.02
R_VDD5_16617 METAL6_364000_517000 METAL6_364000_529000 0.024
R_VDD5_16618 METAL6_364000_529000 METAL6_364000_541000 0.024
R_VDD5_16619 METAL6_364000_541000 METAL6_364000_553000 0.024
R_VDD5_16620 METAL6_364000_553000 METAL6_364000_565000 0.024
R_VDD5_16621 METAL6_364000_565000 METAL6_364000_577000 0.024
R_VDD5_16622 METAL6_364000_577000 METAL6_364000_589000 0.024
R_VDD5_16623 METAL6_364000_589000 METAL6_364000_693000 0.208
R_VDD5_16624 METAL6_364000_693000 METAL6_364000_707000 0.028
R_VDD5_16625 METAL6_364000_707000 METAL6_364000_817000 0.22
R_VDD5_16626 METAL6_364000_817000 METAL5_364000_817000 0.1
R_VDD5_16627 METAL5_364000_817000 METAL5_374000_817000 0.04
R_VDD5_16628 METAL5_374000_817000 METAL5_376000_817000 0.008
R_VDD5_16629 METAL5_376000_817000 METAL5_386000_817000 0.04
R_VDD5_16630 METAL5_386000_817000 METAL5_388000_817000 0.008
R_VDD5_16631 METAL5_388000_817000 METAL5_400000_817000 0.048
R_VDD5_16632 METAL5_400000_817000 METAL5_402000_817000 0.008
R_VDD5_16633 METAL5_402000_817000 METAL5_412000_817000 0.04
R_VDD5_16634 METAL5_412000_817000 METAL5_414000_817000 0.008
R_VDD5_16635 METAL5_414000_817000 METAL5_424000_817000 0.04
R_VDD5_16636 METAL5_424000_817000 METAL5_426000_817000 0.008
R_VDD5_16637 METAL5_426000_817000 METAL5_436000_817000 0.04
R_VDD5_16638 METAL5_436000_817000 METAL5_438000_817000 0.008
R_VDD5_16639 METAL5_438000_817000 METAL5_448000_817000 0.04
R_VDD5_16640 METAL5_448000_817000 METAL5_450000_817000 0.008
R_VDD5_16641 METAL5_450000_817000 METAL5_452000_817000 0.008
R_VDD5_16642 METAL5_452000_817000 METAL5_460000_817000 0.032
R_VDD5_16643 METAL5_460000_817000 METAL5_460000_829000 0.048
R_VDD5_16644 METAL5_460000_829000 METAL5_460000_841000 0.048
R_VDD5_16645 METAL5_460000_841000 METAL5_460000_853000 0.048
R_VDD5_16646 METAL5_460000_853000 METAL6_460000_853000 0.1
R_VDD5_16647 METAL6_460000_853000 METAL6_460000_865000 0.024
R_VDD5_16648 METAL6_460000_865000 METAL6_460000_877000 0.024
R_VDD5_16649 METAL6_460000_877000 METAL6_460000_905000 0.056
R_VDD5_16650 METAL6_460000_905000 METAL6_460000_917000 0.024
R_VDD5_16651 METAL6_460000_917000 METAL6_460000_929000 0.024
R_VDD5_16652 METAL6_460000_929000 METAL6_460000_941000 0.024
R_VDD5_16653 METAL6_460000_941000 METAL6_460000_953000 0.024
R_VDD5_16654 METAL6_460000_953000 METAL6_460000_965000 0.024
R_VDD5_16655 METAL6_460000_965000 METAL6_460000_977000 0.024
R_VDD5_16656 METAL6_460000_977000 METAL6_460000_1041000 0.128
R_VDD5_16657 METAL6_460000_1041000 METAL6_460000_1053000 0.024
R_VDD5_16658 METAL6_460000_1053000 METAL6_460000_1065000 0.024
R_VDD5_16659 METAL6_460000_1065000 METAL6_460000_1077000 0.024
R_VDD5_16660 METAL6_460000_1077000 METAL6_460000_1153000 0.152
R_VDD5_16661 METAL6_460000_1153000 METAL6_460000_1165000 0.024
R_VDD5_16662 METAL6_460000_1165000 METAL6_460000_1177000 0.024
R_VDD5_16663 METAL6_460000_1177000 METAL6_460000_1253000 0.152
R_VDD5_16664 METAL6_460000_1253000 METAL6_460000_1265000 0.024
R_VDD5_16665 METAL6_460000_1265000 METAL6_460000_1277000 0.024
R_VDD5_16666 METAL6_460000_1277000 METAL6_460000_1381000 0.208
R_VDD5_16667 METAL6_460000_1381000 METAL6_460000_1393000 0.024
R_VDD5_16668 METAL6_460000_1393000 METAL6_460000_1405000 0.024
R_VDD5_16669 METAL6_460000_1405000 METAL6_460000_1407000 0.004
R_VDD5_16670 METAL6_460000_1407000 METAL6_460000_1553000 0.292
R_VDD5_16671 METAL6_460000_1553000 METAL6_460000_1565000 0.024
R_VDD5_16672 METAL6_460000_1565000 METAL6_460000_1577000 0.024
R_VDD5_16673 METAL6_460000_1577000 METAL6_460000_1653000 0.152
R_VDD5_16674 METAL6_460000_1653000 METAL6_460000_1665000 0.024
R_VDD5_16675 METAL6_460000_1665000 METAL6_460000_1677000 0.024
R_VDD5_16676 METAL6_460000_1677000 METAL6_460000_1753000 0.152
R_VDD5_16677 METAL6_460000_1753000 METAL6_460000_1765000 0.024
R_VDD5_16678 METAL6_460000_1765000 METAL6_460000_1777000 0.024
R_VDD5_16679 METAL6_460000_1777000 METAL6_460000_1841000 0.128
R_VDD5_16680 METAL6_460000_1841000 METAL6_460000_1853000 0.024
R_VDD5_16681 METAL6_460000_1853000 METAL6_460000_1865000 0.024
R_VDD5_16682 METAL6_460000_1865000 METAL6_460000_1877000 0.024
R_VDD5_16683 METAL6_460000_1877000 METAL6_460000_1953000 0.152
R_VDD5_16684 METAL6_460000_1953000 METAL6_460000_1965000 0.024
R_VDD5_16685 METAL6_460000_1965000 METAL6_460000_1977000 0.024
R_VDD5_16686 METAL6_460000_1977000 METAL6_460000_2093000 0.232
R_VDD5_16687 METAL6_460000_2093000 METAL6_460000_2107000 0.028
R_VDD5_16688 METAL6_460000_2107000 METAL6_460000_2241000 0.268
R_VDD5_16689 METAL6_460000_2241000 METAL6_460000_2253000 0.024
R_VDD5_16690 METAL6_460000_2253000 METAL6_460000_2265000 0.024
R_VDD5_16691 METAL6_460000_2265000 METAL6_460000_2277000 0.024
R_VDD5_16692 METAL6_460000_2277000 METAL6_460000_2353000 0.152
R_VDD5_16693 METAL6_460000_2353000 METAL6_460000_2365000 0.024
R_VDD5_16694 METAL6_460000_2365000 METAL6_460000_2377000 0.024
R_VDD5_16695 METAL6_460000_2377000 METAL6_460000_2453000 0.152
R_VDD5_16696 METAL6_460000_2453000 METAL6_460000_2465000 0.024
R_VDD5_16697 METAL6_460000_2465000 METAL6_460000_2477000 0.024
R_VDD5_16698 METAL6_460000_2477000 METAL6_460000_2553000 0.152
R_VDD5_16699 METAL6_460000_2553000 METAL6_460000_2565000 0.024
R_VDD5_16700 METAL6_460000_2565000 METAL6_460000_2577000 0.024
R_VDD5_16701 METAL6_460000_2577000 METAL6_460000_2629000 0.104
R_VDD5_16702 METAL6_460000_2629000 METAL6_460000_2641000 0.024
R_VDD5_16703 METAL6_460000_2641000 METAL6_460000_2653000 0.024
R_VDD5_16704 METAL6_460000_2653000 METAL6_460000_2665000 0.024
R_VDD5_16705 METAL6_460000_2665000 METAL6_462000_2665000 0.004
R_VDD5_16706 METAL6_462000_2665000 METAL6_464000_2665000 0.004
R_VDD5_16707 METAL6_464000_2665000 METAL5_464000_2665000 0.1
R_VDD5_16708 METAL5_464000_2665000 METAL5_474000_2665000 0.04
R_VDD5_16709 METAL5_474000_2665000 METAL5_476000_2665000 0.008
R_VDD5_16710 METAL5_476000_2665000 METAL5_486000_2665000 0.04
R_VDD5_16711 METAL5_486000_2665000 METAL5_488000_2665000 0.008
R_VDD5_16712 METAL5_488000_2665000 METAL5_500000_2665000 0.048
R_VDD5_16713 METAL5_500000_2665000 METAL5_507000_2665000 0.028
R_VDD5_16714 METAL5_507000_2665000 METAL5_512000_2665000 0.02
R_VDD5_16715 METAL5_512000_2665000 METAL5_519000_2665000 0.028
R_VDD5_16716 METAL5_519000_2665000 METAL5_524000_2665000 0.02
R_VDD5_16717 METAL5_524000_2665000 METAL5_531000_2665000 0.028
R_VDD5_16718 METAL5_531000_2665000 METAL5_543000_2665000 0.048
R_VDD5_16719 METAL5_543000_2665000 METAL6_543000_2665000 0.1
R_VDD5_16720 METAL6_245000_1965000 METAL6_257000_1965000 0.024
R_VDD5_16721 METAL6_312000_553000 METAL6_314000_553000 0.004
R_VDD5_16722 METAL6_314000_553000 METAL6_324000_553000 0.02
R_VDD5_16723 METAL6_324000_553000 METAL6_324000_565000 0.024
R_VDD5_16724 METAL6_324000_565000 METAL6_324000_577000 0.024
R_VDD5_16725 METAL6_324000_577000 METAL6_324000_589000 0.024
R_VDD5_16726 METAL6_324000_589000 METAL6_324000_693000 0.208
R_VDD5_16727 METAL6_324000_693000 METAL6_324000_707000 0.028
R_VDD5_16728 METAL6_324000_707000 METAL6_324000_805000 0.196
R_VDD5_16729 METAL6_324000_805000 METAL6_324000_817000 0.024
R_VDD5_16730 METAL6_324000_817000 METAL6_324000_829000 0.024
R_VDD5_16731 METAL6_324000_829000 METAL6_314000_829000 0.02
R_VDD5_16732 METAL6_314000_829000 METAL6_314000_841000 0.024
R_VDD5_16733 METAL6_314000_841000 METAL6_314000_853000 0.024
R_VDD5_16734 METAL6_314000_853000 METAL6_314000_865000 0.024
R_VDD5_16735 METAL6_314000_865000 METAL6_314000_877000 0.024
R_VDD5_16736 METAL6_314000_877000 METAL6_314000_905000 0.056
R_VDD5_16737 METAL6_314000_905000 METAL6_314000_917000 0.024
R_VDD5_16738 METAL6_314000_917000 METAL6_314000_929000 0.024
R_VDD5_16739 METAL6_314000_929000 METAL6_324000_929000 0.02
R_VDD5_16740 METAL6_324000_929000 METAL6_326000_929000 0.004
R_VDD5_16741 METAL6_326000_929000 METAL5_326000_929000 0.1
R_VDD5_16742 METAL5_326000_929000 METAL5_326000_941000 0.048
R_VDD5_16743 METAL5_326000_941000 METAL5_326000_953000 0.048
R_VDD5_16744 METAL5_326000_953000 METAL5_326000_965000 0.048
R_VDD5_16745 METAL5_326000_965000 METAL5_326000_977000 0.048
R_VDD5_16746 METAL5_326000_977000 METAL5_336000_977000 0.04
R_VDD5_16747 METAL5_336000_977000 METAL5_338000_977000 0.008
R_VDD5_16748 METAL5_338000_977000 METAL5_350000_977000 0.048
R_VDD5_16749 METAL5_350000_977000 METAL5_352000_977000 0.008
R_VDD5_16750 METAL5_352000_977000 METAL5_362000_977000 0.04
R_VDD5_16751 METAL5_362000_977000 METAL6_362000_977000 0.1
R_VDD5_16752 METAL6_362000_977000 METAL6_362000_1041000 0.128
R_VDD5_16753 METAL6_362000_1041000 METAL6_362000_1053000 0.024
R_VDD5_16754 METAL6_362000_1053000 METAL6_362000_1065000 0.024
R_VDD5_16755 METAL6_362000_1065000 METAL6_362000_1077000 0.024
R_VDD5_16756 METAL6_362000_1077000 METAL6_362000_1153000 0.152
R_VDD5_16757 METAL6_362000_1153000 METAL6_362000_1165000 0.024
R_VDD5_16758 METAL6_362000_1165000 METAL6_362000_1177000 0.024
R_VDD5_16759 METAL6_362000_1177000 METAL6_362000_1253000 0.152
R_VDD5_16760 METAL6_362000_1253000 METAL6_362000_1265000 0.024
R_VDD5_16761 METAL6_362000_1265000 METAL6_362000_1277000 0.024
R_VDD5_16762 METAL6_362000_1277000 METAL6_362000_1381000 0.208
R_VDD5_16763 METAL6_362000_1381000 METAL6_362000_1393000 0.024
R_VDD5_16764 METAL6_362000_1393000 METAL6_362000_1405000 0.024
R_VDD5_16765 METAL6_362000_1405000 METAL6_362000_1407000 0.004
R_VDD5_16766 METAL6_362000_1407000 METAL6_362000_1553000 0.292
R_VDD5_16767 METAL6_362000_1553000 METAL6_362000_1565000 0.024
R_VDD5_16768 METAL6_362000_1565000 METAL6_362000_1577000 0.024
R_VDD5_16769 METAL6_362000_1577000 METAL6_362000_1653000 0.152
R_VDD5_16770 METAL6_362000_1653000 METAL6_362000_1665000 0.024
R_VDD5_16771 METAL6_362000_1665000 METAL6_362000_1677000 0.024
R_VDD5_16772 METAL6_362000_1677000 METAL6_362000_1753000 0.152
R_VDD5_16773 METAL6_362000_1753000 METAL6_362000_1765000 0.024
R_VDD5_16774 METAL6_362000_1765000 METAL6_362000_1777000 0.024
R_VDD5_16775 METAL6_362000_1777000 METAL6_362000_1841000 0.128
R_VDD5_16776 METAL6_362000_1841000 METAL6_362000_1853000 0.024
R_VDD5_16777 METAL6_362000_1853000 METAL6_362000_1865000 0.024
R_VDD5_16778 METAL6_362000_1865000 METAL6_362000_1877000 0.024
R_VDD5_16779 METAL6_362000_1877000 METAL6_362000_1953000 0.152
R_VDD5_16780 METAL6_362000_1953000 METAL5_362000_1953000 0.1
R_VDD5_16781 METAL5_362000_1953000 METAL5_352000_1953000 0.04
R_VDD5_16782 METAL5_352000_1953000 METAL5_350000_1953000 0.008
R_VDD5_16783 METAL5_350000_1953000 METAL5_338000_1953000 0.048
R_VDD5_16784 METAL5_338000_1953000 METAL5_336000_1953000 0.008
R_VDD5_16785 METAL5_336000_1953000 METAL5_326000_1953000 0.04
R_VDD5_16786 METAL5_326000_1953000 METAL5_324000_1953000 0.008
R_VDD5_16787 METAL5_324000_1953000 METAL5_314000_1953000 0.04
R_VDD5_16788 METAL5_314000_1953000 METAL5_312000_1953000 0.008
R_VDD5_16789 METAL5_312000_1953000 METAL5_300000_1953000 0.048
R_VDD5_16790 METAL5_300000_1953000 METAL5_293000_1953000 0.028
R_VDD5_16791 METAL5_293000_1953000 METAL5_288000_1953000 0.02
R_VDD5_16792 METAL5_288000_1953000 METAL5_281000_1953000 0.028
R_VDD5_16793 METAL5_281000_1953000 METAL5_276000_1953000 0.02
R_VDD5_16794 METAL5_276000_1953000 METAL5_269000_1953000 0.028
R_VDD5_16795 METAL5_269000_1953000 METAL5_257000_1953000 0.048
R_VDD5_16796 METAL5_257000_1953000 METAL6_257000_1953000 0.1
R_VDD5_16797 METAL6_257000_1953000 METAL6_257000_1965000 0.024
R_VDD5_16798 METAL6_555000_1965000 METAL6_543000_1965000 0.024
R_VDD5_16799 METAL6_531000_693000 METAL6_543000_693000 0.024
R_VDD5_16800 METAL6_543000_693000 METAL6_543000_707000 0.028
R_VDD5_16801 METAL6_543000_707000 METAL6_543000_805000 0.196
R_VDD5_16802 METAL6_543000_805000 METAL6_543000_817000 0.024
R_VDD5_16803 METAL6_543000_817000 METAL6_543000_829000 0.024
R_VDD5_16804 METAL6_543000_829000 METAL6_543000_841000 0.024
R_VDD5_16805 METAL6_543000_841000 METAL6_543000_853000 0.024
R_VDD5_16806 METAL6_543000_853000 METAL5_543000_853000 0.1
R_VDD5_16807 METAL5_543000_853000 METAL5_531000_853000 0.048
R_VDD5_16808 METAL5_531000_853000 METAL5_531000_865000 0.048
R_VDD5_16809 METAL5_531000_865000 METAL5_531000_877000 0.048
R_VDD5_16810 METAL5_531000_877000 METAL5_524000_877000 0.028
R_VDD5_16811 METAL5_524000_877000 METAL5_519000_877000 0.02
R_VDD5_16812 METAL5_519000_877000 METAL5_512000_877000 0.028
R_VDD5_16813 METAL5_512000_877000 METAL5_507000_877000 0.02
R_VDD5_16814 METAL5_507000_877000 METAL5_500000_877000 0.028
R_VDD5_16815 METAL5_500000_877000 METAL5_488000_877000 0.048
R_VDD5_16816 METAL5_488000_877000 METAL5_486000_877000 0.008
R_VDD5_16817 METAL5_486000_877000 METAL5_476000_877000 0.04
R_VDD5_16818 METAL5_476000_877000 METAL5_474000_877000 0.008
R_VDD5_16819 METAL5_474000_877000 METAL5_472000_877000 0.008
R_VDD5_16820 METAL5_472000_877000 METAL5_464000_877000 0.032
R_VDD5_16821 METAL5_464000_877000 METAL5_462000_877000 0.008
R_VDD5_16822 METAL5_462000_877000 METAL5_460000_877000 0.008
R_VDD5_16823 METAL5_460000_877000 METAL5_452000_877000 0.032
R_VDD5_16824 METAL5_452000_877000 METAL5_450000_877000 0.008
R_VDD5_16825 METAL5_450000_877000 METAL5_448000_877000 0.008
R_VDD5_16826 METAL5_448000_877000 METAL5_438000_877000 0.04
R_VDD5_16827 METAL5_438000_877000 METAL5_436000_877000 0.008
R_VDD5_16828 METAL5_436000_877000 METAL5_426000_877000 0.04
R_VDD5_16829 METAL5_426000_877000 METAL5_424000_877000 0.008
R_VDD5_16830 METAL5_424000_877000 METAL6_424000_877000 0.1
R_VDD5_16831 METAL6_424000_877000 METAL6_424000_905000 0.056
R_VDD5_16832 METAL6_424000_905000 METAL6_424000_917000 0.024
R_VDD5_16833 METAL6_424000_917000 METAL6_424000_929000 0.024
R_VDD5_16834 METAL6_424000_929000 METAL6_424000_941000 0.024
R_VDD5_16835 METAL6_424000_941000 METAL6_424000_953000 0.024
R_VDD5_16836 METAL6_424000_953000 METAL6_424000_965000 0.024
R_VDD5_16837 METAL6_424000_965000 METAL6_424000_977000 0.024
R_VDD5_16838 METAL6_424000_977000 METAL6_424000_989000 0.024
R_VDD5_16839 METAL6_424000_989000 METAL6_424000_1041000 0.104
R_VDD5_16840 METAL6_424000_1041000 METAL6_424000_1053000 0.024
R_VDD5_16841 METAL6_424000_1053000 METAL6_424000_1065000 0.024
R_VDD5_16842 METAL6_424000_1065000 METAL6_424000_1077000 0.024
R_VDD5_16843 METAL6_424000_1077000 METAL6_424000_1153000 0.152
R_VDD5_16844 METAL6_424000_1153000 METAL6_424000_1165000 0.024
R_VDD5_16845 METAL6_424000_1165000 METAL6_424000_1177000 0.024
R_VDD5_16846 METAL6_424000_1177000 METAL6_424000_1253000 0.152
R_VDD5_16847 METAL6_424000_1253000 METAL6_424000_1265000 0.024
R_VDD5_16848 METAL6_424000_1265000 METAL6_424000_1277000 0.024
R_VDD5_16849 METAL6_424000_1277000 METAL6_424000_1381000 0.208
R_VDD5_16850 METAL6_424000_1381000 METAL6_424000_1393000 0.024
R_VDD5_16851 METAL6_424000_1393000 METAL6_424000_1405000 0.024
R_VDD5_16852 METAL6_424000_1405000 METAL6_424000_1407000 0.004
R_VDD5_16853 METAL6_424000_1407000 METAL6_424000_1553000 0.292
R_VDD5_16854 METAL6_424000_1553000 METAL6_424000_1565000 0.024
R_VDD5_16855 METAL6_424000_1565000 METAL6_424000_1577000 0.024
R_VDD5_16856 METAL6_424000_1577000 METAL6_424000_1653000 0.152
R_VDD5_16857 METAL6_424000_1653000 METAL6_424000_1665000 0.024
R_VDD5_16858 METAL6_424000_1665000 METAL6_424000_1677000 0.024
R_VDD5_16859 METAL6_424000_1677000 METAL6_424000_1753000 0.152
R_VDD5_16860 METAL6_424000_1753000 METAL6_424000_1765000 0.024
R_VDD5_16861 METAL6_424000_1765000 METAL6_424000_1777000 0.024
R_VDD5_16862 METAL6_424000_1777000 METAL6_424000_1841000 0.128
R_VDD5_16863 METAL6_424000_1841000 METAL6_424000_1853000 0.024
R_VDD5_16864 METAL6_424000_1853000 METAL6_424000_1865000 0.024
R_VDD5_16865 METAL6_424000_1865000 METAL6_424000_1877000 0.024
R_VDD5_16866 METAL6_424000_1877000 METAL6_424000_1941000 0.128
R_VDD5_16867 METAL6_424000_1941000 METAL5_424000_1941000 0.1
R_VDD5_16868 METAL5_424000_1941000 METAL5_426000_1941000 0.008
R_VDD5_16869 METAL5_426000_1941000 METAL5_436000_1941000 0.04
R_VDD5_16870 METAL5_436000_1941000 METAL5_438000_1941000 0.008
R_VDD5_16871 METAL5_438000_1941000 METAL5_448000_1941000 0.04
R_VDD5_16872 METAL5_448000_1941000 METAL5_450000_1941000 0.008
R_VDD5_16873 METAL5_450000_1941000 METAL5_452000_1941000 0.008
R_VDD5_16874 METAL5_452000_1941000 METAL5_460000_1941000 0.032
R_VDD5_16875 METAL5_460000_1941000 METAL5_462000_1941000 0.008
R_VDD5_16876 METAL5_462000_1941000 METAL5_464000_1941000 0.008
R_VDD5_16877 METAL5_464000_1941000 METAL5_472000_1941000 0.032
R_VDD5_16878 METAL5_472000_1941000 METAL5_474000_1941000 0.008
R_VDD5_16879 METAL5_474000_1941000 METAL5_476000_1941000 0.008
R_VDD5_16880 METAL5_476000_1941000 METAL5_486000_1941000 0.04
R_VDD5_16881 METAL5_486000_1941000 METAL5_488000_1941000 0.008
R_VDD5_16882 METAL5_488000_1941000 METAL5_500000_1941000 0.048
R_VDD5_16883 METAL5_500000_1941000 METAL5_507000_1941000 0.028
R_VDD5_16884 METAL5_507000_1941000 METAL5_512000_1941000 0.02
R_VDD5_16885 METAL5_512000_1941000 METAL5_519000_1941000 0.028
R_VDD5_16886 METAL5_519000_1941000 METAL5_524000_1941000 0.02
R_VDD5_16887 METAL5_524000_1941000 METAL5_531000_1941000 0.028
R_VDD5_16888 METAL5_531000_1941000 METAL5_543000_1941000 0.048
R_VDD5_16889 METAL5_543000_1941000 METAL6_543000_1941000 0.1
R_VDD5_16890 METAL6_543000_1941000 METAL6_543000_1953000 0.024
R_VDD5_16891 METAL6_543000_1953000 METAL6_543000_1965000 0.024
R_VDD5_16892 METAL6_245000_1265000 METAL6_257000_1265000 0.024
R_VDD5_16893 METAL6_512000_577000 METAL5_512000_577000 0.1
R_VDD5_16894 METAL5_512000_577000 METAL5_512000_589000 0.048
R_VDD5_16895 METAL5_512000_589000 METAL5_507000_589000 0.02
R_VDD5_16896 METAL5_507000_589000 METAL5_500000_589000 0.028
R_VDD5_16897 METAL5_500000_589000 METAL5_488000_589000 0.048
R_VDD5_16898 METAL5_488000_589000 METAL5_486000_589000 0.008
R_VDD5_16899 METAL5_486000_589000 METAL5_476000_589000 0.04
R_VDD5_16900 METAL5_476000_589000 METAL5_474000_589000 0.008
R_VDD5_16901 METAL5_474000_589000 METAL5_472000_589000 0.008
R_VDD5_16902 METAL5_472000_589000 METAL5_464000_589000 0.032
R_VDD5_16903 METAL5_464000_589000 METAL5_462000_589000 0.008
R_VDD5_16904 METAL5_462000_589000 METAL5_460000_589000 0.008
R_VDD5_16905 METAL5_460000_589000 METAL5_452000_589000 0.032
R_VDD5_16906 METAL5_452000_589000 METAL5_450000_589000 0.008
R_VDD5_16907 METAL5_450000_589000 METAL5_448000_589000 0.008
R_VDD5_16908 METAL5_448000_589000 METAL5_438000_589000 0.04
R_VDD5_16909 METAL5_438000_589000 METAL5_436000_589000 0.008
R_VDD5_16910 METAL5_436000_589000 METAL5_426000_589000 0.04
R_VDD5_16911 METAL5_426000_589000 METAL5_424000_589000 0.008
R_VDD5_16912 METAL5_424000_589000 METAL5_414000_589000 0.04
R_VDD5_16913 METAL5_414000_589000 METAL5_412000_589000 0.008
R_VDD5_16914 METAL5_412000_589000 METAL5_402000_589000 0.04
R_VDD5_16915 METAL5_402000_589000 METAL5_400000_589000 0.008
R_VDD5_16916 METAL5_400000_589000 METAL5_390000_589000 0.04
R_VDD5_16917 METAL5_390000_589000 METAL5_388000_589000 0.008
R_VDD5_16918 METAL5_388000_589000 METAL5_386000_589000 0.008
R_VDD5_16919 METAL5_386000_589000 METAL5_376000_589000 0.04
R_VDD5_16920 METAL5_376000_589000 METAL5_374000_589000 0.008
R_VDD5_16921 METAL5_374000_589000 METAL5_364000_589000 0.04
R_VDD5_16922 METAL5_364000_589000 METAL5_362000_589000 0.008
R_VDD5_16923 METAL5_362000_589000 METAL5_352000_589000 0.04
R_VDD5_16924 METAL5_352000_589000 METAL5_350000_589000 0.008
R_VDD5_16925 METAL5_350000_589000 METAL5_338000_589000 0.048
R_VDD5_16926 METAL5_338000_589000 METAL5_336000_589000 0.008
R_VDD5_16927 METAL5_336000_589000 METAL5_326000_589000 0.04
R_VDD5_16928 METAL5_326000_589000 METAL5_324000_589000 0.008
R_VDD5_16929 METAL5_324000_589000 METAL5_314000_589000 0.04
R_VDD5_16930 METAL5_314000_589000 METAL5_312000_589000 0.008
R_VDD5_16931 METAL5_312000_589000 METAL5_302000_589000 0.04
R_VDD5_16932 METAL5_302000_589000 METAL5_300000_589000 0.008
R_VDD5_16933 METAL5_300000_589000 METAL5_293000_589000 0.028
R_VDD5_16934 METAL5_293000_589000 METAL5_288000_589000 0.02
R_VDD5_16935 METAL5_288000_589000 METAL5_281000_589000 0.028
R_VDD5_16936 METAL5_281000_589000 METAL5_276000_589000 0.02
R_VDD5_16937 METAL5_276000_589000 METAL6_276000_589000 0.1
R_VDD5_16938 METAL6_276000_589000 METAL6_276000_681000 0.184
R_VDD5_16939 METAL6_276000_681000 METAL6_276000_693000 0.024
R_VDD5_16940 METAL6_276000_693000 METAL6_276000_705000 0.024
R_VDD5_16941 METAL6_276000_705000 METAL6_269000_705000 0.014
R_VDD5_16942 METAL6_269000_705000 METAL6_269000_707000 0.004
R_VDD5_16943 METAL6_269000_707000 METAL6_269000_805000 0.196
R_VDD5_16944 METAL6_269000_805000 METAL6_269000_817000 0.024
R_VDD5_16945 METAL6_269000_817000 METAL6_269000_829000 0.024
R_VDD5_16946 METAL6_269000_829000 METAL6_269000_841000 0.024
R_VDD5_16947 METAL6_269000_841000 METAL6_269000_853000 0.024
R_VDD5_16948 METAL6_269000_853000 METAL6_269000_865000 0.024
R_VDD5_16949 METAL6_269000_865000 METAL6_269000_877000 0.024
R_VDD5_16950 METAL6_269000_877000 METAL6_269000_889000 0.024
R_VDD5_16951 METAL6_269000_889000 METAL6_269000_905000 0.032
R_VDD5_16952 METAL6_269000_905000 METAL6_269000_917000 0.024
R_VDD5_16953 METAL6_269000_917000 METAL6_269000_929000 0.024
R_VDD5_16954 METAL6_269000_929000 METAL6_269000_941000 0.024
R_VDD5_16955 METAL6_269000_941000 METAL5_269000_941000 0.1
R_VDD5_16956 METAL5_269000_941000 METAL5_269000_953000 0.048
R_VDD5_16957 METAL5_269000_953000 METAL5_269000_965000 0.048
R_VDD5_16958 METAL5_269000_965000 METAL5_269000_977000 0.048
R_VDD5_16959 METAL5_269000_977000 METAL5_269000_989000 0.048
R_VDD5_16960 METAL5_269000_989000 METAL5_269000_1041000 0.208
R_VDD5_16961 METAL5_269000_1041000 METAL5_269000_1053000 0.048
R_VDD5_16962 METAL5_269000_1053000 METAL5_269000_1065000 0.048
R_VDD5_16963 METAL5_269000_1065000 METAL5_269000_1077000 0.048
R_VDD5_16964 METAL5_269000_1077000 METAL5_269000_1153000 0.304
R_VDD5_16965 METAL5_269000_1153000 METAL5_269000_1165000 0.048
R_VDD5_16966 METAL5_269000_1165000 METAL5_269000_1177000 0.048
R_VDD5_16967 METAL5_269000_1177000 METAL5_257000_1177000 0.048
R_VDD5_16968 METAL5_257000_1177000 METAL6_257000_1177000 0.1
R_VDD5_16969 METAL6_257000_1177000 METAL6_257000_1253000 0.152
R_VDD5_16970 METAL6_257000_1253000 METAL6_257000_1265000 0.024
R_VDD5_16971 METAL6_555000_1265000 METAL6_543000_1265000 0.024
R_VDD5_16972 METAL6_500000_553000 METAL5_500000_553000 0.1
R_VDD5_16973 METAL5_500000_553000 METAL5_488000_553000 0.048
R_VDD5_16974 METAL5_488000_553000 METAL5_486000_553000 0.008
R_VDD5_16975 METAL5_486000_553000 METAL5_476000_553000 0.04
R_VDD5_16976 METAL5_476000_553000 METAL5_474000_553000 0.008
R_VDD5_16977 METAL5_474000_553000 METAL5_472000_553000 0.008
R_VDD5_16978 METAL5_472000_553000 METAL5_464000_553000 0.032
R_VDD5_16979 METAL5_464000_553000 METAL5_464000_565000 0.048
R_VDD5_16980 METAL5_464000_565000 METAL5_464000_577000 0.048
R_VDD5_16981 METAL5_464000_577000 METAL5_462000_577000 0.008
R_VDD5_16982 METAL5_462000_577000 METAL5_460000_577000 0.008
R_VDD5_16983 METAL5_460000_577000 METAL5_452000_577000 0.032
R_VDD5_16984 METAL5_452000_577000 METAL5_450000_577000 0.008
R_VDD5_16985 METAL5_450000_577000 METAL6_450000_577000 0.1
R_VDD5_16986 METAL6_450000_577000 METAL6_450000_589000 0.024
R_VDD5_16987 METAL6_450000_589000 METAL6_450000_601000 0.024
R_VDD5_16988 METAL6_450000_601000 METAL6_450000_681000 0.16
R_VDD5_16989 METAL6_450000_681000 METAL6_450000_693000 0.024
R_VDD5_16990 METAL6_450000_693000 METAL6_450000_705000 0.024
R_VDD5_16991 METAL6_450000_705000 METAL6_450000_707000 0.004
R_VDD5_16992 METAL6_450000_707000 METAL6_450000_717000 0.02
R_VDD5_16993 METAL6_450000_717000 METAL6_450000_805000 0.176
R_VDD5_16994 METAL6_450000_805000 METAL5_450000_805000 0.1
R_VDD5_16995 METAL5_450000_805000 METAL5_452000_805000 0.008
R_VDD5_16996 METAL5_452000_805000 METAL5_460000_805000 0.032
R_VDD5_16997 METAL5_460000_805000 METAL5_462000_805000 0.008
R_VDD5_16998 METAL5_462000_805000 METAL5_464000_805000 0.008
R_VDD5_16999 METAL5_464000_805000 METAL5_472000_805000 0.032
R_VDD5_17000 METAL5_472000_805000 METAL5_472000_817000 0.048
R_VDD5_17001 METAL5_472000_817000 METAL5_472000_829000 0.048
R_VDD5_17002 METAL5_472000_829000 METAL5_472000_841000 0.048
R_VDD5_17003 METAL5_472000_841000 METAL5_472000_853000 0.048
R_VDD5_17004 METAL5_472000_853000 METAL5_472000_865000 0.048
R_VDD5_17005 METAL5_472000_865000 METAL5_464000_865000 0.032
R_VDD5_17006 METAL5_464000_865000 METAL5_462000_865000 0.008
R_VDD5_17007 METAL5_462000_865000 METAL5_460000_865000 0.008
R_VDD5_17008 METAL5_460000_865000 METAL5_452000_865000 0.032
R_VDD5_17009 METAL5_452000_865000 METAL5_450000_865000 0.008
R_VDD5_17010 METAL5_450000_865000 METAL5_448000_865000 0.008
R_VDD5_17011 METAL5_448000_865000 METAL5_438000_865000 0.04
R_VDD5_17012 METAL5_438000_865000 METAL5_436000_865000 0.008
R_VDD5_17013 METAL5_436000_865000 METAL5_426000_865000 0.04
R_VDD5_17014 METAL5_426000_865000 METAL5_424000_865000 0.008
R_VDD5_17015 METAL5_424000_865000 METAL5_414000_865000 0.04
R_VDD5_17016 METAL5_414000_865000 METAL5_412000_865000 0.008
R_VDD5_17017 METAL5_412000_865000 METAL5_412000_877000 0.048
R_VDD5_17018 METAL5_412000_877000 METAL5_412000_889000 0.048
R_VDD5_17019 METAL5_412000_889000 METAL5_412000_905000 0.064
R_VDD5_17020 METAL5_412000_905000 METAL5_412000_917000 0.048
R_VDD5_17021 METAL5_412000_917000 METAL5_412000_929000 0.048
R_VDD5_17022 METAL5_412000_929000 METAL5_412000_941000 0.048
R_VDD5_17023 METAL5_412000_941000 METAL6_412000_941000 0.1
R_VDD5_17024 METAL6_412000_941000 METAL6_412000_953000 0.024
R_VDD5_17025 METAL6_412000_953000 METAL6_412000_965000 0.024
R_VDD5_17026 METAL6_412000_965000 METAL6_412000_977000 0.024
R_VDD5_17027 METAL6_412000_977000 METAL6_412000_989000 0.024
R_VDD5_17028 METAL6_412000_989000 METAL6_412000_1041000 0.104
R_VDD5_17029 METAL6_412000_1041000 METAL6_412000_1053000 0.024
R_VDD5_17030 METAL6_412000_1053000 METAL6_412000_1065000 0.024
R_VDD5_17031 METAL6_412000_1065000 METAL6_412000_1077000 0.024
R_VDD5_17032 METAL6_412000_1077000 METAL6_412000_1153000 0.152
R_VDD5_17033 METAL6_412000_1153000 METAL6_412000_1165000 0.024
R_VDD5_17034 METAL6_412000_1165000 METAL6_412000_1177000 0.024
R_VDD5_17035 METAL6_412000_1177000 METAL5_412000_1177000 0.1
R_VDD5_17036 METAL5_412000_1177000 METAL5_414000_1177000 0.008
R_VDD5_17037 METAL5_414000_1177000 METAL5_424000_1177000 0.04
R_VDD5_17038 METAL5_424000_1177000 METAL5_426000_1177000 0.008
R_VDD5_17039 METAL5_426000_1177000 METAL5_436000_1177000 0.04
R_VDD5_17040 METAL5_436000_1177000 METAL5_438000_1177000 0.008
R_VDD5_17041 METAL5_438000_1177000 METAL5_448000_1177000 0.04
R_VDD5_17042 METAL5_448000_1177000 METAL5_450000_1177000 0.008
R_VDD5_17043 METAL5_450000_1177000 METAL5_452000_1177000 0.008
R_VDD5_17044 METAL5_452000_1177000 METAL5_460000_1177000 0.032
R_VDD5_17045 METAL5_460000_1177000 METAL5_462000_1177000 0.008
R_VDD5_17046 METAL5_462000_1177000 METAL5_464000_1177000 0.008
R_VDD5_17047 METAL5_464000_1177000 METAL5_472000_1177000 0.032
R_VDD5_17048 METAL5_472000_1177000 METAL5_474000_1177000 0.008
R_VDD5_17049 METAL5_474000_1177000 METAL5_476000_1177000 0.008
R_VDD5_17050 METAL5_476000_1177000 METAL5_486000_1177000 0.04
R_VDD5_17051 METAL5_486000_1177000 METAL5_488000_1177000 0.008
R_VDD5_17052 METAL5_488000_1177000 METAL5_500000_1177000 0.048
R_VDD5_17053 METAL5_500000_1177000 METAL5_507000_1177000 0.028
R_VDD5_17054 METAL5_507000_1177000 METAL5_512000_1177000 0.02
R_VDD5_17055 METAL5_512000_1177000 METAL5_519000_1177000 0.028
R_VDD5_17056 METAL5_519000_1177000 METAL5_524000_1177000 0.02
R_VDD5_17057 METAL5_524000_1177000 METAL5_531000_1177000 0.028
R_VDD5_17058 METAL5_531000_1177000 METAL5_543000_1177000 0.048
R_VDD5_17059 METAL5_543000_1177000 METAL6_543000_1177000 0.1
R_VDD5_17060 METAL6_543000_1177000 METAL6_543000_1189000 0.024
R_VDD5_17061 METAL6_543000_1189000 METAL6_543000_1253000 0.128
R_VDD5_17062 METAL6_543000_1253000 METAL6_543000_1265000 0.024
R_VDD5_17063 METAL6_245000_565000 METAL6_257000_565000 0.024
R_VDD5_17064 METAL6_438000_465000 METAL5_438000_465000 0.1
R_VDD5_17065 METAL5_438000_465000 METAL5_436000_465000 0.008
R_VDD5_17066 METAL5_436000_465000 METAL5_426000_465000 0.04
R_VDD5_17067 METAL5_426000_465000 METAL5_424000_465000 0.008
R_VDD5_17068 METAL5_424000_465000 METAL5_414000_465000 0.04
R_VDD5_17069 METAL5_414000_465000 METAL5_412000_465000 0.008
R_VDD5_17070 METAL5_412000_465000 METAL5_402000_465000 0.04
R_VDD5_17071 METAL5_402000_465000 METAL5_400000_465000 0.008
R_VDD5_17072 METAL5_400000_465000 METAL5_390000_465000 0.04
R_VDD5_17073 METAL5_390000_465000 METAL5_388000_465000 0.008
R_VDD5_17074 METAL5_388000_465000 METAL5_386000_465000 0.008
R_VDD5_17075 METAL5_386000_465000 METAL5_376000_465000 0.04
R_VDD5_17076 METAL5_376000_465000 METAL5_374000_465000 0.008
R_VDD5_17077 METAL5_374000_465000 METAL5_364000_465000 0.04
R_VDD5_17078 METAL5_364000_465000 METAL5_362000_465000 0.008
R_VDD5_17079 METAL5_362000_465000 METAL5_352000_465000 0.04
R_VDD5_17080 METAL5_352000_465000 METAL5_350000_465000 0.008
R_VDD5_17081 METAL5_350000_465000 METAL5_338000_465000 0.048
R_VDD5_17082 METAL5_338000_465000 METAL5_336000_465000 0.008
R_VDD5_17083 METAL5_336000_465000 METAL5_326000_465000 0.04
R_VDD5_17084 METAL5_326000_465000 METAL5_324000_465000 0.008
R_VDD5_17085 METAL5_324000_465000 METAL5_314000_465000 0.04
R_VDD5_17086 METAL5_314000_465000 METAL5_312000_465000 0.008
R_VDD5_17087 METAL5_312000_465000 METAL5_302000_465000 0.04
R_VDD5_17088 METAL5_302000_465000 METAL5_300000_465000 0.008
R_VDD5_17089 METAL5_300000_465000 METAL5_293000_465000 0.028
R_VDD5_17090 METAL5_293000_465000 METAL5_288000_465000 0.02
R_VDD5_17091 METAL5_288000_465000 METAL6_288000_465000 0.1
R_VDD5_17092 METAL6_288000_465000 METAL6_288000_477000 0.024
R_VDD5_17093 METAL6_288000_477000 METAL6_288000_505000 0.056
R_VDD5_17094 METAL6_288000_505000 METAL6_288000_517000 0.024
R_VDD5_17095 METAL6_288000_517000 METAL6_288000_529000 0.024
R_VDD5_17096 METAL6_288000_529000 METAL6_288000_541000 0.024
R_VDD5_17097 METAL6_288000_541000 METAL6_281000_541000 0.014
R_VDD5_17098 METAL6_281000_541000 METAL6_276000_541000 0.01
R_VDD5_17099 METAL6_276000_541000 METAL6_276000_553000 0.024
R_VDD5_17100 METAL6_276000_553000 METAL6_276000_565000 0.024
R_VDD5_17101 METAL6_276000_565000 METAL6_269000_565000 0.014
R_VDD5_17102 METAL6_269000_565000 METAL6_264000_565000 0.01
R_VDD5_17103 METAL6_264000_565000 METAL6_257000_565000 0.014
R_VDD5_17104 METAL6_555000_565000 METAL6_543000_565000 0.024
R_VDD5_17105 METAL6_424000_693000 METAL6_426000_693000 0.004
R_VDD5_17106 METAL6_426000_693000 METAL6_436000_693000 0.02
R_VDD5_17107 METAL6_436000_693000 METAL6_436000_681000 0.024
R_VDD5_17108 METAL6_436000_681000 METAL6_436000_601000 0.16
R_VDD5_17109 METAL6_436000_601000 METAL6_438000_601000 0.004
R_VDD5_17110 METAL6_438000_601000 METAL5_438000_601000 0.1
R_VDD5_17111 METAL5_438000_601000 METAL5_448000_601000 0.04
R_VDD5_17112 METAL5_448000_601000 METAL5_450000_601000 0.008
R_VDD5_17113 METAL5_450000_601000 METAL5_452000_601000 0.008
R_VDD5_17114 METAL5_452000_601000 METAL5_460000_601000 0.032
R_VDD5_17115 METAL5_460000_601000 METAL5_462000_601000 0.008
R_VDD5_17116 METAL5_462000_601000 METAL5_464000_601000 0.008
R_VDD5_17117 METAL5_464000_601000 METAL5_472000_601000 0.032
R_VDD5_17118 METAL5_472000_601000 METAL5_474000_601000 0.008
R_VDD5_17119 METAL5_474000_601000 METAL5_476000_601000 0.008
R_VDD5_17120 METAL5_476000_601000 METAL5_484000_601000 0.032
R_VDD5_17121 METAL5_484000_601000 METAL5_486000_601000 0.008
R_VDD5_17122 METAL5_486000_601000 METAL5_488000_601000 0.008
R_VDD5_17123 METAL5_488000_601000 METAL5_500000_601000 0.048
R_VDD5_17124 METAL5_500000_601000 METAL5_507000_601000 0.028
R_VDD5_17125 METAL5_507000_601000 METAL5_512000_601000 0.02
R_VDD5_17126 METAL5_512000_601000 METAL5_519000_601000 0.028
R_VDD5_17127 METAL5_519000_601000 METAL5_524000_601000 0.02
R_VDD5_17128 METAL5_524000_601000 METAL5_531000_601000 0.028
R_VDD5_17129 METAL5_531000_601000 METAL5_543000_601000 0.048
R_VDD5_17130 METAL5_543000_601000 METAL6_543000_601000 0.1
R_VDD5_17131 METAL6_543000_601000 METAL6_543000_589000 0.024
R_VDD5_17132 METAL6_543000_589000 METAL6_543000_577000 0.024
R_VDD5_17133 METAL6_543000_577000 METAL6_543000_565000 0.024
R_VDD5_17134 METAL6_257000_565000 METAL5_257000_565000 0.1
R_VDD5_17135 METAL5_257000_565000 METAL4_257000_565000 0.1
R_VDD5_17136 METAL4_257000_565000 METAL4_257000_553000 0.096
R_VDD5_17137 METAL4_257000_553000 METAL4_257000_541000 0.096
R_VDD5_17138 METAL4_257000_541000 METAL4_257000_529000 0.096
R_VDD5_17139 METAL4_257000_529000 METAL4_257000_517000 0.096
R_VDD5_17140 METAL4_257000_517000 METAL4_257000_505000 0.096
R_VDD5_17141 METAL4_257000_505000 METAL4_257000_501000 0.032
R_VDD5_17142 METAL4_257000_501000 METAL4_258000_501000 0.008
R_VDD5_17143 METAL4_258000_501000 METAL4_264000_501000 0.048
R_VDD5_17144 METAL4_264000_501000 METAL4_266000_501000 0.016
R_VDD5_17145 METAL4_266000_501000 METAL4_268000_501000 0.016
R_VDD5_17146 METAL4_268000_501000 METAL4_269000_501000 0.008
R_VDD5_17147 METAL4_269000_501000 METAL4_270000_501000 0.008
R_VDD5_17148 METAL4_270000_501000 METAL4_276000_501000 0.048
R_VDD5_17149 METAL4_276000_501000 METAL4_278000_501000 0.016
R_VDD5_17150 METAL4_278000_501000 METAL4_280000_501000 0.016
R_VDD5_17151 METAL4_280000_501000 METAL4_281000_501000 0.008
R_VDD5_17152 METAL4_281000_501000 METAL3_281000_501000 0.1
R_VDD5_17153 METAL3_281000_501000 METAL3_281000_493000 0.064
R_VDD5_17154 METAL3_281000_493000 METAL3_281000_489000 0.032
R_VDD5_17155 METAL3_281000_489000 METAL3_281000_481000 0.064
R_VDD5_17156 METAL3_281000_481000 METAL3_281000_477000 0.032
R_VDD5_17157 METAL3_281000_477000 METAL3_281000_469000 0.064
R_VDD5_17158 METAL3_281000_469000 METAL3_281000_465000 0.032
R_VDD5_17159 METAL3_281000_465000 METAL3_281000_453000 0.096
R_VDD5_17160 METAL3_281000_453000 METAL3_281000_441000 0.096
R_VDD5_17161 METAL3_281000_441000 METAL3_281000_429000 0.096
R_VDD5_17162 METAL3_281000_429000 METAL3_281000_417000 0.096
R_VDD5_17163 METAL3_281000_417000 METAL3_281000_405000 0.096
R_VDD5_17164 METAL3_281000_405000 METAL3_281000_401000 0.032
R_VDD5_17165 METAL3_281000_401000 METAL3_281000_393000 0.064
R_VDD5_17166 METAL3_281000_393000 METAL3_281000_389000 0.032
R_VDD5_17167 METAL3_281000_389000 METAL3_281000_381000 0.064
R_VDD5_17168 METAL3_281000_381000 METAL3_281000_377000 0.032
R_VDD5_17169 METAL3_281000_377000 METAL3_281000_365000 0.096
R_VDD5_17170 METAL3_281000_365000 METAL3_281000_353000 0.096
R_VDD5_17171 METAL3_281000_353000 METAL3_281000_341000 0.096
R_VDD5_17172 METAL3_281000_341000 METAL3_281000_329000 0.096
R_VDD5_17173 METAL3_281000_329000 METAL3_281000_317000 0.096
R_VDD5_17174 METAL3_281000_317000 METAL3_281000_313000 0.032
R_VDD5_17175 METAL3_281000_313000 METAL3_281000_305000 0.064
R_VDD5_17176 METAL3_281000_305000 METAL3_281000_301000 0.032
R_VDD5_17177 METAL3_281000_301000 METAL3_281000_293000 0.064
R_VDD5_17178 METAL3_281000_293000 METAL3_281000_289000 0.032
R_VDD5_17179 METAL3_281000_289000 METAL3_281000_281000 0.064
R_VDD5_17180 METAL3_281000_281000 METAL3_281000_277000 0.032
R_VDD5_17181 METAL3_281000_277000 METAL3_281000_269000 0.064
R_VDD5_17182 METAL3_281000_269000 METAL3_281000_265000 0.032
R_VDD5_17183 METAL3_281000_265000 METAL3_281000_257000 0.064
R_VDD5_17184 METAL3_281000_257000 METAL3_281000_253000 0.032
R_VDD5_17185 METAL3_281000_253000 METAL3_281000_245000 0.064
R_VDD5_17186 METAL3_281000_245000 METAL3_281000_241000 0.032
R_VDD5_17187 METAL3_281000_241000 METAL3_281000_233000 0.064
R_VDD5_17188 METAL3_281000_233000 METAL3_281000_229000 0.032
R_VDD5_17189 METAL3_281000_229000 METAL3_281000_221000 0.064
R_VDD5_17190 METAL3_281000_221000 METAL3_281000_217000 0.032
R_VDD5_17191 METAL3_281000_217000 METAL3_281000_205000 0.096
R_VDD5_17192 METAL3_281000_205000 METAL3_281000_193000 0.096
R_VDD5_17193 METAL3_281000_193000 METAL3_281000_189000 0.032
R_VDD5_17194 METAL3_281000_189000 METAL3_281000_181000 0.064
R_VDD5_17195 METAL3_281000_181000 METAL3_281000_177000 0.032
R_VDD5_17196 METAL3_281000_177000 METAL3_281000_169000 0.064
R_VDD5_17197 METAL3_281000_169000 METAL3_281000_165000 0.032
R_VDD5_17198 METAL3_281000_165000 METAL3_281000_157000 0.064
R_VDD5_17199 METAL3_281000_157000 METAL3_281000_153000 0.032
R_VDD5_17200 METAL3_281000_153000 METAL3_281000_145000 0.064
R_VDD5_17201 METAL3_281000_145000 METAL3_281000_141000 0.032
R_VDD5_17202 METAL3_281000_141000 METAL3_281000_133000 0.064
R_VDD5_17203 METAL3_281000_133000 METAL3_281000_129000 0.032
R_VDD5_17204 METAL3_281000_129000 METAL3_281000_121000 0.064
R_VDD5_17205 METAL3_281000_121000 METAL3_281000_117000 0.032
R_VDD5_17206 METAL3_281000_117000 METAL3_281000_116000 0.008
R_VDD5_17207 METAL3_281000_116000 METAL3_281000_109000 0.056
R_VDD5_17208 METAL3_281000_109000 METAL3_281000_105000 0.032
R_VDD5_17209 METAL3_281000_105000 METAL3_281000_104000 0.008
R_VDD5_17210 METAL3_281000_104000 METAL3_281000_97000 0.056
R_VDD5_17211 METAL3_281000_97000 METAL3_281000_93000 0.032
R_VDD5_17212 METAL3_281000_93000 METAL3_281000_92000 0.008
R_VDD5_17213 METAL3_281000_92000 METAL3_281000_81000 0.088
R_VDD5_17214 METAL3_281000_81000 METAL3_282000_81000 0.008
R_VDD5_17215 METAL3_282000_81000 METAL3_288000_81000 0.048
R_VDD5_17216 METAL3_288000_81000 METAL3_290000_81000 0.016
R_VDD5_17217 METAL3_290000_81000 METAL3_292000_81000 0.016
R_VDD5_17218 METAL3_292000_81000 METAL3_293000_81000 0.008
R_VDD5_17219 METAL3_293000_81000 METAL3_294000_81000 0.008
R_VDD5_17220 METAL3_294000_81000 METAL3_300000_81000 0.048
R_VDD5_17221 METAL3_300000_81000 METAL3_302000_81000 0.016
R_VDD5_17222 METAL3_302000_81000 METAL3_304000_81000 0.016
R_VDD5_17223 METAL3_304000_81000 METAL3_305000_81000 0.008
R_VDD5_17224 METAL3_305000_81000 METAL3_306000_81000 0.008
R_VDD5_17225 METAL3_306000_81000 METAL3_312000_81000 0.048
R_VDD5_17226 METAL3_312000_81000 METAL3_314000_81000 0.016
R_VDD5_17227 METAL3_314000_81000 METAL3_316000_81000 0.016
R_VDD5_17228 METAL3_316000_81000 METAL3_317000_81000 0.008
R_VDD5_17229 METAL3_317000_81000 METAL3_318000_81000 0.008
R_VDD5_17230 METAL3_318000_81000 METAL3_324000_81000 0.048
R_VDD5_17231 METAL3_324000_81000 METAL3_326000_81000 0.016
R_VDD5_17232 METAL3_326000_81000 METAL3_328000_81000 0.016
R_VDD5_17233 METAL3_328000_81000 METAL3_329000_81000 0.008
R_VDD5_17234 METAL3_329000_81000 METAL3_330000_81000 0.008
R_VDD5_17235 METAL3_330000_81000 METAL3_336000_81000 0.048
R_VDD5_17236 METAL3_336000_81000 METAL3_338000_81000 0.016
R_VDD5_17237 METAL3_338000_81000 METAL3_340000_81000 0.016
R_VDD5_17238 METAL3_340000_81000 METAL3_342000_81000 0.016
R_VDD5_17239 METAL3_342000_81000 METAL3_348000_81000 0.048
R_VDD5_17240 METAL3_348000_81000 METAL3_350000_81000 0.016
R_VDD5_17241 METAL3_350000_81000 METAL3_352000_81000 0.016
R_VDD5_17242 METAL3_352000_81000 METAL3_354000_81000 0.016
R_VDD5_17243 METAL3_354000_81000 METAL3_360000_81000 0.048
R_VDD5_17244 METAL3_360000_81000 METAL3_362000_81000 0.016
R_VDD5_17245 METAL3_362000_81000 METAL3_364000_81000 0.016
R_VDD5_17246 METAL3_364000_81000 METAL3_366000_81000 0.016
R_VDD5_17247 METAL3_366000_81000 METAL3_372000_81000 0.048
R_VDD5_17248 METAL3_372000_81000 METAL3_374000_81000 0.016
R_VDD5_17249 METAL3_374000_81000 METAL3_376000_81000 0.016
R_VDD5_17250 METAL3_376000_81000 METAL3_378000_81000 0.016
R_VDD5_17251 METAL3_378000_81000 METAL3_384000_81000 0.048
R_VDD5_17252 METAL3_384000_81000 METAL3_386000_81000 0.016
R_VDD5_17253 METAL3_386000_81000 METAL3_388000_81000 0.016
R_VDD5_17254 METAL3_388000_81000 METAL3_390000_81000 0.016
R_VDD5_17255 METAL3_390000_81000 METAL3_396000_81000 0.048
R_VDD5_17256 METAL3_396000_81000 METAL3_398000_81000 0.016
R_VDD5_17257 METAL3_398000_81000 METAL3_400000_81000 0.016
R_VDD5_17258 METAL3_400000_81000 METAL3_402000_81000 0.016
R_VDD5_17259 METAL3_402000_81000 METAL3_404000_81000 0.016
R_VDD5_17260 METAL3_404000_81000 METAL3_408000_81000 0.032
R_VDD5_17261 METAL3_408000_81000 METAL3_410000_81000 0.016
R_VDD5_17262 METAL3_410000_81000 METAL3_412000_81000 0.016
R_VDD5_17263 METAL3_412000_81000 METAL3_414000_81000 0.016
R_VDD5_17264 METAL3_414000_81000 METAL3_416000_81000 0.016
R_VDD5_17265 METAL3_416000_81000 METAL3_420000_81000 0.032
R_VDD5_17266 METAL3_420000_81000 METAL3_422000_81000 0.016
R_VDD5_17267 METAL3_422000_81000 METAL3_424000_81000 0.016
R_VDD5_17268 METAL3_424000_81000 METAL3_426000_81000 0.016
R_VDD5_17269 METAL3_426000_81000 METAL3_428000_81000 0.016
R_VDD5_17270 METAL3_428000_81000 METAL3_432000_81000 0.032
R_VDD5_17271 METAL3_432000_81000 METAL3_434000_81000 0.016
R_VDD5_17272 METAL3_434000_81000 METAL3_436000_81000 0.016
R_VDD5_17273 METAL3_436000_81000 METAL3_438000_81000 0.016
R_VDD5_17274 METAL3_438000_81000 METAL3_440000_81000 0.016
R_VDD5_17275 METAL3_440000_81000 METAL3_444000_81000 0.032
R_VDD5_17276 METAL3_444000_81000 METAL3_446000_81000 0.016
R_VDD5_17277 METAL3_446000_81000 METAL3_448000_81000 0.016
R_VDD5_17278 METAL3_448000_81000 METAL3_448000_80000 0.008
R_VDD5_17279 METAL3_448000_80000 METAL3_448000_69000 0.088
R_VDD5_17280 METAL3_448000_69000 METAL3_448000_68000 0.008
R_VDD5_17281 METAL3_448000_68000 METAL3_448000_57000 0.088
R_VDD5_17282 METAL3_448000_57000 METAL3_448000_56000 0.008
R_VDD5_17283 METAL3_448000_56000 METAL3_448000_45000 0.088
R_VDD5_17284 METAL3_448000_45000 METAL3_448000_44000 0.008
R_VDD5_17285 METAL3_448000_44000 METAL3_448000_33000 0.088
R_VDD5_17286 METAL3_448000_33000 METAL3_448000_32000 0.008
R_VDD5_17287 METAL3_448000_32000 METAL4_448000_32000 0.1
R_VDD5_17288 METAL4_448000_32000 METAL5_448000_32000 0.1
R_VDD5_17289 METAL5_448000_32000 METAL5_450000_32000 0.008
R_VDD5_17290 METAL5_450000_32000 METAL5_452000_32000 0.008
R_VDD5_17291 METAL5_452000_32000 METAL5_458000_32000 0.024
R_VDD5_17292 METAL5_458000_32000 METAL5_460000_32000 0.008
R_VDD5_17293 METAL5_460000_32000 METAL5_462000_32000 0.008
R_VDD5_17294 METAL5_462000_32000 METAL5_462000_20000 0.048
R_VDD5_17295 METAL5_462000_20000 METAL5_462000_8000 0.048
R_VDD5_17296 METAL5_462000_8000 METAL5_464000_8000 0.008
R_VDD5_17297 METAL5_464000_8000 METAL5_470000_8000 0.024
R_VDD5_17298 METAL5_470000_8000 METAL5_471000_8000 0.004
R_VDD5_17299 METAL5_471000_8000 METAL5_472000_8000 0.004
R_VDD5_17300 METAL5_472000_8000 METAL5_474000_8000 0.008
R_VDD5_17301 METAL5_474000_8000 METAL5_476000_8000 0.008
R_VDD5_17302 METAL5_476000_8000 METAL4_476000_8000 0.1
R_VDD5_17303 METAL4_476000_8000 METAL4_482000_8000 0.048
R_VDD5_17304 METAL4_482000_8000 METAL4_483000_8000 0.008
R_VDD5_17305 METAL4_483000_8000 METAL4_484000_8000 0.008
R_VDD5_17306 METAL4_484000_8000 METAL4_486000_8000 0.016
R_VDD5_17307 METAL4_486000_8000 METAL4_488000_8000 0.016
R_VDD5_17308 METAL4_488000_8000 METAL4_494000_8000 0.048
R_VDD5_17309 METAL4_494000_8000 METAL4_495000_8000 0.008
R_VDD5_17310 METAL4_495000_8000 METAL4_496000_8000 0.008
R_VDD5_17311 METAL4_496000_8000 METAL4_498000_8000 0.016
R_VDD5_17312 METAL4_498000_8000 METAL4_500000_8000 0.016
R_VDD5_17313 METAL4_500000_8000 METAL5_500000_8000 0.1
R_VDD5_17314 METAL5_500000_8000 METAL6_500000_8000 0.1
R_VDD5_17315 METAL6_438000_377000 METAL5_438000_377000 0.1
R_VDD5_17316 METAL5_438000_377000 METAL4_438000_377000 0.1
R_VDD5_17317 METAL4_438000_377000 METAL3_438000_377000 0.1
R_VDD5_17318 METAL3_438000_377000 METAL3_438000_365000 0.096
R_VDD5_17319 METAL3_438000_365000 METAL3_438000_353000 0.096
R_VDD5_17320 METAL3_438000_353000 METAL3_438000_341000 0.096
R_VDD5_17321 METAL3_438000_341000 METAL3_438000_329000 0.096
R_VDD5_17322 METAL3_438000_329000 METAL3_438000_317000 0.096
R_VDD5_17323 METAL3_438000_317000 METAL3_438000_313000 0.032
R_VDD5_17324 METAL3_438000_313000 METAL3_438000_305000 0.064
R_VDD5_17325 METAL3_438000_305000 METAL3_438000_301000 0.032
R_VDD5_17326 METAL3_438000_301000 METAL3_438000_293000 0.064
R_VDD5_17327 METAL3_438000_293000 METAL3_438000_289000 0.032
R_VDD5_17328 METAL3_438000_289000 METAL3_438000_281000 0.064
R_VDD5_17329 METAL3_438000_281000 METAL3_438000_277000 0.032
R_VDD5_17330 METAL3_438000_277000 METAL3_438000_269000 0.064
R_VDD5_17331 METAL3_438000_269000 METAL3_438000_265000 0.032
R_VDD5_17332 METAL3_438000_265000 METAL3_438000_257000 0.064
R_VDD5_17333 METAL3_438000_257000 METAL3_438000_253000 0.032
R_VDD5_17334 METAL3_438000_253000 METAL3_438000_245000 0.064
R_VDD5_17335 METAL3_438000_245000 METAL3_438000_241000 0.032
R_VDD5_17336 METAL3_438000_241000 METAL3_438000_233000 0.064
R_VDD5_17337 METAL3_438000_233000 METAL3_438000_229000 0.032
R_VDD5_17338 METAL3_438000_229000 METAL3_438000_221000 0.064
R_VDD5_17339 METAL3_438000_221000 METAL3_438000_217000 0.032
R_VDD5_17340 METAL3_438000_217000 METAL3_438000_205000 0.096
R_VDD5_17341 METAL3_438000_205000 METAL3_438000_193000 0.096
R_VDD5_17342 METAL3_438000_193000 METAL3_438000_189000 0.032
R_VDD5_17343 METAL3_438000_189000 METAL3_438000_181000 0.064
R_VDD5_17344 METAL3_438000_181000 METAL3_438000_177000 0.032
R_VDD5_17345 METAL3_438000_177000 METAL3_438000_169000 0.064
R_VDD5_17346 METAL3_438000_169000 METAL3_438000_165000 0.032
R_VDD5_17347 METAL3_438000_165000 METAL3_438000_157000 0.064
R_VDD5_17348 METAL3_438000_157000 METAL3_438000_153000 0.032
R_VDD5_17349 METAL3_438000_153000 METAL3_438000_145000 0.064
R_VDD5_17350 METAL3_438000_145000 METAL3_438000_141000 0.032
R_VDD5_17351 METAL3_438000_141000 METAL3_438000_133000 0.064
R_VDD5_17352 METAL3_438000_133000 METAL3_438000_129000 0.032
R_VDD5_17353 METAL3_438000_129000 METAL3_438000_121000 0.064
R_VDD5_17354 METAL3_438000_121000 METAL3_438000_117000 0.032
R_VDD5_17355 METAL3_438000_117000 METAL3_440000_117000 0.016
R_VDD5_17356 METAL3_440000_117000 METAL3_444000_117000 0.032
R_VDD5_17357 METAL3_444000_117000 METAL3_446000_117000 0.016
R_VDD5_17358 METAL3_446000_117000 METAL3_448000_117000 0.016
R_VDD5_17359 METAL3_448000_117000 METAL3_450000_117000 0.016
R_VDD5_17360 METAL3_450000_117000 METAL3_452000_117000 0.016
R_VDD5_17361 METAL3_452000_117000 METAL3_458000_117000 0.048
R_VDD5_17362 METAL3_458000_117000 METAL3_460000_117000 0.016
R_VDD5_17363 METAL3_460000_117000 METAL3_462000_117000 0.016
R_VDD5_17364 METAL3_462000_117000 METAL3_464000_117000 0.016
R_VDD5_17365 METAL3_464000_117000 METAL3_470000_117000 0.048
R_VDD5_17366 METAL3_470000_117000 METAL3_470000_116000 0.008
R_VDD5_17367 METAL3_470000_116000 METAL3_470000_109000 0.056
R_VDD5_17368 METAL3_470000_109000 METAL3_470000_105000 0.032
R_VDD5_17369 METAL3_470000_105000 METAL3_470000_104000 0.008
R_VDD5_17370 METAL3_470000_104000 METAL3_470000_97000 0.056
R_VDD5_17371 METAL3_470000_97000 METAL3_470000_93000 0.032
R_VDD5_17372 METAL3_470000_93000 METAL3_470000_92000 0.008
R_VDD5_17373 METAL3_470000_92000 METAL3_470000_81000 0.088
R_VDD5_17374 METAL3_470000_81000 METAL3_470000_80000 0.008
R_VDD5_17375 METAL3_470000_80000 METAL3_470000_69000 0.088
R_VDD5_17376 METAL3_470000_69000 METAL3_470000_68000 0.008
R_VDD5_17377 METAL3_470000_68000 METAL3_470000_57000 0.088
R_VDD5_17378 METAL3_470000_57000 METAL3_470000_56000 0.008
R_VDD5_17379 METAL3_470000_56000 METAL3_470000_45000 0.088
R_VDD5_17380 METAL3_470000_45000 METAL3_470000_44000 0.008
R_VDD5_17381 METAL3_470000_44000 METAL3_470000_33000 0.088
R_VDD5_17382 METAL3_470000_33000 METAL3_470000_32000 0.008
R_VDD5_17383 METAL3_470000_32000 METAL4_470000_32000 0.1
R_VDD5_17384 METAL4_470000_32000 METAL4_470000_20000 0.096
R_VDD5_17385 METAL4_470000_20000 METAL4_471000_20000 0.008
R_VDD5_17386 METAL4_471000_20000 METAL4_472000_20000 0.008
R_VDD5_17387 METAL4_472000_20000 METAL4_474000_20000 0.016
R_VDD5_17388 METAL4_474000_20000 METAL4_476000_20000 0.016
R_VDD5_17389 METAL4_476000_20000 METAL4_482000_20000 0.048
R_VDD5_17390 METAL4_482000_20000 METAL4_483000_20000 0.008
R_VDD5_17391 METAL4_483000_20000 METAL4_484000_20000 0.008
R_VDD5_17392 METAL4_484000_20000 METAL4_486000_20000 0.016
R_VDD5_17393 METAL4_486000_20000 METAL4_488000_20000 0.016
R_VDD5_17394 METAL4_488000_20000 METAL4_494000_20000 0.048
R_VDD5_17395 METAL4_494000_20000 METAL4_495000_20000 0.008
R_VDD5_17396 METAL4_495000_20000 METAL4_496000_20000 0.008
R_VDD5_17397 METAL4_496000_20000 METAL4_498000_20000 0.016
R_VDD5_17398 METAL4_498000_20000 METAL4_500000_20000 0.016
R_VDD5_17399 METAL4_500000_20000 METAL4_500000_8000 0.096
R_VDD5_17400 METAL4_257000_565000 METAL3_257000_565000 0.1
R_VDD5_17401 METAL3_257000_565000 METAL2_257000_565000 0.1
R_VDD5_17402 METAL2_257000_565000 METAL1_257000_565000 0.1
R_VDD5_17403 METAL1_257000_565000 METAL1_257000_553000 0.096
R_VDD5_17404 METAL1_257000_553000 METAL1_257000_541000 0.096
R_VDD5_17405 METAL1_257000_541000 METAL1_257000_529000 0.096
R_VDD5_17406 METAL1_257000_529000 METAL1_257000_517000 0.096
R_VDD5_17407 METAL1_257000_517000 METAL1_257000_513000 0.032
R_VDD5_17408 METAL1_257000_513000 METAL1_257000_505000 0.064
R_VDD5_17409 METAL1_257000_505000 METAL1_257000_501000 0.032
R_VDD5_17410 METAL1_257000_501000 METAL1_257000_493000 0.064
R_VDD5_17411 METAL1_257000_493000 METAL1_257000_489000 0.032
R_VDD5_17412 METAL1_257000_489000 METAL1_257000_481000 0.064
R_VDD5_17413 METAL1_257000_481000 METAL1_257000_477000 0.032
R_VDD5_17414 METAL1_257000_477000 METAL1_258000_477000 0.008
R_VDD5_17415 METAL1_258000_477000 METAL1_264000_477000 0.048
R_VDD5_17416 METAL1_264000_477000 METAL1_266000_477000 0.016
R_VDD5_17417 METAL1_266000_477000 METAL1_268000_477000 0.016
R_VDD5_17418 METAL1_268000_477000 METAL1_269000_477000 0.008
R_VDD5_17419 METAL1_269000_477000 METAL1_269000_469000 0.064
R_VDD5_17420 METAL1_269000_469000 METAL1_269000_465000 0.032
R_VDD5_17421 METAL1_269000_465000 METAL1_269000_453000 0.096
R_VDD5_17422 METAL1_269000_453000 METAL1_269000_441000 0.096
R_VDD5_17423 METAL1_269000_441000 METAL1_269000_429000 0.096
R_VDD5_17424 METAL1_269000_429000 METAL1_269000_417000 0.096
R_VDD5_17425 METAL1_269000_417000 METAL1_269000_405000 0.096
R_VDD5_17426 METAL1_269000_405000 METAL1_269000_401000 0.032
R_VDD5_17427 METAL1_269000_401000 METAL1_269000_393000 0.064
R_VDD5_17428 METAL1_269000_393000 METAL1_269000_389000 0.032
R_VDD5_17429 METAL1_269000_389000 METAL1_269000_381000 0.064
R_VDD5_17430 METAL1_269000_381000 METAL1_269000_377000 0.032
R_VDD5_17431 METAL1_269000_377000 METAL1_269000_365000 0.096
R_VDD5_17432 METAL1_269000_365000 METAL1_269000_353000 0.096
R_VDD5_17433 METAL1_269000_353000 METAL1_269000_341000 0.096
R_VDD5_17434 METAL1_269000_341000 METAL1_269000_329000 0.096
R_VDD5_17435 METAL1_269000_329000 METAL1_269000_317000 0.096
R_VDD5_17436 METAL1_269000_317000 METAL1_269000_313000 0.032
R_VDD5_17437 METAL1_269000_313000 METAL1_269000_305000 0.064
R_VDD5_17438 METAL1_269000_305000 METAL1_269000_301000 0.032
R_VDD5_17439 METAL1_269000_301000 METAL1_269000_293000 0.064
R_VDD5_17440 METAL1_269000_293000 METAL1_269000_289000 0.032
R_VDD5_17441 METAL1_269000_289000 METAL1_269000_281000 0.064
R_VDD5_17442 METAL1_269000_281000 METAL1_269000_277000 0.032
R_VDD5_17443 METAL1_269000_277000 METAL1_269000_269000 0.064
R_VDD5_17444 METAL1_269000_269000 METAL1_269000_265000 0.032
R_VDD5_17445 METAL1_269000_265000 METAL1_269000_257000 0.064
R_VDD5_17446 METAL1_269000_257000 METAL1_269000_253000 0.032
R_VDD5_17447 METAL1_269000_253000 METAL1_269000_245000 0.064
R_VDD5_17448 METAL1_269000_245000 METAL1_269000_241000 0.032
R_VDD5_17449 METAL1_269000_241000 METAL1_269000_233000 0.064
R_VDD5_17450 METAL1_269000_233000 METAL1_269000_229000 0.032
R_VDD5_17451 METAL1_269000_229000 METAL1_269000_221000 0.064
R_VDD5_17452 METAL1_269000_221000 METAL1_269000_217000 0.032
R_VDD5_17453 METAL1_269000_217000 METAL1_269000_205000 0.096
R_VDD5_17454 METAL1_269000_205000 METAL1_269000_193000 0.096
R_VDD5_17455 METAL1_269000_193000 METAL1_269000_189000 0.032
R_VDD5_17456 METAL1_269000_189000 METAL1_269000_181000 0.064
R_VDD5_17457 METAL1_269000_181000 METAL1_269000_177000 0.032
R_VDD5_17458 METAL1_269000_177000 METAL1_269000_169000 0.064
R_VDD5_17459 METAL1_269000_169000 METAL1_269000_165000 0.032
R_VDD5_17460 METAL1_269000_165000 METAL1_269000_157000 0.064
R_VDD5_17461 METAL1_269000_157000 METAL1_269000_153000 0.032
R_VDD5_17462 METAL1_269000_153000 METAL1_269000_145000 0.064
R_VDD5_17463 METAL1_269000_145000 METAL1_269000_141000 0.032
R_VDD5_17464 METAL1_269000_141000 METAL2_269000_141000 0.1
R_VDD5_17465 METAL2_269000_141000 METAL2_269000_133000 0.064
R_VDD5_17466 METAL2_269000_133000 METAL2_269000_129000 0.032
R_VDD5_17467 METAL2_269000_129000 METAL2_269000_121000 0.064
R_VDD5_17468 METAL2_269000_121000 METAL2_269000_117000 0.032
R_VDD5_17469 METAL2_269000_117000 METAL2_269000_116000 0.008
R_VDD5_17470 METAL2_269000_116000 METAL2_269000_109000 0.056
R_VDD5_17471 METAL2_269000_109000 METAL2_269000_105000 0.032
R_VDD5_17472 METAL2_269000_105000 METAL2_269000_104000 0.008
R_VDD5_17473 METAL2_269000_104000 METAL2_269000_97000 0.056
R_VDD5_17474 METAL2_269000_97000 METAL2_269000_93000 0.032
R_VDD5_17475 METAL2_269000_93000 METAL2_269000_92000 0.008
R_VDD5_17476 METAL2_269000_92000 METAL2_269000_81000 0.088
R_VDD5_17477 METAL2_269000_81000 METAL2_269000_80000 0.008
R_VDD5_17478 METAL2_269000_80000 METAL2_269000_69000 0.088
R_VDD5_17479 METAL2_269000_69000 METAL2_269000_68000 0.008
R_VDD5_17480 METAL2_269000_68000 METAL2_269000_57000 0.088
R_VDD5_17481 METAL2_269000_57000 METAL2_269000_56000 0.008
R_VDD5_17482 METAL2_269000_56000 METAL2_269000_45000 0.088
R_VDD5_17483 METAL2_269000_45000 METAL2_269000_44000 0.008
R_VDD5_17484 METAL2_269000_44000 METAL2_269000_33000 0.088
R_VDD5_17485 METAL2_269000_33000 METAL2_269000_32000 0.008
R_VDD5_17486 METAL2_269000_32000 METAL2_269000_20000 0.096
R_VDD5_17487 METAL2_269000_20000 METAL2_270000_20000 0.008
R_VDD5_17488 METAL2_270000_20000 METAL2_276000_20000 0.048
R_VDD5_17489 METAL2_276000_20000 METAL2_278000_20000 0.016
R_VDD5_17490 METAL2_278000_20000 METAL2_280000_20000 0.016
R_VDD5_17491 METAL2_280000_20000 METAL2_281000_20000 0.008
R_VDD5_17492 METAL2_281000_20000 METAL2_282000_20000 0.008
R_VDD5_17493 METAL2_282000_20000 METAL2_288000_20000 0.048
R_VDD5_17494 METAL2_288000_20000 METAL2_290000_20000 0.016
R_VDD5_17495 METAL2_290000_20000 METAL2_292000_20000 0.016
R_VDD5_17496 METAL2_292000_20000 METAL2_293000_20000 0.008
R_VDD5_17497 METAL2_293000_20000 METAL2_294000_20000 0.008
R_VDD5_17498 METAL2_294000_20000 METAL2_300000_20000 0.048
R_VDD5_17499 METAL2_300000_20000 METAL2_302000_20000 0.016
R_VDD5_17500 METAL2_302000_20000 METAL2_304000_20000 0.016
R_VDD5_17501 METAL2_304000_20000 METAL2_305000_20000 0.008
R_VDD5_17502 METAL2_305000_20000 METAL2_306000_20000 0.008
R_VDD5_17503 METAL2_306000_20000 METAL2_312000_20000 0.048
R_VDD5_17504 METAL2_312000_20000 METAL2_314000_20000 0.016
R_VDD5_17505 METAL2_314000_20000 METAL2_316000_20000 0.016
R_VDD5_17506 METAL2_316000_20000 METAL2_317000_20000 0.008
R_VDD5_17507 METAL2_317000_20000 METAL2_318000_20000 0.008
R_VDD5_17508 METAL2_318000_20000 METAL2_324000_20000 0.048
R_VDD5_17509 METAL2_324000_20000 METAL2_326000_20000 0.016
R_VDD5_17510 METAL2_326000_20000 METAL2_328000_20000 0.016
R_VDD5_17511 METAL2_328000_20000 METAL2_329000_20000 0.008
R_VDD5_17512 METAL2_329000_20000 METAL2_330000_20000 0.008
R_VDD5_17513 METAL2_330000_20000 METAL2_336000_20000 0.048
R_VDD5_17514 METAL2_336000_20000 METAL2_338000_20000 0.016
R_VDD5_17515 METAL2_338000_20000 METAL2_340000_20000 0.016
R_VDD5_17516 METAL2_340000_20000 METAL2_342000_20000 0.016
R_VDD5_17517 METAL2_342000_20000 METAL2_348000_20000 0.048
R_VDD5_17518 METAL2_348000_20000 METAL2_350000_20000 0.016
R_VDD5_17519 METAL2_350000_20000 METAL2_352000_20000 0.016
R_VDD5_17520 METAL2_352000_20000 METAL2_354000_20000 0.016
R_VDD5_17521 METAL2_354000_20000 METAL2_360000_20000 0.048
R_VDD5_17522 METAL2_360000_20000 METAL2_362000_20000 0.016
R_VDD5_17523 METAL2_362000_20000 METAL2_364000_20000 0.016
R_VDD5_17524 METAL2_364000_20000 METAL2_366000_20000 0.016
R_VDD5_17525 METAL2_366000_20000 METAL2_372000_20000 0.048
R_VDD5_17526 METAL2_372000_20000 METAL2_374000_20000 0.016
R_VDD5_17527 METAL2_374000_20000 METAL2_376000_20000 0.016
R_VDD5_17528 METAL2_376000_20000 METAL2_378000_20000 0.016
R_VDD5_17529 METAL2_378000_20000 METAL2_384000_20000 0.048
R_VDD5_17530 METAL2_384000_20000 METAL2_386000_20000 0.016
R_VDD5_17531 METAL2_386000_20000 METAL2_388000_20000 0.016
R_VDD5_17532 METAL2_388000_20000 METAL2_390000_20000 0.016
R_VDD5_17533 METAL2_390000_20000 METAL2_396000_20000 0.048
R_VDD5_17534 METAL2_396000_20000 METAL2_398000_20000 0.016
R_VDD5_17535 METAL2_398000_20000 METAL2_400000_20000 0.016
R_VDD5_17536 METAL2_400000_20000 METAL2_402000_20000 0.016
R_VDD5_17537 METAL2_402000_20000 METAL2_404000_20000 0.016
R_VDD5_17538 METAL2_404000_20000 METAL2_408000_20000 0.032
R_VDD5_17539 METAL2_408000_20000 METAL2_410000_20000 0.016
R_VDD5_17540 METAL2_410000_20000 METAL2_412000_20000 0.016
R_VDD5_17541 METAL2_412000_20000 METAL2_414000_20000 0.016
R_VDD5_17542 METAL2_414000_20000 METAL2_416000_20000 0.016
R_VDD5_17543 METAL2_416000_20000 METAL2_420000_20000 0.032
R_VDD5_17544 METAL2_420000_20000 METAL2_422000_20000 0.016
R_VDD5_17545 METAL2_422000_20000 METAL2_424000_20000 0.016
R_VDD5_17546 METAL2_424000_20000 METAL2_426000_20000 0.016
R_VDD5_17547 METAL2_426000_20000 METAL2_428000_20000 0.016
R_VDD5_17548 METAL2_428000_20000 METAL2_432000_20000 0.032
R_VDD5_17549 METAL2_432000_20000 METAL2_434000_20000 0.016
R_VDD5_17550 METAL2_434000_20000 METAL2_436000_20000 0.016
R_VDD5_17551 METAL2_436000_20000 METAL2_438000_20000 0.016
R_VDD5_17552 METAL2_438000_20000 METAL2_440000_20000 0.016
R_VDD5_17553 METAL2_440000_20000 METAL2_444000_20000 0.032
R_VDD5_17554 METAL2_444000_20000 METAL2_446000_20000 0.016
R_VDD5_17555 METAL2_446000_20000 METAL2_448000_20000 0.016
R_VDD5_17556 METAL2_448000_20000 METAL3_448000_20000 0.1
R_VDD5_17557 METAL3_448000_20000 METAL3_450000_20000 0.016
R_VDD5_17558 METAL3_450000_20000 METAL3_452000_20000 0.016
R_VDD5_17559 METAL3_452000_20000 METAL3_458000_20000 0.048
R_VDD5_17560 METAL3_458000_20000 METAL3_460000_20000 0.016
R_VDD5_17561 METAL3_460000_20000 METAL3_462000_20000 0.016
R_VDD5_17562 METAL3_462000_20000 METAL3_462000_8000 0.096
R_VDD5_17563 METAL3_462000_8000 METAL3_464000_8000 0.016
R_VDD5_17564 METAL3_464000_8000 METAL3_470000_8000 0.048
R_VDD5_17565 METAL3_470000_8000 METAL3_471000_8000 0.008
R_VDD5_17566 METAL3_471000_8000 METAL3_472000_8000 0.008
R_VDD5_17567 METAL3_472000_8000 METAL3_474000_8000 0.016
R_VDD5_17568 METAL3_474000_8000 METAL3_476000_8000 0.016
R_VDD5_17569 METAL3_476000_8000 METAL3_482000_8000 0.048
R_VDD5_17570 METAL3_482000_8000 METAL3_483000_8000 0.008
R_VDD5_17571 METAL3_483000_8000 METAL3_484000_8000 0.008
R_VDD5_17572 METAL3_484000_8000 METAL3_486000_8000 0.016
R_VDD5_17573 METAL3_486000_8000 METAL3_488000_8000 0.016
R_VDD5_17574 METAL3_488000_8000 METAL3_494000_8000 0.048
R_VDD5_17575 METAL3_494000_8000 METAL3_495000_8000 0.008
R_VDD5_17576 METAL3_495000_8000 METAL3_496000_8000 0.008
R_VDD5_17577 METAL3_496000_8000 METAL3_498000_8000 0.016
R_VDD5_17578 METAL3_498000_8000 METAL3_500000_8000 0.016
R_VDD5_17579 METAL3_500000_8000 METAL4_500000_8000 0.1
R_VDD5_17580 METAL5_500000_601000 METAL4_500000_601000 0.1
R_VDD5_17581 METAL4_500000_601000 METAL4_500000_589000 0.096
R_VDD5_17582 METAL4_500000_589000 METAL4_500000_577000 0.096
R_VDD5_17583 METAL4_500000_577000 METAL4_500000_565000 0.096
R_VDD5_17584 METAL4_500000_565000 METAL4_500000_553000 0.096
R_VDD5_17585 METAL4_500000_553000 METAL4_500000_541000 0.096
R_VDD5_17586 METAL4_500000_541000 METAL4_500000_529000 0.096
R_VDD5_17587 METAL4_500000_529000 METAL4_506000_529000 0.048
R_VDD5_17588 METAL4_506000_529000 METAL4_507000_529000 0.008
R_VDD5_17589 METAL4_507000_529000 METAL3_507000_529000 0.1
R_VDD5_17590 METAL3_507000_529000 METAL3_507000_517000 0.096
R_VDD5_17591 METAL3_507000_517000 METAL3_507000_513000 0.032
R_VDD5_17592 METAL3_507000_513000 METAL3_507000_505000 0.064
R_VDD5_17593 METAL3_507000_505000 METAL3_507000_501000 0.032
R_VDD5_17594 METAL3_507000_501000 METAL3_507000_493000 0.064
R_VDD5_17595 METAL3_507000_493000 METAL3_507000_489000 0.032
R_VDD5_17596 METAL3_507000_489000 METAL3_507000_481000 0.064
R_VDD5_17597 METAL3_507000_481000 METAL3_507000_477000 0.032
R_VDD5_17598 METAL3_507000_477000 METAL3_507000_469000 0.064
R_VDD5_17599 METAL3_507000_469000 METAL3_507000_465000 0.032
R_VDD5_17600 METAL3_507000_465000 METAL3_507000_453000 0.096
R_VDD5_17601 METAL3_507000_453000 METAL3_507000_441000 0.096
R_VDD5_17602 METAL3_507000_441000 METAL3_507000_429000 0.096
R_VDD5_17603 METAL3_507000_429000 METAL3_507000_417000 0.096
R_VDD5_17604 METAL3_507000_417000 METAL3_507000_405000 0.096
R_VDD5_17605 METAL3_507000_405000 METAL3_507000_401000 0.032
R_VDD5_17606 METAL3_507000_401000 METAL3_507000_393000 0.064
R_VDD5_17607 METAL3_507000_393000 METAL3_507000_389000 0.032
R_VDD5_17608 METAL3_507000_389000 METAL3_507000_381000 0.064
R_VDD5_17609 METAL3_507000_381000 METAL3_507000_377000 0.032
R_VDD5_17610 METAL3_507000_377000 METAL3_507000_365000 0.096
R_VDD5_17611 METAL3_507000_365000 METAL3_507000_353000 0.096
R_VDD5_17612 METAL3_507000_353000 METAL3_507000_341000 0.096
R_VDD5_17613 METAL3_507000_341000 METAL3_507000_329000 0.096
R_VDD5_17614 METAL3_507000_329000 METAL3_507000_317000 0.096
R_VDD5_17615 METAL3_507000_317000 METAL3_507000_313000 0.032
R_VDD5_17616 METAL3_507000_313000 METAL3_507000_305000 0.064
R_VDD5_17617 METAL3_507000_305000 METAL3_507000_301000 0.032
R_VDD5_17618 METAL3_507000_301000 METAL3_507000_293000 0.064
R_VDD5_17619 METAL3_507000_293000 METAL3_507000_289000 0.032
R_VDD5_17620 METAL3_507000_289000 METAL3_507000_281000 0.064
R_VDD5_17621 METAL3_507000_281000 METAL3_507000_277000 0.032
R_VDD5_17622 METAL3_507000_277000 METAL3_507000_269000 0.064
R_VDD5_17623 METAL3_507000_269000 METAL3_507000_265000 0.032
R_VDD5_17624 METAL3_507000_265000 METAL3_507000_257000 0.064
R_VDD5_17625 METAL3_507000_257000 METAL3_507000_253000 0.032
R_VDD5_17626 METAL3_507000_253000 METAL3_507000_245000 0.064
R_VDD5_17627 METAL3_507000_245000 METAL3_507000_241000 0.032
R_VDD5_17628 METAL3_507000_241000 METAL3_507000_233000 0.064
R_VDD5_17629 METAL3_507000_233000 METAL3_507000_229000 0.032
R_VDD5_17630 METAL3_507000_229000 METAL3_507000_221000 0.064
R_VDD5_17631 METAL3_507000_221000 METAL3_507000_217000 0.032
R_VDD5_17632 METAL3_507000_217000 METAL3_507000_205000 0.096
R_VDD5_17633 METAL3_507000_205000 METAL3_507000_193000 0.096
R_VDD5_17634 METAL3_507000_193000 METAL3_507000_189000 0.032
R_VDD5_17635 METAL3_507000_189000 METAL3_507000_181000 0.064
R_VDD5_17636 METAL3_507000_181000 METAL3_507000_177000 0.032
R_VDD5_17637 METAL3_507000_177000 METAL3_507000_169000 0.064
R_VDD5_17638 METAL3_507000_169000 METAL3_507000_165000 0.032
R_VDD5_17639 METAL3_507000_165000 METAL3_507000_157000 0.064
R_VDD5_17640 METAL3_507000_157000 METAL3_507000_153000 0.032
R_VDD5_17641 METAL3_507000_153000 METAL3_507000_145000 0.064
R_VDD5_17642 METAL3_507000_145000 METAL3_507000_141000 0.032
R_VDD5_17643 METAL3_507000_141000 METAL3_507000_133000 0.064
R_VDD5_17644 METAL3_507000_133000 METAL3_507000_129000 0.032
R_VDD5_17645 METAL3_507000_129000 METAL3_507000_121000 0.064
R_VDD5_17646 METAL3_507000_121000 METAL3_507000_117000 0.032
R_VDD5_17647 METAL3_507000_117000 METAL3_507000_116000 0.008
R_VDD5_17648 METAL3_507000_116000 METAL3_507000_109000 0.056
R_VDD5_17649 METAL3_507000_109000 METAL3_507000_105000 0.032
R_VDD5_17650 METAL3_507000_105000 METAL3_507000_104000 0.008
R_VDD5_17651 METAL3_507000_104000 METAL3_507000_97000 0.056
R_VDD5_17652 METAL3_507000_97000 METAL3_507000_93000 0.032
R_VDD5_17653 METAL3_507000_93000 METAL3_507000_92000 0.008
R_VDD5_17654 METAL3_507000_92000 METAL3_507000_81000 0.088
R_VDD5_17655 METAL3_507000_81000 METAL3_507000_80000 0.008
R_VDD5_17656 METAL3_507000_80000 METAL3_507000_69000 0.088
R_VDD5_17657 METAL3_507000_69000 METAL3_507000_68000 0.008
R_VDD5_17658 METAL3_507000_68000 METAL3_507000_57000 0.088
R_VDD5_17659 METAL3_507000_57000 METAL3_507000_56000 0.008
R_VDD5_17660 METAL3_507000_56000 METAL3_507000_45000 0.088
R_VDD5_17661 METAL3_507000_45000 METAL3_507000_44000 0.008
R_VDD5_17662 METAL3_507000_44000 METAL3_507000_33000 0.088
R_VDD5_17663 METAL3_507000_33000 METAL3_507000_32000 0.008
R_VDD5_17664 METAL3_507000_32000 METAL3_507000_20000 0.096
R_VDD5_17665 METAL3_507000_20000 METAL3_506000_20000 0.008
R_VDD5_17666 METAL3_506000_20000 METAL3_500000_20000 0.048
R_VDD5_17667 METAL3_500000_20000 METAL3_500000_8000 0.096
R_VDD5_17668 METAL6_474000_20000 METAL5_474000_20000 0.1
R_VDD5_17669 METAL5_474000_20000 METAL5_474000_32000 0.048
R_VDD5_17670 METAL5_474000_32000 METAL5_476000_32000 0.008
R_VDD5_17671 METAL5_476000_32000 METAL5_482000_32000 0.024
R_VDD5_17672 METAL5_482000_32000 METAL5_483000_32000 0.004
R_VDD5_17673 METAL5_483000_32000 METAL5_484000_32000 0.004
R_VDD5_17674 METAL5_484000_32000 METAL5_486000_32000 0.008
R_VDD5_17675 METAL5_486000_32000 METAL5_488000_32000 0.008
R_VDD5_17676 METAL5_488000_32000 METAL4_488000_32000 0.1
R_VDD5_17677 METAL4_488000_32000 METAL4_494000_32000 0.048
R_VDD5_17678 METAL4_494000_32000 METAL4_495000_32000 0.008
R_VDD5_17679 METAL4_495000_32000 METAL4_496000_32000 0.008
R_VDD5_17680 METAL4_496000_32000 METAL4_498000_32000 0.016
R_VDD5_17681 METAL4_498000_32000 METAL4_500000_32000 0.016
R_VDD5_17682 METAL4_500000_32000 METAL4_506000_32000 0.048
R_VDD5_17683 METAL4_506000_32000 METAL4_507000_32000 0.008
R_VDD5_17684 METAL4_507000_32000 METAL4_508000_32000 0.008
R_VDD5_17685 METAL4_508000_32000 METAL4_510000_32000 0.016
R_VDD5_17686 METAL4_510000_32000 METAL4_512000_32000 0.016
R_VDD5_17687 METAL4_512000_32000 METAL4_512000_20000 0.096
R_VDD5_17688 METAL4_512000_20000 METAL4_512000_8000 0.096
R_VDD5_17689 METAL4_512000_8000 METAL4_510000_8000 0.016
R_VDD5_17690 METAL4_510000_8000 METAL4_508000_8000 0.016
R_VDD5_17691 METAL4_508000_8000 METAL4_507000_8000 0.008
R_VDD5_17692 METAL4_507000_8000 METAL4_506000_8000 0.008
R_VDD5_17693 METAL4_506000_8000 METAL4_500000_8000 0.048
R_VDD5_17694 METAL5_500000_8000 METAL4_500000_8000 0.1
R_VDD5_17695 METAL4_500000_8000 METAL3_500000_8000 0.1
R_VDD5_17696 METAL3_500000_8000 METAL3_506000_8000 0.048
R_VDD5_17697 METAL3_506000_8000 METAL3_507000_8000 0.008
R_VDD5_17698 METAL3_507000_8000 METAL3_508000_8000 0.008
R_VDD5_17699 METAL3_508000_8000 METAL3_510000_8000 0.016
R_VDD5_17700 METAL3_510000_8000 METAL3_512000_8000 0.016
R_VDD5_17701 METAL3_512000_8000 METAL3_519000_8000 0.056
R_VDD5_17702 METAL3_519000_8000 METAL3_519000_20000 0.096
R_VDD5_17703 METAL3_519000_20000 METAL3_519000_32000 0.096
R_VDD5_17704 METAL3_519000_32000 METAL3_519000_33000 0.008
R_VDD5_17705 METAL3_519000_33000 METAL3_519000_44000 0.088
R_VDD5_17706 METAL3_519000_44000 METAL3_519000_45000 0.008
R_VDD5_17707 METAL3_519000_45000 METAL3_519000_56000 0.088
R_VDD5_17708 METAL3_519000_56000 METAL3_519000_57000 0.008
R_VDD5_17709 METAL3_519000_57000 METAL3_519000_68000 0.088
R_VDD5_17710 METAL3_519000_68000 METAL3_519000_69000 0.008
R_VDD5_17711 METAL3_519000_69000 METAL3_519000_80000 0.088
R_VDD5_17712 METAL3_519000_80000 METAL3_519000_81000 0.008
R_VDD5_17713 METAL3_519000_81000 METAL3_519000_92000 0.088
R_VDD5_17714 METAL3_519000_92000 METAL3_519000_93000 0.008
R_VDD5_17715 METAL3_519000_93000 METAL3_519000_97000 0.032
R_VDD5_17716 METAL3_519000_97000 METAL3_519000_104000 0.056
R_VDD5_17717 METAL3_519000_104000 METAL3_519000_105000 0.008
R_VDD5_17718 METAL3_519000_105000 METAL3_519000_109000 0.032
R_VDD5_17719 METAL3_519000_109000 METAL3_519000_116000 0.056
R_VDD5_17720 METAL3_519000_116000 METAL3_519000_117000 0.008
R_VDD5_17721 METAL3_519000_117000 METAL3_519000_121000 0.032
R_VDD5_17722 METAL3_519000_121000 METAL3_519000_129000 0.064
R_VDD5_17723 METAL3_519000_129000 METAL3_519000_133000 0.032
R_VDD5_17724 METAL3_519000_133000 METAL3_519000_141000 0.064
R_VDD5_17725 METAL3_519000_141000 METAL3_519000_145000 0.032
R_VDD5_17726 METAL3_519000_145000 METAL3_519000_153000 0.064
R_VDD5_17727 METAL3_519000_153000 METAL3_519000_157000 0.032
R_VDD5_17728 METAL3_519000_157000 METAL3_519000_165000 0.064
R_VDD5_17729 METAL3_519000_165000 METAL3_519000_169000 0.032
R_VDD5_17730 METAL3_519000_169000 METAL3_519000_177000 0.064
R_VDD5_17731 METAL3_519000_177000 METAL3_519000_181000 0.032
R_VDD5_17732 METAL3_519000_181000 METAL3_519000_189000 0.064
R_VDD5_17733 METAL3_519000_189000 METAL3_519000_193000 0.032
R_VDD5_17734 METAL3_519000_193000 METAL3_519000_205000 0.096
R_VDD5_17735 METAL3_519000_205000 METAL3_519000_217000 0.096
R_VDD5_17736 METAL3_519000_217000 METAL3_519000_221000 0.032
R_VDD5_17737 METAL3_519000_221000 METAL3_519000_229000 0.064
R_VDD5_17738 METAL3_519000_229000 METAL3_519000_233000 0.032
R_VDD5_17739 METAL3_519000_233000 METAL3_519000_241000 0.064
R_VDD5_17740 METAL3_519000_241000 METAL3_519000_245000 0.032
R_VDD5_17741 METAL3_519000_245000 METAL3_519000_253000 0.064
R_VDD5_17742 METAL3_519000_253000 METAL3_519000_257000 0.032
R_VDD5_17743 METAL3_519000_257000 METAL3_519000_265000 0.064
R_VDD5_17744 METAL3_519000_265000 METAL3_519000_269000 0.032
R_VDD5_17745 METAL3_519000_269000 METAL3_519000_277000 0.064
R_VDD5_17746 METAL3_519000_277000 METAL3_519000_281000 0.032
R_VDD5_17747 METAL3_519000_281000 METAL3_519000_289000 0.064
R_VDD5_17748 METAL3_519000_289000 METAL3_519000_293000 0.032
R_VDD5_17749 METAL3_519000_293000 METAL3_519000_301000 0.064
R_VDD5_17750 METAL3_519000_301000 METAL3_519000_305000 0.032
R_VDD5_17751 METAL3_519000_305000 METAL3_519000_313000 0.064
R_VDD5_17752 METAL3_519000_313000 METAL3_519000_317000 0.032
R_VDD5_17753 METAL3_519000_317000 METAL4_519000_317000 0.1
R_VDD5_17754 METAL4_519000_317000 METAL4_519000_329000 0.096
R_VDD5_17755 METAL4_519000_329000 METAL4_519000_341000 0.096
R_VDD5_17756 METAL4_519000_341000 METAL4_519000_353000 0.096
R_VDD5_17757 METAL4_519000_353000 METAL4_519000_365000 0.096
R_VDD5_17758 METAL4_519000_365000 METAL4_519000_377000 0.096
R_VDD5_17759 METAL4_519000_377000 METAL4_519000_381000 0.032
R_VDD5_17760 METAL4_519000_381000 METAL4_519000_389000 0.064
R_VDD5_17761 METAL4_519000_389000 METAL4_519000_393000 0.032
R_VDD5_17762 METAL4_519000_393000 METAL4_519000_401000 0.064
R_VDD5_17763 METAL4_519000_401000 METAL4_519000_405000 0.032
R_VDD5_17764 METAL4_519000_405000 METAL4_519000_417000 0.096
R_VDD5_17765 METAL4_519000_417000 METAL4_519000_429000 0.096
R_VDD5_17766 METAL4_519000_429000 METAL4_519000_441000 0.096
R_VDD5_17767 METAL4_519000_441000 METAL4_519000_453000 0.096
R_VDD5_17768 METAL4_519000_453000 METAL4_519000_465000 0.096
R_VDD5_17769 METAL4_519000_465000 METAL4_519000_469000 0.032
R_VDD5_17770 METAL4_519000_469000 METAL4_519000_477000 0.064
R_VDD5_17771 METAL4_519000_477000 METAL4_522000_477000 0.024
R_VDD5_17772 METAL4_522000_477000 METAL4_524000_477000 0.016
R_VDD5_17773 METAL4_524000_477000 METAL4_531000_477000 0.056
R_VDD5_17774 METAL4_531000_477000 METAL4_536000_477000 0.04
R_VDD5_17775 METAL4_536000_477000 METAL4_543000_477000 0.056
R_VDD5_17776 METAL4_543000_477000 METAL5_543000_477000 0.1
R_VDD5_17777 METAL5_543000_477000 METAL6_543000_477000 0.1
R_VDD5_17778 METAL6_543000_477000 METAL6_543000_481000 0.008
R_VDD5_17779 METAL6_543000_481000 METAL6_543000_489000 0.016
R_VDD5_17780 METAL6_543000_489000 METAL6_543000_493000 0.008
R_VDD5_17781 METAL6_543000_493000 METAL6_543000_501000 0.016
R_VDD5_17782 METAL6_543000_501000 METAL6_543000_505000 0.008
R_VDD5_17783 METAL6_543000_505000 METAL6_543000_513000 0.016
R_VDD5_17784 METAL6_543000_513000 METAL6_543000_517000 0.008
R_VDD5_17785 METAL6_543000_517000 METAL6_543000_529000 0.024
R_VDD5_17786 METAL6_543000_529000 METAL6_543000_541000 0.024
R_VDD5_17787 METAL6_543000_541000 METAL6_543000_553000 0.024
R_VDD5_17788 METAL6_543000_553000 METAL6_543000_565000 0.024
R_VDD5_17789 METAL6_257000_1265000 METAL5_257000_1265000 0.1
R_VDD5_17790 METAL5_257000_1265000 METAL5_257000_1253000 0.048
R_VDD5_17791 METAL5_257000_1253000 METAL5_257000_1241000 0.048
R_VDD5_17792 METAL5_257000_1241000 METAL5_257000_1229000 0.048
R_VDD5_17793 METAL5_257000_1229000 METAL5_257000_1217000 0.048
R_VDD5_17794 METAL5_257000_1217000 METAL5_257000_1205000 0.048
R_VDD5_17795 METAL5_257000_1205000 METAL5_257000_1201000 0.016
R_VDD5_17796 METAL5_257000_1201000 METAL5_257000_1189000 0.048
R_VDD5_17797 METAL5_257000_1189000 METAL5_258000_1189000 0.004
R_VDD5_17798 METAL5_258000_1189000 METAL5_264000_1189000 0.024
R_VDD5_17799 METAL5_264000_1189000 METAL5_266000_1189000 0.008
R_VDD5_17800 METAL5_266000_1189000 METAL5_268000_1189000 0.008
R_VDD5_17801 METAL5_268000_1189000 METAL5_269000_1189000 0.004
R_VDD5_17802 METAL5_269000_1189000 METAL5_270000_1189000 0.004
R_VDD5_17803 METAL5_270000_1189000 METAL5_276000_1189000 0.024
R_VDD5_17804 METAL5_276000_1189000 METAL4_276000_1189000 0.1
R_VDD5_17805 METAL4_276000_1189000 METAL3_276000_1189000 0.1
R_VDD5_17806 METAL3_276000_1189000 METAL2_276000_1189000 0.1
R_VDD5_17807 METAL2_276000_1189000 METAL2_276000_1177000 0.096
R_VDD5_17808 METAL2_276000_1177000 METAL2_276000_1165000 0.096
R_VDD5_17809 METAL2_276000_1165000 METAL2_276000_1153000 0.096
R_VDD5_17810 METAL2_276000_1153000 METAL2_276000_1141000 0.096
R_VDD5_17811 METAL2_276000_1141000 METAL2_276000_1113000 0.224
R_VDD5_17812 METAL2_276000_1113000 METAL2_276000_1101000 0.096
R_VDD5_17813 METAL2_276000_1101000 METAL2_276000_1089000 0.096
R_VDD5_17814 METAL2_276000_1089000 METAL2_276000_1077000 0.096
R_VDD5_17815 METAL2_276000_1077000 METAL2_276000_1065000 0.096
R_VDD5_17816 METAL2_276000_1065000 METAL2_276000_1053000 0.096
R_VDD5_17817 METAL2_276000_1053000 METAL2_276000_1041000 0.096
R_VDD5_17818 METAL2_276000_1041000 METAL2_276000_1037000 0.032
R_VDD5_17819 METAL2_276000_1037000 METAL2_276000_1025000 0.096
R_VDD5_17820 METAL2_276000_1025000 METAL2_276000_1013000 0.096
R_VDD5_17821 METAL2_276000_1013000 METAL2_276000_1001000 0.096
R_VDD5_17822 METAL2_276000_1001000 METAL2_276000_989000 0.096
R_VDD5_17823 METAL2_276000_989000 METAL2_276000_977000 0.096
R_VDD5_17824 METAL2_276000_977000 METAL2_276000_965000 0.096
R_VDD5_17825 METAL2_276000_965000 METAL2_276000_953000 0.096
R_VDD5_17826 METAL2_276000_953000 METAL2_276000_941000 0.096
R_VDD5_17827 METAL2_276000_941000 METAL2_276000_929000 0.096
R_VDD5_17828 METAL2_276000_929000 METAL2_276000_917000 0.096
R_VDD5_17829 METAL2_276000_917000 METAL2_276000_913000 0.032
R_VDD5_17830 METAL2_276000_913000 METAL2_276000_905000 0.064
R_VDD5_17831 METAL2_276000_905000 METAL2_276000_901000 0.032
R_VDD5_17832 METAL2_276000_901000 METAL2_276000_893000 0.064
R_VDD5_17833 METAL2_276000_893000 METAL2_276000_889000 0.032
R_VDD5_17834 METAL2_276000_889000 METAL2_276000_881000 0.064
R_VDD5_17835 METAL2_276000_881000 METAL2_276000_877000 0.032
R_VDD5_17836 METAL2_276000_877000 METAL2_278000_877000 0.016
R_VDD5_17837 METAL2_278000_877000 METAL2_280000_877000 0.016
R_VDD5_17838 METAL2_280000_877000 METAL2_281000_877000 0.008
R_VDD5_17839 METAL2_281000_877000 METAL2_281000_869000 0.064
R_VDD5_17840 METAL2_281000_869000 METAL2_281000_865000 0.032
R_VDD5_17841 METAL2_281000_865000 METAL2_281000_857000 0.064
R_VDD5_17842 METAL2_281000_857000 METAL2_281000_853000 0.032
R_VDD5_17843 METAL2_281000_853000 METAL2_281000_845000 0.064
R_VDD5_17844 METAL2_281000_845000 METAL2_281000_841000 0.032
R_VDD5_17845 METAL2_281000_841000 METAL2_281000_829000 0.096
R_VDD5_17846 METAL2_281000_829000 METAL2_281000_817000 0.096
R_VDD5_17847 METAL2_281000_817000 METAL2_281000_805000 0.096
R_VDD5_17848 METAL2_281000_805000 METAL2_281000_793000 0.096
R_VDD5_17849 METAL2_281000_793000 METAL2_281000_781000 0.096
R_VDD5_17850 METAL2_281000_781000 METAL2_281000_769000 0.096
R_VDD5_17851 METAL2_281000_769000 METAL2_281000_757000 0.096
R_VDD5_17852 METAL2_281000_757000 METAL2_281000_729000 0.224
R_VDD5_17853 METAL2_281000_729000 METAL2_281000_717000 0.096
R_VDD5_17854 METAL2_281000_717000 METAL2_281000_707000 0.08
R_VDD5_17855 METAL2_281000_707000 METAL2_281000_705000 0.016
R_VDD5_17856 METAL2_281000_705000 METAL2_281000_693000 0.096
R_VDD5_17857 METAL2_281000_693000 METAL2_281000_681000 0.096
R_VDD5_17858 METAL2_281000_681000 METAL2_281000_669000 0.096
R_VDD5_17859 METAL2_281000_669000 METAL2_281000_657000 0.096
R_VDD5_17860 METAL2_281000_657000 METAL2_281000_625000 0.256
R_VDD5_17861 METAL2_281000_625000 METAL2_281000_613000 0.096
R_VDD5_17862 METAL2_281000_613000 METAL2_281000_601000 0.096
R_VDD5_17863 METAL2_281000_601000 METAL2_281000_589000 0.096
R_VDD5_17864 METAL2_281000_589000 METAL2_281000_577000 0.096
R_VDD5_17865 METAL2_281000_577000 METAL2_281000_565000 0.096
R_VDD5_17866 METAL2_281000_565000 METAL2_281000_553000 0.096
R_VDD5_17867 METAL2_281000_553000 METAL2_281000_541000 0.096
R_VDD5_17868 METAL2_281000_541000 METAL2_281000_529000 0.096
R_VDD5_17869 METAL2_281000_529000 METAL2_281000_517000 0.096
R_VDD5_17870 METAL2_281000_517000 METAL2_281000_513000 0.032
R_VDD5_17871 METAL2_281000_513000 METAL2_281000_505000 0.064
R_VDD5_17872 METAL2_281000_505000 METAL2_281000_501000 0.032
R_VDD5_17873 METAL2_281000_501000 METAL2_281000_493000 0.064
R_VDD5_17874 METAL2_281000_493000 METAL2_281000_489000 0.032
R_VDD5_17875 METAL2_281000_489000 METAL2_281000_481000 0.064
R_VDD5_17876 METAL2_281000_481000 METAL2_281000_477000 0.032
R_VDD5_17877 METAL2_281000_477000 METAL2_281000_469000 0.064
R_VDD5_17878 METAL2_281000_469000 METAL2_281000_465000 0.032
R_VDD5_17879 METAL2_281000_465000 METAL2_281000_453000 0.096
R_VDD5_17880 METAL2_281000_453000 METAL2_281000_441000 0.096
R_VDD5_17881 METAL2_281000_441000 METAL2_281000_429000 0.096
R_VDD5_17882 METAL2_281000_429000 METAL2_281000_417000 0.096
R_VDD5_17883 METAL2_281000_417000 METAL2_281000_405000 0.096
R_VDD5_17884 METAL2_281000_405000 METAL2_281000_401000 0.032
R_VDD5_17885 METAL2_281000_401000 METAL2_281000_393000 0.064
R_VDD5_17886 METAL2_281000_393000 METAL2_281000_389000 0.032
R_VDD5_17887 METAL2_281000_389000 METAL2_281000_381000 0.064
R_VDD5_17888 METAL2_281000_381000 METAL2_281000_377000 0.032
R_VDD5_17889 METAL2_281000_377000 METAL2_281000_365000 0.096
R_VDD5_17890 METAL2_281000_365000 METAL2_281000_353000 0.096
R_VDD5_17891 METAL2_281000_353000 METAL2_281000_341000 0.096
R_VDD5_17892 METAL2_281000_341000 METAL2_281000_329000 0.096
R_VDD5_17893 METAL2_281000_329000 METAL2_281000_317000 0.096
R_VDD5_17894 METAL2_281000_317000 METAL2_281000_313000 0.032
R_VDD5_17895 METAL2_281000_313000 METAL2_281000_305000 0.064
R_VDD5_17896 METAL2_281000_305000 METAL2_281000_301000 0.032
R_VDD5_17897 METAL2_281000_301000 METAL2_281000_293000 0.064
R_VDD5_17898 METAL2_281000_293000 METAL2_281000_289000 0.032
R_VDD5_17899 METAL2_281000_289000 METAL2_281000_281000 0.064
R_VDD5_17900 METAL2_281000_281000 METAL2_281000_277000 0.032
R_VDD5_17901 METAL2_281000_277000 METAL2_281000_269000 0.064
R_VDD5_17902 METAL2_281000_269000 METAL2_281000_265000 0.032
R_VDD5_17903 METAL2_281000_265000 METAL2_281000_257000 0.064
R_VDD5_17904 METAL2_281000_257000 METAL2_281000_253000 0.032
R_VDD5_17905 METAL2_281000_253000 METAL2_281000_245000 0.064
R_VDD5_17906 METAL2_281000_245000 METAL2_281000_241000 0.032
R_VDD5_17907 METAL2_281000_241000 METAL2_281000_233000 0.064
R_VDD5_17908 METAL2_281000_233000 METAL2_281000_229000 0.032
R_VDD5_17909 METAL2_281000_229000 METAL2_281000_221000 0.064
R_VDD5_17910 METAL2_281000_221000 METAL2_281000_217000 0.032
R_VDD5_17911 METAL2_281000_217000 METAL2_281000_205000 0.096
R_VDD5_17912 METAL2_281000_205000 METAL2_281000_201000 0.032
R_VDD5_17913 METAL2_281000_201000 METAL2_281000_193000 0.064
R_VDD5_17914 METAL2_281000_193000 METAL2_281000_189000 0.032
R_VDD5_17915 METAL2_281000_189000 METAL2_281000_181000 0.064
R_VDD5_17916 METAL2_281000_181000 METAL2_281000_177000 0.032
R_VDD5_17917 METAL2_281000_177000 METAL2_281000_169000 0.064
R_VDD5_17918 METAL2_281000_169000 METAL2_281000_165000 0.032
R_VDD5_17919 METAL2_281000_165000 METAL2_281000_157000 0.064
R_VDD5_17920 METAL2_281000_157000 METAL2_281000_153000 0.032
R_VDD5_17921 METAL2_281000_153000 METAL2_281000_145000 0.064
R_VDD5_17922 METAL2_281000_145000 METAL2_281000_141000 0.032
R_VDD5_17923 METAL2_281000_141000 METAL2_281000_133000 0.064
R_VDD5_17924 METAL2_281000_133000 METAL2_281000_129000 0.032
R_VDD5_17925 METAL2_281000_129000 METAL2_281000_128000 0.008
R_VDD5_17926 METAL2_281000_128000 METAL2_281000_121000 0.056
R_VDD5_17927 METAL2_281000_121000 METAL2_281000_117000 0.032
R_VDD5_17928 METAL2_281000_117000 METAL2_281000_116000 0.008
R_VDD5_17929 METAL2_281000_116000 METAL2_281000_109000 0.056
R_VDD5_17930 METAL2_281000_109000 METAL2_281000_105000 0.032
R_VDD5_17931 METAL2_281000_105000 METAL2_281000_104000 0.008
R_VDD5_17932 METAL2_281000_104000 METAL2_281000_97000 0.056
R_VDD5_17933 METAL2_281000_97000 METAL2_281000_93000 0.032
R_VDD5_17934 METAL2_281000_93000 METAL2_281000_92000 0.008
R_VDD5_17935 METAL2_281000_92000 METAL2_281000_81000 0.088
R_VDD5_17936 METAL2_281000_81000 METAL2_281000_80000 0.008
R_VDD5_17937 METAL2_281000_80000 METAL2_281000_69000 0.088
R_VDD5_17938 METAL2_281000_69000 METAL2_281000_68000 0.008
R_VDD5_17939 METAL2_281000_68000 METAL2_281000_57000 0.088
R_VDD5_17940 METAL2_281000_57000 METAL2_281000_56000 0.008
R_VDD5_17941 METAL2_281000_56000 METAL2_281000_45000 0.088
R_VDD5_17942 METAL2_281000_45000 METAL2_281000_44000 0.008
R_VDD5_17943 METAL2_281000_44000 METAL2_281000_33000 0.088
R_VDD5_17944 METAL2_281000_33000 METAL2_281000_32000 0.008
R_VDD5_17945 METAL2_281000_32000 METAL2_282000_32000 0.008
R_VDD5_17946 METAL2_282000_32000 METAL2_288000_32000 0.048
R_VDD5_17947 METAL2_288000_32000 METAL2_290000_32000 0.016
R_VDD5_17948 METAL2_290000_32000 METAL2_292000_32000 0.016
R_VDD5_17949 METAL2_292000_32000 METAL2_293000_32000 0.008
R_VDD5_17950 METAL2_293000_32000 METAL2_294000_32000 0.008
R_VDD5_17951 METAL2_294000_32000 METAL2_300000_32000 0.048
R_VDD5_17952 METAL2_300000_32000 METAL2_302000_32000 0.016
R_VDD5_17953 METAL2_302000_32000 METAL2_304000_32000 0.016
R_VDD5_17954 METAL2_304000_32000 METAL2_305000_32000 0.008
R_VDD5_17955 METAL2_305000_32000 METAL2_306000_32000 0.008
R_VDD5_17956 METAL2_306000_32000 METAL2_312000_32000 0.048
R_VDD5_17957 METAL2_312000_32000 METAL2_314000_32000 0.016
R_VDD5_17958 METAL2_314000_32000 METAL2_316000_32000 0.016
R_VDD5_17959 METAL2_316000_32000 METAL2_317000_32000 0.008
R_VDD5_17960 METAL2_317000_32000 METAL2_318000_32000 0.008
R_VDD5_17961 METAL2_318000_32000 METAL2_324000_32000 0.048
R_VDD5_17962 METAL2_324000_32000 METAL2_326000_32000 0.016
R_VDD5_17963 METAL2_326000_32000 METAL2_328000_32000 0.016
R_VDD5_17964 METAL2_328000_32000 METAL2_329000_32000 0.008
R_VDD5_17965 METAL2_329000_32000 METAL2_330000_32000 0.008
R_VDD5_17966 METAL2_330000_32000 METAL2_336000_32000 0.048
R_VDD5_17967 METAL2_336000_32000 METAL2_338000_32000 0.016
R_VDD5_17968 METAL2_338000_32000 METAL2_340000_32000 0.016
R_VDD5_17969 METAL2_340000_32000 METAL2_342000_32000 0.016
R_VDD5_17970 METAL2_342000_32000 METAL2_348000_32000 0.048
R_VDD5_17971 METAL2_348000_32000 METAL2_350000_32000 0.016
R_VDD5_17972 METAL2_350000_32000 METAL2_352000_32000 0.016
R_VDD5_17973 METAL2_352000_32000 METAL2_354000_32000 0.016
R_VDD5_17974 METAL2_354000_32000 METAL2_360000_32000 0.048
R_VDD5_17975 METAL2_360000_32000 METAL2_362000_32000 0.016
R_VDD5_17976 METAL2_362000_32000 METAL2_364000_32000 0.016
R_VDD5_17977 METAL2_364000_32000 METAL2_366000_32000 0.016
R_VDD5_17978 METAL2_366000_32000 METAL2_372000_32000 0.048
R_VDD5_17979 METAL2_372000_32000 METAL2_374000_32000 0.016
R_VDD5_17980 METAL2_374000_32000 METAL2_376000_32000 0.016
R_VDD5_17981 METAL2_376000_32000 METAL2_378000_32000 0.016
R_VDD5_17982 METAL2_378000_32000 METAL2_384000_32000 0.048
R_VDD5_17983 METAL2_384000_32000 METAL2_386000_32000 0.016
R_VDD5_17984 METAL2_386000_32000 METAL2_388000_32000 0.016
R_VDD5_17985 METAL2_388000_32000 METAL2_390000_32000 0.016
R_VDD5_17986 METAL2_390000_32000 METAL2_396000_32000 0.048
R_VDD5_17987 METAL2_396000_32000 METAL2_398000_32000 0.016
R_VDD5_17988 METAL2_398000_32000 METAL2_400000_32000 0.016
R_VDD5_17989 METAL2_400000_32000 METAL2_402000_32000 0.016
R_VDD5_17990 METAL2_402000_32000 METAL2_404000_32000 0.016
R_VDD5_17991 METAL2_404000_32000 METAL2_408000_32000 0.032
R_VDD5_17992 METAL2_408000_32000 METAL2_410000_32000 0.016
R_VDD5_17993 METAL2_410000_32000 METAL2_412000_32000 0.016
R_VDD5_17994 METAL2_412000_32000 METAL2_414000_32000 0.016
R_VDD5_17995 METAL2_414000_32000 METAL2_416000_32000 0.016
R_VDD5_17996 METAL2_416000_32000 METAL2_420000_32000 0.032
R_VDD5_17997 METAL2_420000_32000 METAL2_422000_32000 0.016
R_VDD5_17998 METAL2_422000_32000 METAL2_424000_32000 0.016
R_VDD5_17999 METAL2_424000_32000 METAL2_426000_32000 0.016
R_VDD5_18000 METAL2_426000_32000 METAL2_428000_32000 0.016
R_VDD5_18001 METAL2_428000_32000 METAL2_432000_32000 0.032
R_VDD5_18002 METAL2_432000_32000 METAL2_434000_32000 0.016
R_VDD5_18003 METAL2_434000_32000 METAL2_436000_32000 0.016
R_VDD5_18004 METAL2_436000_32000 METAL2_438000_32000 0.016
R_VDD5_18005 METAL2_438000_32000 METAL2_440000_32000 0.016
R_VDD5_18006 METAL2_440000_32000 METAL2_444000_32000 0.032
R_VDD5_18007 METAL2_444000_32000 METAL2_446000_32000 0.016
R_VDD5_18008 METAL2_446000_32000 METAL2_448000_32000 0.016
R_VDD5_18009 METAL2_448000_32000 METAL2_450000_32000 0.016
R_VDD5_18010 METAL2_450000_32000 METAL2_452000_32000 0.016
R_VDD5_18011 METAL2_452000_32000 METAL2_458000_32000 0.048
R_VDD5_18012 METAL2_458000_32000 METAL2_460000_32000 0.016
R_VDD5_18013 METAL2_460000_32000 METAL2_460000_21000 0.088
R_VDD5_18014 METAL2_460000_21000 METAL2_462000_21000 0.016
R_VDD5_18015 METAL2_462000_21000 METAL2_464000_21000 0.016
R_VDD5_18016 METAL2_464000_21000 METAL2_470000_21000 0.048
R_VDD5_18017 METAL2_470000_21000 METAL2_470000_20000 0.008
R_VDD5_18018 METAL2_470000_20000 METAL2_470000_9000 0.088
R_VDD5_18019 METAL2_470000_9000 METAL2_471000_9000 0.008
R_VDD5_18020 METAL2_471000_9000 METAL2_472000_9000 0.008
R_VDD5_18021 METAL2_472000_9000 METAL2_474000_9000 0.016
R_VDD5_18022 METAL2_474000_9000 METAL2_476000_9000 0.016
R_VDD5_18023 METAL2_476000_9000 METAL2_482000_9000 0.048
R_VDD5_18024 METAL2_482000_9000 METAL2_483000_9000 0.008
R_VDD5_18025 METAL2_483000_9000 METAL2_484000_9000 0.008
R_VDD5_18026 METAL2_484000_9000 METAL2_486000_9000 0.016
R_VDD5_18027 METAL2_486000_9000 METAL2_488000_9000 0.016
R_VDD5_18028 METAL2_488000_9000 METAL2_488000_8000 0.008
R_VDD5_18029 METAL2_488000_8000 METAL2_494000_8000 0.048
R_VDD5_18030 METAL2_494000_8000 METAL2_495000_8000 0.008
R_VDD5_18031 METAL2_495000_8000 METAL2_496000_8000 0.008
R_VDD5_18032 METAL2_496000_8000 METAL2_498000_8000 0.016
R_VDD5_18033 METAL2_498000_8000 METAL2_500000_8000 0.016
R_VDD5_18034 METAL2_500000_8000 METAL3_500000_8000 0.1
R_VDD5_18035 METAL5_257000_1265000 METAL5_258000_1265000 0.004
R_VDD5_18036 METAL5_258000_1265000 METAL5_264000_1265000 0.024
R_VDD5_18037 METAL5_264000_1265000 METAL5_266000_1265000 0.008
R_VDD5_18038 METAL5_266000_1265000 METAL5_268000_1265000 0.008
R_VDD5_18039 METAL5_268000_1265000 METAL5_269000_1265000 0.004
R_VDD5_18040 METAL5_269000_1265000 METAL5_269000_1253000 0.048
R_VDD5_18041 METAL5_269000_1253000 METAL5_269000_1241000 0.048
R_VDD5_18042 METAL5_269000_1241000 METAL5_269000_1229000 0.048
R_VDD5_18043 METAL5_269000_1229000 METAL5_269000_1217000 0.048
R_VDD5_18044 METAL5_269000_1217000 METAL5_269000_1205000 0.048
R_VDD5_18045 METAL5_269000_1205000 METAL5_269000_1201000 0.016
R_VDD5_18046 METAL5_269000_1201000 METAL5_270000_1201000 0.004
R_VDD5_18047 METAL5_270000_1201000 METAL5_276000_1201000 0.024
R_VDD5_18048 METAL5_276000_1201000 METAL4_276000_1201000 0.1
R_VDD5_18049 METAL4_276000_1201000 METAL3_276000_1201000 0.1
R_VDD5_18050 METAL3_276000_1201000 METAL2_276000_1201000 0.1
R_VDD5_18051 METAL2_276000_1201000 METAL2_278000_1201000 0.016
R_VDD5_18052 METAL2_278000_1201000 METAL2_280000_1201000 0.016
R_VDD5_18053 METAL2_280000_1201000 METAL2_281000_1201000 0.008
R_VDD5_18054 METAL2_281000_1201000 METAL2_282000_1201000 0.008
R_VDD5_18055 METAL2_282000_1201000 METAL2_288000_1201000 0.048
R_VDD5_18056 METAL2_288000_1201000 METAL2_288000_1189000 0.096
R_VDD5_18057 METAL2_288000_1189000 METAL2_288000_1177000 0.096
R_VDD5_18058 METAL2_288000_1177000 METAL2_288000_1165000 0.096
R_VDD5_18059 METAL2_288000_1165000 METAL2_288000_1153000 0.096
R_VDD5_18060 METAL2_288000_1153000 METAL2_288000_1141000 0.096
R_VDD5_18061 METAL2_288000_1141000 METAL2_288000_1113000 0.224
R_VDD5_18062 METAL2_288000_1113000 METAL2_288000_1101000 0.096
R_VDD5_18063 METAL2_288000_1101000 METAL2_288000_1089000 0.096
R_VDD5_18064 METAL2_288000_1089000 METAL2_288000_1077000 0.096
R_VDD5_18065 METAL2_288000_1077000 METAL2_288000_1065000 0.096
R_VDD5_18066 METAL2_288000_1065000 METAL2_288000_1053000 0.096
R_VDD5_18067 METAL2_288000_1053000 METAL2_288000_1041000 0.096
R_VDD5_18068 METAL2_288000_1041000 METAL2_288000_1037000 0.032
R_VDD5_18069 METAL2_288000_1037000 METAL2_288000_1025000 0.096
R_VDD5_18070 METAL2_288000_1025000 METAL2_288000_1013000 0.096
R_VDD5_18071 METAL2_288000_1013000 METAL2_288000_1001000 0.096
R_VDD5_18072 METAL2_288000_1001000 METAL2_288000_989000 0.096
R_VDD5_18073 METAL2_288000_989000 METAL2_288000_977000 0.096
R_VDD5_18074 METAL2_288000_977000 METAL2_288000_965000 0.096
R_VDD5_18075 METAL2_288000_965000 METAL2_288000_953000 0.096
R_VDD5_18076 METAL2_288000_953000 METAL2_288000_941000 0.096
R_VDD5_18077 METAL2_288000_941000 METAL2_288000_929000 0.096
R_VDD5_18078 METAL2_288000_929000 METAL2_288000_917000 0.096
R_VDD5_18079 METAL2_288000_917000 METAL2_288000_913000 0.032
R_VDD5_18080 METAL2_288000_913000 METAL2_288000_905000 0.064
R_VDD5_18081 METAL2_288000_905000 METAL2_288000_901000 0.032
R_VDD5_18082 METAL2_288000_901000 METAL2_288000_893000 0.064
R_VDD5_18083 METAL2_288000_893000 METAL2_288000_889000 0.032
R_VDD5_18084 METAL2_288000_889000 METAL2_290000_889000 0.016
R_VDD5_18085 METAL2_290000_889000 METAL2_292000_889000 0.016
R_VDD5_18086 METAL2_292000_889000 METAL2_293000_889000 0.008
R_VDD5_18087 METAL2_293000_889000 METAL2_293000_881000 0.064
R_VDD5_18088 METAL2_293000_881000 METAL2_293000_877000 0.032
R_VDD5_18089 METAL2_293000_877000 METAL2_293000_869000 0.064
R_VDD5_18090 METAL2_293000_869000 METAL2_293000_865000 0.032
R_VDD5_18091 METAL2_293000_865000 METAL2_293000_857000 0.064
R_VDD5_18092 METAL2_293000_857000 METAL2_293000_853000 0.032
R_VDD5_18093 METAL2_293000_853000 METAL2_293000_845000 0.064
R_VDD5_18094 METAL2_293000_845000 METAL2_293000_841000 0.032
R_VDD5_18095 METAL2_293000_841000 METAL2_293000_829000 0.096
R_VDD5_18096 METAL2_293000_829000 METAL2_293000_817000 0.096
R_VDD5_18097 METAL2_293000_817000 METAL2_293000_805000 0.096
R_VDD5_18098 METAL2_293000_805000 METAL2_293000_793000 0.096
R_VDD5_18099 METAL2_293000_793000 METAL2_293000_781000 0.096
R_VDD5_18100 METAL2_293000_781000 METAL2_293000_769000 0.096
R_VDD5_18101 METAL2_293000_769000 METAL2_293000_757000 0.096
R_VDD5_18102 METAL2_293000_757000 METAL2_293000_729000 0.224
R_VDD5_18103 METAL2_293000_729000 METAL2_293000_717000 0.096
R_VDD5_18104 METAL2_293000_717000 METAL2_293000_707000 0.08
R_VDD5_18105 METAL2_293000_707000 METAL2_293000_705000 0.016
R_VDD5_18106 METAL2_293000_705000 METAL2_293000_693000 0.096
R_VDD5_18107 METAL2_293000_693000 METAL2_293000_681000 0.096
R_VDD5_18108 METAL2_293000_681000 METAL2_293000_669000 0.096
R_VDD5_18109 METAL2_293000_669000 METAL2_293000_657000 0.096
R_VDD5_18110 METAL2_293000_657000 METAL2_293000_625000 0.256
R_VDD5_18111 METAL2_293000_625000 METAL2_293000_613000 0.096
R_VDD5_18112 METAL2_293000_613000 METAL2_293000_601000 0.096
R_VDD5_18113 METAL2_293000_601000 METAL2_293000_589000 0.096
R_VDD5_18114 METAL2_293000_589000 METAL2_293000_577000 0.096
R_VDD5_18115 METAL2_293000_577000 METAL2_293000_565000 0.096
R_VDD5_18116 METAL2_293000_565000 METAL2_293000_553000 0.096
R_VDD5_18117 METAL2_293000_553000 METAL2_293000_541000 0.096
R_VDD5_18118 METAL2_293000_541000 METAL2_293000_529000 0.096
R_VDD5_18119 METAL2_293000_529000 METAL2_293000_517000 0.096
R_VDD5_18120 METAL2_293000_517000 METAL2_293000_513000 0.032
R_VDD5_18121 METAL2_293000_513000 METAL2_293000_505000 0.064
R_VDD5_18122 METAL2_293000_505000 METAL2_293000_501000 0.032
R_VDD5_18123 METAL2_293000_501000 METAL2_293000_493000 0.064
R_VDD5_18124 METAL2_293000_493000 METAL2_293000_489000 0.032
R_VDD5_18125 METAL2_293000_489000 METAL2_293000_481000 0.064
R_VDD5_18126 METAL2_293000_481000 METAL2_293000_477000 0.032
R_VDD5_18127 METAL2_293000_477000 METAL2_293000_469000 0.064
R_VDD5_18128 METAL2_293000_469000 METAL2_293000_465000 0.032
R_VDD5_18129 METAL2_293000_465000 METAL2_293000_453000 0.096
R_VDD5_18130 METAL2_293000_453000 METAL2_293000_441000 0.096
R_VDD5_18131 METAL2_293000_441000 METAL2_293000_429000 0.096
R_VDD5_18132 METAL2_293000_429000 METAL2_293000_417000 0.096
R_VDD5_18133 METAL2_293000_417000 METAL2_293000_405000 0.096
R_VDD5_18134 METAL2_293000_405000 METAL2_293000_401000 0.032
R_VDD5_18135 METAL2_293000_401000 METAL2_293000_393000 0.064
R_VDD5_18136 METAL2_293000_393000 METAL2_293000_389000 0.032
R_VDD5_18137 METAL2_293000_389000 METAL2_293000_381000 0.064
R_VDD5_18138 METAL2_293000_381000 METAL2_293000_377000 0.032
R_VDD5_18139 METAL2_293000_377000 METAL2_293000_365000 0.096
R_VDD5_18140 METAL2_293000_365000 METAL2_293000_353000 0.096
R_VDD5_18141 METAL2_293000_353000 METAL2_293000_341000 0.096
R_VDD5_18142 METAL2_293000_341000 METAL2_293000_329000 0.096
R_VDD5_18143 METAL2_293000_329000 METAL2_293000_317000 0.096
R_VDD5_18144 METAL2_293000_317000 METAL2_293000_313000 0.032
R_VDD5_18145 METAL2_293000_313000 METAL2_293000_305000 0.064
R_VDD5_18146 METAL2_293000_305000 METAL2_293000_301000 0.032
R_VDD5_18147 METAL2_293000_301000 METAL2_293000_293000 0.064
R_VDD5_18148 METAL2_293000_293000 METAL2_293000_289000 0.032
R_VDD5_18149 METAL2_293000_289000 METAL2_293000_281000 0.064
R_VDD5_18150 METAL2_293000_281000 METAL2_293000_277000 0.032
R_VDD5_18151 METAL2_293000_277000 METAL2_293000_269000 0.064
R_VDD5_18152 METAL2_293000_269000 METAL2_293000_265000 0.032
R_VDD5_18153 METAL2_293000_265000 METAL2_293000_257000 0.064
R_VDD5_18154 METAL2_293000_257000 METAL2_293000_253000 0.032
R_VDD5_18155 METAL2_293000_253000 METAL2_293000_245000 0.064
R_VDD5_18156 METAL2_293000_245000 METAL2_293000_241000 0.032
R_VDD5_18157 METAL2_293000_241000 METAL2_293000_233000 0.064
R_VDD5_18158 METAL2_293000_233000 METAL2_293000_229000 0.032
R_VDD5_18159 METAL2_293000_229000 METAL2_293000_221000 0.064
R_VDD5_18160 METAL2_293000_221000 METAL2_293000_217000 0.032
R_VDD5_18161 METAL2_293000_217000 METAL2_293000_205000 0.096
R_VDD5_18162 METAL2_293000_205000 METAL2_293000_201000 0.032
R_VDD5_18163 METAL2_293000_201000 METAL2_294000_201000 0.008
R_VDD5_18164 METAL2_294000_201000 METAL2_300000_201000 0.048
R_VDD5_18165 METAL2_300000_201000 METAL2_302000_201000 0.016
R_VDD5_18166 METAL2_302000_201000 METAL2_304000_201000 0.016
R_VDD5_18167 METAL2_304000_201000 METAL2_305000_201000 0.008
R_VDD5_18168 METAL2_305000_201000 METAL2_305000_193000 0.064
R_VDD5_18169 METAL2_305000_193000 METAL2_305000_189000 0.032
R_VDD5_18170 METAL2_305000_189000 METAL2_305000_181000 0.064
R_VDD5_18171 METAL2_305000_181000 METAL2_305000_177000 0.032
R_VDD5_18172 METAL2_305000_177000 METAL2_305000_169000 0.064
R_VDD5_18173 METAL2_305000_169000 METAL2_305000_165000 0.032
R_VDD5_18174 METAL2_305000_165000 METAL2_305000_157000 0.064
R_VDD5_18175 METAL2_305000_157000 METAL2_305000_153000 0.032
R_VDD5_18176 METAL2_305000_153000 METAL2_305000_145000 0.064
R_VDD5_18177 METAL2_305000_145000 METAL2_305000_141000 0.032
R_VDD5_18178 METAL2_305000_141000 METAL2_305000_133000 0.064
R_VDD5_18179 METAL2_305000_133000 METAL2_305000_129000 0.032
R_VDD5_18180 METAL2_305000_129000 METAL2_305000_128000 0.008
R_VDD5_18181 METAL2_305000_128000 METAL2_305000_121000 0.056
R_VDD5_18182 METAL2_305000_121000 METAL2_305000_117000 0.032
R_VDD5_18183 METAL2_305000_117000 METAL2_305000_116000 0.008
R_VDD5_18184 METAL2_305000_116000 METAL2_305000_109000 0.056
R_VDD5_18185 METAL2_305000_109000 METAL2_305000_105000 0.032
R_VDD5_18186 METAL2_305000_105000 METAL2_305000_104000 0.008
R_VDD5_18187 METAL2_305000_104000 METAL2_305000_97000 0.056
R_VDD5_18188 METAL2_305000_97000 METAL2_305000_93000 0.032
R_VDD5_18189 METAL2_305000_93000 METAL2_305000_92000 0.008
R_VDD5_18190 METAL2_305000_92000 METAL2_305000_81000 0.088
R_VDD5_18191 METAL2_305000_81000 METAL2_305000_80000 0.008
R_VDD5_18192 METAL2_305000_80000 METAL2_305000_69000 0.088
R_VDD5_18193 METAL2_305000_69000 METAL2_305000_68000 0.008
R_VDD5_18194 METAL2_305000_68000 METAL2_305000_57000 0.088
R_VDD5_18195 METAL2_305000_57000 METAL2_305000_56000 0.008
R_VDD5_18196 METAL2_305000_56000 METAL2_305000_45000 0.088
R_VDD5_18197 METAL2_305000_45000 METAL2_305000_44000 0.008
R_VDD5_18198 METAL2_305000_44000 METAL2_306000_44000 0.008
R_VDD5_18199 METAL2_306000_44000 METAL2_312000_44000 0.048
R_VDD5_18200 METAL2_312000_44000 METAL2_314000_44000 0.016
R_VDD5_18201 METAL2_314000_44000 METAL2_316000_44000 0.016
R_VDD5_18202 METAL2_316000_44000 METAL2_317000_44000 0.008
R_VDD5_18203 METAL2_317000_44000 METAL2_318000_44000 0.008
R_VDD5_18204 METAL2_318000_44000 METAL2_324000_44000 0.048
R_VDD5_18205 METAL2_324000_44000 METAL2_326000_44000 0.016
R_VDD5_18206 METAL2_326000_44000 METAL2_328000_44000 0.016
R_VDD5_18207 METAL2_328000_44000 METAL2_329000_44000 0.008
R_VDD5_18208 METAL2_329000_44000 METAL2_330000_44000 0.008
R_VDD5_18209 METAL2_330000_44000 METAL2_336000_44000 0.048
R_VDD5_18210 METAL2_336000_44000 METAL2_338000_44000 0.016
R_VDD5_18211 METAL2_338000_44000 METAL2_340000_44000 0.016
R_VDD5_18212 METAL2_340000_44000 METAL2_342000_44000 0.016
R_VDD5_18213 METAL2_342000_44000 METAL2_348000_44000 0.048
R_VDD5_18214 METAL2_348000_44000 METAL2_350000_44000 0.016
R_VDD5_18215 METAL2_350000_44000 METAL2_352000_44000 0.016
R_VDD5_18216 METAL2_352000_44000 METAL2_354000_44000 0.016
R_VDD5_18217 METAL2_354000_44000 METAL2_360000_44000 0.048
R_VDD5_18218 METAL2_360000_44000 METAL2_362000_44000 0.016
R_VDD5_18219 METAL2_362000_44000 METAL2_364000_44000 0.016
R_VDD5_18220 METAL2_364000_44000 METAL2_366000_44000 0.016
R_VDD5_18221 METAL2_366000_44000 METAL2_372000_44000 0.048
R_VDD5_18222 METAL2_372000_44000 METAL2_374000_44000 0.016
R_VDD5_18223 METAL2_374000_44000 METAL2_376000_44000 0.016
R_VDD5_18224 METAL2_376000_44000 METAL2_378000_44000 0.016
R_VDD5_18225 METAL2_378000_44000 METAL2_384000_44000 0.048
R_VDD5_18226 METAL2_384000_44000 METAL2_386000_44000 0.016
R_VDD5_18227 METAL2_386000_44000 METAL2_388000_44000 0.016
R_VDD5_18228 METAL2_388000_44000 METAL2_390000_44000 0.016
R_VDD5_18229 METAL2_390000_44000 METAL2_396000_44000 0.048
R_VDD5_18230 METAL2_396000_44000 METAL2_398000_44000 0.016
R_VDD5_18231 METAL2_398000_44000 METAL2_400000_44000 0.016
R_VDD5_18232 METAL2_400000_44000 METAL2_402000_44000 0.016
R_VDD5_18233 METAL2_402000_44000 METAL2_404000_44000 0.016
R_VDD5_18234 METAL2_404000_44000 METAL2_408000_44000 0.032
R_VDD5_18235 METAL2_408000_44000 METAL2_410000_44000 0.016
R_VDD5_18236 METAL2_410000_44000 METAL2_412000_44000 0.016
R_VDD5_18237 METAL2_412000_44000 METAL2_414000_44000 0.016
R_VDD5_18238 METAL2_414000_44000 METAL2_416000_44000 0.016
R_VDD5_18239 METAL2_416000_44000 METAL2_420000_44000 0.032
R_VDD5_18240 METAL2_420000_44000 METAL2_422000_44000 0.016
R_VDD5_18241 METAL2_422000_44000 METAL2_424000_44000 0.016
R_VDD5_18242 METAL2_424000_44000 METAL2_426000_44000 0.016
R_VDD5_18243 METAL2_426000_44000 METAL2_428000_44000 0.016
R_VDD5_18244 METAL2_428000_44000 METAL2_432000_44000 0.032
R_VDD5_18245 METAL2_432000_44000 METAL2_434000_44000 0.016
R_VDD5_18246 METAL2_434000_44000 METAL2_436000_44000 0.016
R_VDD5_18247 METAL2_436000_44000 METAL2_438000_44000 0.016
R_VDD5_18248 METAL2_438000_44000 METAL2_440000_44000 0.016
R_VDD5_18249 METAL2_440000_44000 METAL2_444000_44000 0.032
R_VDD5_18250 METAL2_444000_44000 METAL2_446000_44000 0.016
R_VDD5_18251 METAL2_446000_44000 METAL2_448000_44000 0.016
R_VDD5_18252 METAL2_448000_44000 METAL2_450000_44000 0.016
R_VDD5_18253 METAL2_450000_44000 METAL2_452000_44000 0.016
R_VDD5_18254 METAL2_452000_44000 METAL2_458000_44000 0.048
R_VDD5_18255 METAL2_458000_44000 METAL2_460000_44000 0.016
R_VDD5_18256 METAL2_460000_44000 METAL2_462000_44000 0.016
R_VDD5_18257 METAL2_462000_44000 METAL2_464000_44000 0.016
R_VDD5_18258 METAL2_464000_44000 METAL2_470000_44000 0.048
R_VDD5_18259 METAL2_470000_44000 METAL2_471000_44000 0.008
R_VDD5_18260 METAL2_471000_44000 METAL2_472000_44000 0.008
R_VDD5_18261 METAL2_472000_44000 METAL2_472000_33000 0.088
R_VDD5_18262 METAL2_472000_33000 METAL2_474000_33000 0.016
R_VDD5_18263 METAL2_474000_33000 METAL2_476000_33000 0.016
R_VDD5_18264 METAL2_476000_33000 METAL2_482000_33000 0.048
R_VDD5_18265 METAL2_482000_33000 METAL2_482000_32000 0.008
R_VDD5_18266 METAL2_482000_32000 METAL2_482000_21000 0.088
R_VDD5_18267 METAL2_482000_21000 METAL2_483000_21000 0.008
R_VDD5_18268 METAL2_483000_21000 METAL2_484000_21000 0.008
R_VDD5_18269 METAL2_484000_21000 METAL2_486000_21000 0.016
R_VDD5_18270 METAL2_486000_21000 METAL2_488000_21000 0.016
R_VDD5_18271 METAL2_488000_21000 METAL2_494000_21000 0.048
R_VDD5_18272 METAL2_494000_21000 METAL2_495000_21000 0.008
R_VDD5_18273 METAL2_495000_21000 METAL2_496000_21000 0.008
R_VDD5_18274 METAL2_496000_21000 METAL2_498000_21000 0.016
R_VDD5_18275 METAL2_498000_21000 METAL2_500000_21000 0.016
R_VDD5_18276 METAL2_500000_21000 METAL2_500000_20000 0.008
R_VDD5_18277 METAL2_500000_20000 METAL2_500000_9000 0.088
R_VDD5_18278 METAL2_500000_9000 METAL2_500000_8000 0.008
R_VDD5_18279 METAL5_257000_1177000 METAL4_257000_1177000 0.1
R_VDD5_18280 METAL4_257000_1177000 METAL3_257000_1177000 0.1
R_VDD5_18281 METAL3_257000_1177000 METAL3_258000_1177000 0.008
R_VDD5_18282 METAL3_258000_1177000 METAL3_264000_1177000 0.048
R_VDD5_18283 METAL3_264000_1177000 METAL3_266000_1177000 0.016
R_VDD5_18284 METAL3_266000_1177000 METAL3_268000_1177000 0.016
R_VDD5_18285 METAL3_268000_1177000 METAL3_269000_1177000 0.008
R_VDD5_18286 METAL3_269000_1177000 METAL3_269000_1165000 0.096
R_VDD5_18287 METAL3_269000_1165000 METAL3_269000_1153000 0.096
R_VDD5_18288 METAL3_269000_1153000 METAL3_269000_1141000 0.096
R_VDD5_18289 METAL3_269000_1141000 METAL3_269000_1113000 0.224
R_VDD5_18290 METAL3_269000_1113000 METAL3_269000_1101000 0.096
R_VDD5_18291 METAL3_269000_1101000 METAL3_269000_1089000 0.096
R_VDD5_18292 METAL3_269000_1089000 METAL3_269000_1077000 0.096
R_VDD5_18293 METAL3_269000_1077000 METAL3_269000_1065000 0.096
R_VDD5_18294 METAL3_269000_1065000 METAL3_269000_1053000 0.096
R_VDD5_18295 METAL3_269000_1053000 METAL3_269000_1041000 0.096
R_VDD5_18296 METAL3_269000_1041000 METAL3_269000_1037000 0.032
R_VDD5_18297 METAL3_269000_1037000 METAL3_269000_1025000 0.096
R_VDD5_18298 METAL3_269000_1025000 METAL3_269000_1013000 0.096
R_VDD5_18299 METAL3_269000_1013000 METAL3_269000_1001000 0.096
R_VDD5_18300 METAL3_269000_1001000 METAL3_269000_989000 0.096
R_VDD5_18301 METAL3_269000_989000 METAL3_269000_977000 0.096
R_VDD5_18302 METAL3_269000_977000 METAL3_269000_965000 0.096
R_VDD5_18303 METAL3_269000_965000 METAL3_269000_953000 0.096
R_VDD5_18304 METAL3_269000_953000 METAL3_269000_941000 0.096
R_VDD5_18305 METAL3_269000_941000 METAL3_269000_929000 0.096
R_VDD5_18306 METAL3_269000_929000 METAL3_269000_917000 0.096
R_VDD5_18307 METAL3_269000_917000 METAL3_269000_913000 0.032
R_VDD5_18308 METAL3_269000_913000 METAL3_269000_905000 0.064
R_VDD5_18309 METAL3_269000_905000 METAL3_269000_901000 0.032
R_VDD5_18310 METAL3_269000_901000 METAL3_269000_893000 0.064
R_VDD5_18311 METAL3_269000_893000 METAL3_269000_889000 0.032
R_VDD5_18312 METAL3_269000_889000 METAL3_270000_889000 0.008
R_VDD5_18313 METAL3_270000_889000 METAL3_276000_889000 0.048
R_VDD5_18314 METAL3_276000_889000 METAL3_278000_889000 0.016
R_VDD5_18315 METAL3_278000_889000 METAL3_280000_889000 0.016
R_VDD5_18316 METAL3_280000_889000 METAL3_281000_889000 0.008
R_VDD5_18317 METAL3_281000_889000 METAL3_281000_881000 0.064
R_VDD5_18318 METAL3_281000_881000 METAL3_281000_877000 0.032
R_VDD5_18319 METAL3_281000_877000 METAL3_281000_869000 0.064
R_VDD5_18320 METAL3_281000_869000 METAL3_281000_865000 0.032
R_VDD5_18321 METAL3_281000_865000 METAL3_281000_857000 0.064
R_VDD5_18322 METAL3_281000_857000 METAL3_281000_853000 0.032
R_VDD5_18323 METAL3_281000_853000 METAL3_281000_845000 0.064
R_VDD5_18324 METAL3_281000_845000 METAL3_281000_841000 0.032
R_VDD5_18325 METAL3_281000_841000 METAL3_281000_829000 0.096
R_VDD5_18326 METAL3_281000_829000 METAL3_281000_817000 0.096
R_VDD5_18327 METAL3_281000_817000 METAL3_281000_805000 0.096
R_VDD5_18328 METAL3_281000_805000 METAL3_281000_793000 0.096
R_VDD5_18329 METAL3_281000_793000 METAL3_281000_781000 0.096
R_VDD5_18330 METAL3_281000_781000 METAL3_281000_769000 0.096
R_VDD5_18331 METAL3_281000_769000 METAL3_281000_757000 0.096
R_VDD5_18332 METAL3_281000_757000 METAL3_281000_729000 0.224
R_VDD5_18333 METAL3_281000_729000 METAL3_281000_717000 0.096
R_VDD5_18334 METAL3_281000_717000 METAL3_281000_707000 0.08
R_VDD5_18335 METAL3_281000_707000 METAL3_281000_705000 0.016
R_VDD5_18336 METAL3_281000_705000 METAL3_281000_693000 0.096
R_VDD5_18337 METAL3_281000_693000 METAL3_281000_681000 0.096
R_VDD5_18338 METAL3_281000_681000 METAL3_281000_669000 0.096
R_VDD5_18339 METAL3_281000_669000 METAL3_281000_657000 0.096
R_VDD5_18340 METAL3_281000_657000 METAL3_281000_625000 0.256
R_VDD5_18341 METAL3_281000_625000 METAL3_281000_613000 0.096
R_VDD5_18342 METAL3_281000_613000 METAL3_282000_613000 0.008
R_VDD5_18343 METAL3_282000_613000 METAL3_288000_613000 0.048
R_VDD5_18344 METAL3_288000_613000 METAL3_290000_613000 0.016
R_VDD5_18345 METAL3_290000_613000 METAL3_292000_613000 0.016
R_VDD5_18346 METAL3_292000_613000 METAL3_293000_613000 0.008
R_VDD5_18347 METAL3_293000_613000 METAL3_294000_613000 0.008
R_VDD5_18348 METAL3_294000_613000 METAL3_300000_613000 0.048
R_VDD5_18349 METAL3_300000_613000 METAL3_302000_613000 0.016
R_VDD5_18350 METAL3_302000_613000 METAL3_304000_613000 0.016
R_VDD5_18351 METAL3_304000_613000 METAL3_305000_613000 0.008
R_VDD5_18352 METAL3_305000_613000 METAL2_305000_613000 0.1
R_VDD5_18353 METAL2_305000_613000 METAL2_305000_601000 0.096
R_VDD5_18354 METAL2_305000_601000 METAL2_305000_589000 0.096
R_VDD5_18355 METAL2_305000_589000 METAL2_305000_577000 0.096
R_VDD5_18356 METAL2_305000_577000 METAL2_305000_565000 0.096
R_VDD5_18357 METAL2_305000_565000 METAL2_305000_553000 0.096
R_VDD5_18358 METAL2_305000_553000 METAL2_305000_541000 0.096
R_VDD5_18359 METAL2_305000_541000 METAL2_305000_529000 0.096
R_VDD5_18360 METAL2_305000_529000 METAL2_305000_517000 0.096
R_VDD5_18361 METAL2_305000_517000 METAL2_305000_513000 0.032
R_VDD5_18362 METAL2_305000_513000 METAL2_305000_505000 0.064
R_VDD5_18363 METAL2_305000_505000 METAL2_305000_501000 0.032
R_VDD5_18364 METAL2_305000_501000 METAL2_305000_493000 0.064
R_VDD5_18365 METAL2_305000_493000 METAL2_305000_489000 0.032
R_VDD5_18366 METAL2_305000_489000 METAL2_305000_481000 0.064
R_VDD5_18367 METAL2_305000_481000 METAL2_305000_477000 0.032
R_VDD5_18368 METAL2_305000_477000 METAL2_305000_469000 0.064
R_VDD5_18369 METAL2_305000_469000 METAL2_305000_465000 0.032
R_VDD5_18370 METAL2_305000_465000 METAL2_305000_453000 0.096
R_VDD5_18371 METAL2_305000_453000 METAL2_305000_441000 0.096
R_VDD5_18372 METAL2_305000_441000 METAL2_305000_429000 0.096
R_VDD5_18373 METAL2_305000_429000 METAL2_305000_417000 0.096
R_VDD5_18374 METAL2_305000_417000 METAL2_305000_405000 0.096
R_VDD5_18375 METAL2_305000_405000 METAL2_305000_401000 0.032
R_VDD5_18376 METAL2_305000_401000 METAL2_305000_393000 0.064
R_VDD5_18377 METAL2_305000_393000 METAL2_305000_389000 0.032
R_VDD5_18378 METAL2_305000_389000 METAL2_305000_381000 0.064
R_VDD5_18379 METAL2_305000_381000 METAL2_305000_377000 0.032
R_VDD5_18380 METAL2_305000_377000 METAL2_305000_365000 0.096
R_VDD5_18381 METAL2_305000_365000 METAL2_305000_353000 0.096
R_VDD5_18382 METAL2_305000_353000 METAL2_305000_341000 0.096
R_VDD5_18383 METAL2_305000_341000 METAL2_305000_329000 0.096
R_VDD5_18384 METAL2_305000_329000 METAL2_305000_317000 0.096
R_VDD5_18385 METAL2_305000_317000 METAL2_305000_313000 0.032
R_VDD5_18386 METAL2_305000_313000 METAL2_305000_305000 0.064
R_VDD5_18387 METAL2_305000_305000 METAL2_305000_301000 0.032
R_VDD5_18388 METAL2_305000_301000 METAL2_305000_293000 0.064
R_VDD5_18389 METAL2_305000_293000 METAL2_305000_289000 0.032
R_VDD5_18390 METAL2_305000_289000 METAL2_305000_281000 0.064
R_VDD5_18391 METAL2_305000_281000 METAL2_305000_277000 0.032
R_VDD5_18392 METAL2_305000_277000 METAL2_305000_269000 0.064
R_VDD5_18393 METAL2_305000_269000 METAL2_305000_265000 0.032
R_VDD5_18394 METAL2_305000_265000 METAL2_305000_257000 0.064
R_VDD5_18395 METAL2_305000_257000 METAL2_305000_253000 0.032
R_VDD5_18396 METAL2_305000_253000 METAL2_305000_245000 0.064
R_VDD5_18397 METAL2_305000_245000 METAL2_305000_241000 0.032
R_VDD5_18398 METAL2_305000_241000 METAL2_305000_233000 0.064
R_VDD5_18399 METAL2_305000_233000 METAL2_305000_229000 0.032
R_VDD5_18400 METAL2_305000_229000 METAL2_305000_221000 0.064
R_VDD5_18401 METAL2_305000_221000 METAL2_305000_217000 0.032
R_VDD5_18402 METAL2_305000_217000 METAL2_305000_213000 0.032
R_VDD5_18403 METAL2_305000_213000 METAL2_306000_213000 0.008
R_VDD5_18404 METAL2_306000_213000 METAL2_312000_213000 0.048
R_VDD5_18405 METAL2_312000_213000 METAL2_314000_213000 0.016
R_VDD5_18406 METAL2_314000_213000 METAL2_316000_213000 0.016
R_VDD5_18407 METAL2_316000_213000 METAL2_317000_213000 0.008
R_VDD5_18408 METAL2_317000_213000 METAL2_317000_205000 0.064
R_VDD5_18409 METAL2_317000_205000 METAL2_317000_201000 0.032
R_VDD5_18410 METAL2_317000_201000 METAL2_317000_193000 0.064
R_VDD5_18411 METAL2_317000_193000 METAL2_317000_189000 0.032
R_VDD5_18412 METAL2_317000_189000 METAL2_317000_181000 0.064
R_VDD5_18413 METAL2_317000_181000 METAL2_317000_177000 0.032
R_VDD5_18414 METAL2_317000_177000 METAL2_317000_169000 0.064
R_VDD5_18415 METAL2_317000_169000 METAL2_317000_165000 0.032
R_VDD5_18416 METAL2_317000_165000 METAL2_317000_157000 0.064
R_VDD5_18417 METAL2_317000_157000 METAL2_317000_153000 0.032
R_VDD5_18418 METAL2_317000_153000 METAL2_317000_145000 0.064
R_VDD5_18419 METAL2_317000_145000 METAL2_317000_141000 0.032
R_VDD5_18420 METAL2_317000_141000 METAL2_317000_133000 0.064
R_VDD5_18421 METAL2_317000_133000 METAL2_317000_129000 0.032
R_VDD5_18422 METAL2_317000_129000 METAL2_317000_128000 0.008
R_VDD5_18423 METAL2_317000_128000 METAL2_317000_121000 0.056
R_VDD5_18424 METAL2_317000_121000 METAL2_317000_117000 0.032
R_VDD5_18425 METAL2_317000_117000 METAL2_317000_116000 0.008
R_VDD5_18426 METAL2_317000_116000 METAL2_317000_109000 0.056
R_VDD5_18427 METAL2_317000_109000 METAL2_317000_105000 0.032
R_VDD5_18428 METAL2_317000_105000 METAL2_317000_104000 0.008
R_VDD5_18429 METAL2_317000_104000 METAL2_317000_97000 0.056
R_VDD5_18430 METAL2_317000_97000 METAL2_317000_93000 0.032
R_VDD5_18431 METAL2_317000_93000 METAL2_317000_92000 0.008
R_VDD5_18432 METAL2_317000_92000 METAL2_317000_81000 0.088
R_VDD5_18433 METAL2_317000_81000 METAL2_317000_80000 0.008
R_VDD5_18434 METAL2_317000_80000 METAL2_317000_69000 0.088
R_VDD5_18435 METAL2_317000_69000 METAL2_317000_68000 0.008
R_VDD5_18436 METAL2_317000_68000 METAL2_318000_68000 0.008
R_VDD5_18437 METAL2_318000_68000 METAL2_324000_68000 0.048
R_VDD5_18438 METAL2_324000_68000 METAL2_326000_68000 0.016
R_VDD5_18439 METAL2_326000_68000 METAL2_328000_68000 0.016
R_VDD5_18440 METAL2_328000_68000 METAL2_329000_68000 0.008
R_VDD5_18441 METAL2_329000_68000 METAL2_330000_68000 0.008
R_VDD5_18442 METAL2_330000_68000 METAL2_336000_68000 0.048
R_VDD5_18443 METAL2_336000_68000 METAL2_338000_68000 0.016
R_VDD5_18444 METAL2_338000_68000 METAL2_340000_68000 0.016
R_VDD5_18445 METAL2_340000_68000 METAL2_342000_68000 0.016
R_VDD5_18446 METAL2_342000_68000 METAL2_348000_68000 0.048
R_VDD5_18447 METAL2_348000_68000 METAL2_350000_68000 0.016
R_VDD5_18448 METAL2_350000_68000 METAL2_352000_68000 0.016
R_VDD5_18449 METAL2_352000_68000 METAL2_354000_68000 0.016
R_VDD5_18450 METAL2_354000_68000 METAL2_360000_68000 0.048
R_VDD5_18451 METAL2_360000_68000 METAL2_362000_68000 0.016
R_VDD5_18452 METAL2_362000_68000 METAL2_364000_68000 0.016
R_VDD5_18453 METAL2_364000_68000 METAL2_366000_68000 0.016
R_VDD5_18454 METAL2_366000_68000 METAL2_372000_68000 0.048
R_VDD5_18455 METAL2_372000_68000 METAL2_374000_68000 0.016
R_VDD5_18456 METAL2_374000_68000 METAL2_376000_68000 0.016
R_VDD5_18457 METAL2_376000_68000 METAL2_378000_68000 0.016
R_VDD5_18458 METAL2_378000_68000 METAL2_384000_68000 0.048
R_VDD5_18459 METAL2_384000_68000 METAL2_386000_68000 0.016
R_VDD5_18460 METAL2_386000_68000 METAL2_388000_68000 0.016
R_VDD5_18461 METAL2_388000_68000 METAL2_390000_68000 0.016
R_VDD5_18462 METAL2_390000_68000 METAL2_396000_68000 0.048
R_VDD5_18463 METAL2_396000_68000 METAL2_398000_68000 0.016
R_VDD5_18464 METAL2_398000_68000 METAL2_400000_68000 0.016
R_VDD5_18465 METAL2_400000_68000 METAL2_402000_68000 0.016
R_VDD5_18466 METAL2_402000_68000 METAL2_404000_68000 0.016
R_VDD5_18467 METAL2_404000_68000 METAL2_408000_68000 0.032
R_VDD5_18468 METAL2_408000_68000 METAL2_410000_68000 0.016
R_VDD5_18469 METAL2_410000_68000 METAL2_412000_68000 0.016
R_VDD5_18470 METAL2_412000_68000 METAL2_414000_68000 0.016
R_VDD5_18471 METAL2_414000_68000 METAL2_416000_68000 0.016
R_VDD5_18472 METAL2_416000_68000 METAL2_420000_68000 0.032
R_VDD5_18473 METAL2_420000_68000 METAL2_422000_68000 0.016
R_VDD5_18474 METAL2_422000_68000 METAL2_424000_68000 0.016
R_VDD5_18475 METAL2_424000_68000 METAL2_426000_68000 0.016
R_VDD5_18476 METAL2_426000_68000 METAL2_428000_68000 0.016
R_VDD5_18477 METAL2_428000_68000 METAL2_432000_68000 0.032
R_VDD5_18478 METAL2_432000_68000 METAL2_434000_68000 0.016
R_VDD5_18479 METAL2_434000_68000 METAL2_436000_68000 0.016
R_VDD5_18480 METAL2_436000_68000 METAL2_438000_68000 0.016
R_VDD5_18481 METAL2_438000_68000 METAL2_440000_68000 0.016
R_VDD5_18482 METAL2_440000_68000 METAL2_444000_68000 0.032
R_VDD5_18483 METAL2_444000_68000 METAL2_446000_68000 0.016
R_VDD5_18484 METAL2_446000_68000 METAL2_448000_68000 0.016
R_VDD5_18485 METAL2_448000_68000 METAL2_450000_68000 0.016
R_VDD5_18486 METAL2_450000_68000 METAL2_452000_68000 0.016
R_VDD5_18487 METAL2_452000_68000 METAL2_458000_68000 0.048
R_VDD5_18488 METAL2_458000_68000 METAL2_460000_68000 0.016
R_VDD5_18489 METAL2_460000_68000 METAL2_462000_68000 0.016
R_VDD5_18490 METAL2_462000_68000 METAL2_464000_68000 0.016
R_VDD5_18491 METAL2_464000_68000 METAL2_470000_68000 0.048
R_VDD5_18492 METAL2_470000_68000 METAL2_471000_68000 0.008
R_VDD5_18493 METAL2_471000_68000 METAL2_472000_68000 0.008
R_VDD5_18494 METAL2_472000_68000 METAL2_474000_68000 0.016
R_VDD5_18495 METAL2_474000_68000 METAL2_476000_68000 0.016
R_VDD5_18496 METAL2_476000_68000 METAL2_482000_68000 0.048
R_VDD5_18497 METAL2_482000_68000 METAL2_483000_68000 0.008
R_VDD5_18498 METAL2_483000_68000 METAL2_484000_68000 0.008
R_VDD5_18499 METAL2_484000_68000 METAL2_486000_68000 0.016
R_VDD5_18500 METAL2_486000_68000 METAL2_488000_68000 0.016
R_VDD5_18501 METAL2_488000_68000 METAL2_494000_68000 0.048
R_VDD5_18502 METAL2_494000_68000 METAL2_495000_68000 0.008
R_VDD5_18503 METAL2_495000_68000 METAL2_496000_68000 0.008
R_VDD5_18504 METAL2_496000_68000 METAL2_498000_68000 0.016
R_VDD5_18505 METAL2_498000_68000 METAL2_500000_68000 0.016
R_VDD5_18506 METAL2_500000_68000 METAL2_506000_68000 0.048
R_VDD5_18507 METAL2_506000_68000 METAL2_507000_68000 0.008
R_VDD5_18508 METAL2_507000_68000 METAL2_507000_57000 0.088
R_VDD5_18509 METAL2_507000_57000 METAL2_507000_56000 0.008
R_VDD5_18510 METAL2_507000_56000 METAL2_507000_45000 0.088
R_VDD5_18511 METAL2_507000_45000 METAL2_507000_44000 0.008
R_VDD5_18512 METAL2_507000_44000 METAL2_507000_33000 0.088
R_VDD5_18513 METAL2_507000_33000 METAL2_508000_33000 0.008
R_VDD5_18514 METAL2_508000_33000 METAL2_510000_33000 0.016
R_VDD5_18515 METAL2_510000_33000 METAL2_512000_33000 0.016
R_VDD5_18516 METAL2_512000_33000 METAL2_512000_32000 0.008
R_VDD5_18517 METAL2_512000_32000 METAL2_512000_21000 0.088
R_VDD5_18518 METAL2_512000_21000 METAL2_512000_20000 0.008
R_VDD5_18519 METAL2_512000_20000 METAL2_512000_9000 0.088
R_VDD5_18520 METAL2_512000_9000 METAL2_512000_8000 0.008
R_VDD5_18521 METAL2_512000_8000 METAL2_510000_8000 0.016
R_VDD5_18522 METAL2_510000_8000 METAL2_508000_8000 0.016
R_VDD5_18523 METAL2_508000_8000 METAL2_507000_8000 0.008
R_VDD5_18524 METAL2_507000_8000 METAL2_506000_8000 0.008
R_VDD5_18525 METAL2_506000_8000 METAL2_500000_8000 0.048
R_VDD5_18526 METAL6_269000_905000 METAL5_269000_905000 0.1
R_VDD5_18527 METAL5_269000_905000 METAL5_269000_901000 0.016
R_VDD5_18528 METAL5_269000_901000 METAL5_268000_901000 0.004
R_VDD5_18529 METAL5_268000_901000 METAL5_266000_901000 0.008
R_VDD5_18530 METAL5_266000_901000 METAL5_264000_901000 0.008
R_VDD5_18531 METAL5_264000_901000 METAL5_258000_901000 0.024
R_VDD5_18532 METAL5_258000_901000 METAL5_257000_901000 0.004
R_VDD5_18533 METAL5_257000_901000 METAL5_257000_893000 0.032
R_VDD5_18534 METAL5_257000_893000 METAL5_257000_889000 0.016
R_VDD5_18535 METAL5_257000_889000 METAL4_257000_889000 0.1
R_VDD5_18536 METAL4_257000_889000 METAL3_257000_889000 0.1
R_VDD5_18537 METAL3_257000_889000 METAL2_257000_889000 0.1
R_VDD5_18538 METAL2_257000_889000 METAL1_257000_889000 0.1
R_VDD5_18539 METAL1_257000_889000 METAL1_257000_881000 0.064
R_VDD5_18540 METAL1_257000_881000 METAL1_257000_877000 0.032
R_VDD5_18541 METAL1_257000_877000 METAL1_258000_877000 0.008
R_VDD5_18542 METAL1_258000_877000 METAL1_264000_877000 0.048
R_VDD5_18543 METAL1_264000_877000 METAL1_266000_877000 0.016
R_VDD5_18544 METAL1_266000_877000 METAL1_268000_877000 0.016
R_VDD5_18545 METAL1_268000_877000 METAL1_269000_877000 0.008
R_VDD5_18546 METAL1_269000_877000 METAL1_269000_869000 0.064
R_VDD5_18547 METAL1_269000_869000 METAL1_269000_865000 0.032
R_VDD5_18548 METAL1_269000_865000 METAL1_269000_857000 0.064
R_VDD5_18549 METAL1_269000_857000 METAL1_269000_853000 0.032
R_VDD5_18550 METAL1_269000_853000 METAL1_269000_845000 0.064
R_VDD5_18551 METAL1_269000_845000 METAL1_269000_841000 0.032
R_VDD5_18552 METAL1_269000_841000 METAL1_269000_829000 0.096
R_VDD5_18553 METAL1_269000_829000 METAL1_269000_817000 0.096
R_VDD5_18554 METAL1_269000_817000 METAL1_269000_805000 0.096
R_VDD5_18555 METAL1_269000_805000 METAL1_269000_793000 0.096
R_VDD5_18556 METAL1_269000_793000 METAL1_269000_781000 0.096
R_VDD5_18557 METAL1_269000_781000 METAL1_269000_769000 0.096
R_VDD5_18558 METAL1_269000_769000 METAL1_269000_757000 0.096
R_VDD5_18559 METAL1_269000_757000 METAL1_269000_729000 0.224
R_VDD5_18560 METAL1_269000_729000 METAL1_269000_717000 0.096
R_VDD5_18561 METAL1_269000_717000 METAL1_269000_707000 0.08
R_VDD5_18562 METAL1_269000_707000 METAL1_269000_705000 0.016
R_VDD5_18563 METAL1_269000_705000 METAL1_269000_693000 0.096
R_VDD5_18564 METAL1_269000_693000 METAL1_269000_681000 0.096
R_VDD5_18565 METAL1_269000_681000 METAL1_269000_669000 0.096
R_VDD5_18566 METAL1_269000_669000 METAL1_269000_657000 0.096
R_VDD5_18567 METAL1_269000_657000 METAL1_269000_625000 0.256
R_VDD5_18568 METAL1_269000_625000 METAL1_269000_613000 0.096
R_VDD5_18569 METAL1_269000_613000 METAL1_269000_601000 0.096
R_VDD5_18570 METAL1_269000_601000 METAL1_269000_589000 0.096
R_VDD5_18571 METAL1_269000_589000 METAL1_269000_577000 0.096
R_VDD5_18572 METAL1_269000_577000 METAL1_269000_565000 0.096
R_VDD5_18573 METAL1_269000_565000 METAL1_269000_553000 0.096
R_VDD5_18574 METAL1_269000_553000 METAL1_269000_541000 0.096
R_VDD5_18575 METAL1_269000_541000 METAL1_269000_529000 0.096
R_VDD5_18576 METAL1_269000_529000 METAL1_269000_517000 0.096
R_VDD5_18577 METAL1_269000_517000 METAL1_269000_513000 0.032
R_VDD5_18578 METAL1_269000_513000 METAL1_269000_505000 0.064
R_VDD5_18579 METAL1_269000_505000 METAL1_269000_501000 0.032
R_VDD5_18580 METAL1_269000_501000 METAL1_269000_493000 0.064
R_VDD5_18581 METAL1_269000_493000 METAL1_269000_489000 0.032
R_VDD5_18582 METAL1_269000_489000 METAL1_270000_489000 0.008
R_VDD5_18583 METAL1_270000_489000 METAL1_276000_489000 0.048
R_VDD5_18584 METAL1_276000_489000 METAL1_278000_489000 0.016
R_VDD5_18585 METAL1_278000_489000 METAL1_280000_489000 0.016
R_VDD5_18586 METAL1_280000_489000 METAL1_281000_489000 0.008
R_VDD5_18587 METAL1_281000_489000 METAL1_281000_481000 0.064
R_VDD5_18588 METAL1_281000_481000 METAL1_281000_477000 0.032
R_VDD5_18589 METAL1_281000_477000 METAL1_281000_469000 0.064
R_VDD5_18590 METAL1_281000_469000 METAL1_281000_465000 0.032
R_VDD5_18591 METAL1_281000_465000 METAL1_281000_453000 0.096
R_VDD5_18592 METAL1_281000_453000 METAL1_281000_441000 0.096
R_VDD5_18593 METAL1_281000_441000 METAL1_281000_429000 0.096
R_VDD5_18594 METAL1_281000_429000 METAL1_281000_417000 0.096
R_VDD5_18595 METAL1_281000_417000 METAL1_281000_405000 0.096
R_VDD5_18596 METAL1_281000_405000 METAL1_281000_401000 0.032
R_VDD5_18597 METAL1_281000_401000 METAL1_281000_393000 0.064
R_VDD5_18598 METAL1_281000_393000 METAL1_281000_389000 0.032
R_VDD5_18599 METAL1_281000_389000 METAL1_281000_381000 0.064
R_VDD5_18600 METAL1_281000_381000 METAL1_281000_377000 0.032
R_VDD5_18601 METAL1_281000_377000 METAL1_281000_365000 0.096
R_VDD5_18602 METAL1_281000_365000 METAL1_281000_353000 0.096
R_VDD5_18603 METAL1_281000_353000 METAL1_281000_341000 0.096
R_VDD5_18604 METAL1_281000_341000 METAL1_281000_329000 0.096
R_VDD5_18605 METAL1_281000_329000 METAL1_281000_317000 0.096
R_VDD5_18606 METAL1_281000_317000 METAL1_281000_313000 0.032
R_VDD5_18607 METAL1_281000_313000 METAL1_281000_305000 0.064
R_VDD5_18608 METAL1_281000_305000 METAL1_281000_301000 0.032
R_VDD5_18609 METAL1_281000_301000 METAL1_281000_293000 0.064
R_VDD5_18610 METAL1_281000_293000 METAL1_281000_289000 0.032
R_VDD5_18611 METAL1_281000_289000 METAL1_281000_281000 0.064
R_VDD5_18612 METAL1_281000_281000 METAL1_281000_277000 0.032
R_VDD5_18613 METAL1_281000_277000 METAL1_281000_269000 0.064
R_VDD5_18614 METAL1_281000_269000 METAL1_281000_265000 0.032
R_VDD5_18615 METAL1_281000_265000 METAL1_281000_257000 0.064
R_VDD5_18616 METAL1_281000_257000 METAL1_281000_253000 0.032
R_VDD5_18617 METAL1_281000_253000 METAL1_281000_245000 0.064
R_VDD5_18618 METAL1_281000_245000 METAL1_281000_241000 0.032
R_VDD5_18619 METAL1_281000_241000 METAL1_281000_233000 0.064
R_VDD5_18620 METAL1_281000_233000 METAL1_281000_229000 0.032
R_VDD5_18621 METAL1_281000_229000 METAL1_281000_225000 0.032
R_VDD5_18622 METAL1_281000_225000 METAL1_281000_221000 0.032
R_VDD5_18623 METAL1_281000_221000 METAL1_281000_217000 0.032
R_VDD5_18624 METAL1_281000_217000 METAL1_281000_213000 0.032
R_VDD5_18625 METAL1_281000_213000 METAL1_281000_205000 0.064
R_VDD5_18626 METAL1_281000_205000 METAL1_281000_201000 0.032
R_VDD5_18627 METAL1_281000_201000 METAL1_281000_193000 0.064
R_VDD5_18628 METAL1_281000_193000 METAL1_281000_189000 0.032
R_VDD5_18629 METAL1_281000_189000 METAL1_281000_181000 0.064
R_VDD5_18630 METAL1_281000_181000 METAL1_281000_177000 0.032
R_VDD5_18631 METAL1_281000_177000 METAL1_281000_169000 0.064
R_VDD5_18632 METAL1_281000_169000 METAL1_281000_165000 0.032
R_VDD5_18633 METAL1_281000_165000 METAL1_281000_157000 0.064
R_VDD5_18634 METAL1_281000_157000 METAL1_281000_153000 0.032
R_VDD5_18635 METAL1_281000_153000 METAL1_281000_145000 0.064
R_VDD5_18636 METAL1_281000_145000 METAL1_281000_141000 0.032
R_VDD5_18637 METAL1_281000_141000 METAL1_281000_133000 0.064
R_VDD5_18638 METAL1_281000_133000 METAL1_281000_129000 0.032
R_VDD5_18639 METAL1_281000_129000 METAL1_281000_128000 0.008
R_VDD5_18640 METAL1_281000_128000 METAL1_281000_121000 0.056
R_VDD5_18641 METAL1_281000_121000 METAL1_281000_117000 0.032
R_VDD5_18642 METAL1_281000_117000 METAL1_281000_116000 0.008
R_VDD5_18643 METAL1_281000_116000 METAL1_281000_109000 0.056
R_VDD5_18644 METAL1_281000_109000 METAL1_281000_105000 0.032
R_VDD5_18645 METAL1_281000_105000 METAL1_281000_104000 0.008
R_VDD5_18646 METAL1_281000_104000 METAL1_281000_97000 0.056
R_VDD5_18647 METAL1_281000_97000 METAL1_281000_93000 0.032
R_VDD5_18648 METAL1_281000_93000 METAL1_281000_92000 0.008
R_VDD5_18649 METAL1_281000_92000 METAL1_281000_81000 0.088
R_VDD5_18650 METAL1_281000_81000 METAL1_281000_80000 0.008
R_VDD5_18651 METAL1_281000_80000 METAL1_282000_80000 0.008
R_VDD5_18652 METAL1_282000_80000 METAL1_288000_80000 0.048
R_VDD5_18653 METAL1_288000_80000 METAL1_290000_80000 0.016
R_VDD5_18654 METAL1_290000_80000 METAL1_292000_80000 0.016
R_VDD5_18655 METAL1_292000_80000 METAL1_293000_80000 0.008
R_VDD5_18656 METAL1_293000_80000 METAL1_294000_80000 0.008
R_VDD5_18657 METAL1_294000_80000 METAL1_300000_80000 0.048
R_VDD5_18658 METAL1_300000_80000 METAL1_302000_80000 0.016
R_VDD5_18659 METAL1_302000_80000 METAL1_304000_80000 0.016
R_VDD5_18660 METAL1_304000_80000 METAL1_305000_80000 0.008
R_VDD5_18661 METAL1_305000_80000 METAL1_306000_80000 0.008
R_VDD5_18662 METAL1_306000_80000 METAL1_312000_80000 0.048
R_VDD5_18663 METAL1_312000_80000 METAL1_314000_80000 0.016
R_VDD5_18664 METAL1_314000_80000 METAL1_316000_80000 0.016
R_VDD5_18665 METAL1_316000_80000 METAL1_317000_80000 0.008
R_VDD5_18666 METAL1_317000_80000 METAL1_318000_80000 0.008
R_VDD5_18667 METAL1_318000_80000 METAL1_324000_80000 0.048
R_VDD5_18668 METAL1_324000_80000 METAL1_326000_80000 0.016
R_VDD5_18669 METAL1_326000_80000 METAL1_328000_80000 0.016
R_VDD5_18670 METAL1_328000_80000 METAL1_329000_80000 0.008
R_VDD5_18671 METAL1_329000_80000 METAL2_329000_80000 0.1
R_VDD5_18672 METAL2_329000_80000 METAL2_330000_80000 0.008
R_VDD5_18673 METAL2_330000_80000 METAL2_336000_80000 0.048
R_VDD5_18674 METAL2_336000_80000 METAL2_338000_80000 0.016
R_VDD5_18675 METAL2_338000_80000 METAL2_340000_80000 0.016
R_VDD5_18676 METAL2_340000_80000 METAL2_342000_80000 0.016
R_VDD5_18677 METAL2_342000_80000 METAL2_348000_80000 0.048
R_VDD5_18678 METAL2_348000_80000 METAL2_350000_80000 0.016
R_VDD5_18679 METAL2_350000_80000 METAL2_352000_80000 0.016
R_VDD5_18680 METAL2_352000_80000 METAL2_354000_80000 0.016
R_VDD5_18681 METAL2_354000_80000 METAL2_360000_80000 0.048
R_VDD5_18682 METAL2_360000_80000 METAL2_362000_80000 0.016
R_VDD5_18683 METAL2_362000_80000 METAL2_364000_80000 0.016
R_VDD5_18684 METAL2_364000_80000 METAL2_366000_80000 0.016
R_VDD5_18685 METAL2_366000_80000 METAL2_372000_80000 0.048
R_VDD5_18686 METAL2_372000_80000 METAL2_374000_80000 0.016
R_VDD5_18687 METAL2_374000_80000 METAL2_376000_80000 0.016
R_VDD5_18688 METAL2_376000_80000 METAL2_378000_80000 0.016
R_VDD5_18689 METAL2_378000_80000 METAL2_384000_80000 0.048
R_VDD5_18690 METAL2_384000_80000 METAL2_386000_80000 0.016
R_VDD5_18691 METAL2_386000_80000 METAL2_388000_80000 0.016
R_VDD5_18692 METAL2_388000_80000 METAL2_390000_80000 0.016
R_VDD5_18693 METAL2_390000_80000 METAL2_396000_80000 0.048
R_VDD5_18694 METAL2_396000_80000 METAL2_398000_80000 0.016
R_VDD5_18695 METAL2_398000_80000 METAL2_400000_80000 0.016
R_VDD5_18696 METAL2_400000_80000 METAL2_402000_80000 0.016
R_VDD5_18697 METAL2_402000_80000 METAL2_404000_80000 0.016
R_VDD5_18698 METAL2_404000_80000 METAL2_408000_80000 0.032
R_VDD5_18699 METAL2_408000_80000 METAL2_410000_80000 0.016
R_VDD5_18700 METAL2_410000_80000 METAL2_412000_80000 0.016
R_VDD5_18701 METAL2_412000_80000 METAL2_414000_80000 0.016
R_VDD5_18702 METAL2_414000_80000 METAL2_416000_80000 0.016
R_VDD5_18703 METAL2_416000_80000 METAL2_420000_80000 0.032
R_VDD5_18704 METAL2_420000_80000 METAL2_422000_80000 0.016
R_VDD5_18705 METAL2_422000_80000 METAL2_424000_80000 0.016
R_VDD5_18706 METAL2_424000_80000 METAL2_426000_80000 0.016
R_VDD5_18707 METAL2_426000_80000 METAL2_428000_80000 0.016
R_VDD5_18708 METAL2_428000_80000 METAL2_432000_80000 0.032
R_VDD5_18709 METAL2_432000_80000 METAL2_434000_80000 0.016
R_VDD5_18710 METAL2_434000_80000 METAL2_436000_80000 0.016
R_VDD5_18711 METAL2_436000_80000 METAL2_438000_80000 0.016
R_VDD5_18712 METAL2_438000_80000 METAL2_440000_80000 0.016
R_VDD5_18713 METAL2_440000_80000 METAL2_444000_80000 0.032
R_VDD5_18714 METAL2_444000_80000 METAL2_446000_80000 0.016
R_VDD5_18715 METAL2_446000_80000 METAL2_448000_80000 0.016
R_VDD5_18716 METAL2_448000_80000 METAL2_450000_80000 0.016
R_VDD5_18717 METAL2_450000_80000 METAL2_452000_80000 0.016
R_VDD5_18718 METAL2_452000_80000 METAL2_458000_80000 0.048
R_VDD5_18719 METAL2_458000_80000 METAL2_460000_80000 0.016
R_VDD5_18720 METAL2_460000_80000 METAL2_462000_80000 0.016
R_VDD5_18721 METAL2_462000_80000 METAL2_464000_80000 0.016
R_VDD5_18722 METAL2_464000_80000 METAL2_470000_80000 0.048
R_VDD5_18723 METAL2_470000_80000 METAL2_471000_80000 0.008
R_VDD5_18724 METAL2_471000_80000 METAL2_472000_80000 0.008
R_VDD5_18725 METAL2_472000_80000 METAL2_474000_80000 0.016
R_VDD5_18726 METAL2_474000_80000 METAL2_476000_80000 0.016
R_VDD5_18727 METAL2_476000_80000 METAL2_482000_80000 0.048
R_VDD5_18728 METAL2_482000_80000 METAL2_483000_80000 0.008
R_VDD5_18729 METAL2_483000_80000 METAL2_484000_80000 0.008
R_VDD5_18730 METAL2_484000_80000 METAL2_486000_80000 0.016
R_VDD5_18731 METAL2_486000_80000 METAL2_488000_80000 0.016
R_VDD5_18732 METAL2_488000_80000 METAL2_494000_80000 0.048
R_VDD5_18733 METAL2_494000_80000 METAL2_495000_80000 0.008
R_VDD5_18734 METAL2_495000_80000 METAL2_496000_80000 0.008
R_VDD5_18735 METAL2_496000_80000 METAL2_498000_80000 0.016
R_VDD5_18736 METAL2_498000_80000 METAL2_500000_80000 0.016
R_VDD5_18737 METAL2_500000_80000 METAL2_506000_80000 0.048
R_VDD5_18738 METAL2_506000_80000 METAL2_507000_80000 0.008
R_VDD5_18739 METAL2_507000_80000 METAL2_508000_80000 0.008
R_VDD5_18740 METAL2_508000_80000 METAL2_510000_80000 0.016
R_VDD5_18741 METAL2_510000_80000 METAL2_512000_80000 0.016
R_VDD5_18742 METAL2_512000_80000 METAL2_519000_80000 0.056
R_VDD5_18743 METAL2_519000_80000 METAL2_519000_69000 0.088
R_VDD5_18744 METAL2_519000_69000 METAL2_519000_68000 0.008
R_VDD5_18745 METAL2_519000_68000 METAL2_519000_57000 0.088
R_VDD5_18746 METAL2_519000_57000 METAL2_519000_56000 0.008
R_VDD5_18747 METAL2_519000_56000 METAL1_519000_56000 0.1
R_VDD5_18748 METAL1_519000_56000 METAL1_519000_45000 0.088
R_VDD5_18749 METAL1_519000_45000 METAL1_512000_45000 0.056
R_VDD5_18750 METAL1_512000_45000 METAL1_512000_44000 0.008
R_VDD5_18751 METAL1_512000_44000 METAL1_512000_33000 0.088
R_VDD5_18752 METAL1_512000_33000 METAL1_512000_32000 0.008
R_VDD5_18753 METAL1_512000_32000 METAL1_512000_21000 0.088
R_VDD5_18754 METAL1_512000_21000 METAL1_512000_20000 0.008
R_VDD5_18755 METAL1_512000_20000 METAL1_512000_9000 0.088
R_VDD5_18756 METAL1_512000_9000 METAL1_512000_8000 0.008
R_VDD5_18757 METAL1_512000_8000 METAL1_510000_8000 0.016
R_VDD5_18758 METAL1_510000_8000 METAL1_508000_8000 0.016
R_VDD5_18759 METAL1_508000_8000 METAL1_507000_8000 0.008
R_VDD5_18760 METAL1_507000_8000 METAL1_506000_8000 0.008
R_VDD5_18761 METAL1_506000_8000 METAL1_500000_8000 0.048
R_VDD5_18762 METAL1_500000_8000 METAL2_500000_8000 0.1
R_VDD5_18763 METAL5_500000_32000 METAL5_506000_32000 0.024
R_VDD5_18764 METAL5_506000_32000 METAL5_507000_32000 0.004
R_VDD5_18765 METAL5_507000_32000 METAL5_508000_32000 0.004
R_VDD5_18766 METAL5_508000_32000 METAL5_510000_32000 0.008
R_VDD5_18767 METAL5_510000_32000 METAL5_512000_32000 0.008
R_VDD5_18768 METAL5_512000_32000 METAL5_519000_32000 0.028
R_VDD5_18769 METAL5_519000_32000 METAL5_520000_32000 0.004
R_VDD5_18770 METAL5_520000_32000 METAL5_522000_32000 0.008
R_VDD5_18771 METAL5_522000_32000 METAL5_524000_32000 0.008
R_VDD5_18772 METAL5_524000_32000 METAL5_531000_32000 0.028
R_VDD5_18773 METAL5_531000_32000 METAL4_531000_32000 0.1
R_VDD5_18774 METAL4_531000_32000 METAL3_531000_32000 0.1
R_VDD5_18775 METAL3_531000_32000 METAL2_531000_32000 0.1
R_VDD5_18776 METAL2_531000_32000 METAL2_531000_33000 0.008
R_VDD5_18777 METAL2_531000_33000 METAL2_531000_44000 0.088
R_VDD5_18778 METAL2_531000_44000 METAL2_531000_45000 0.008
R_VDD5_18779 METAL2_531000_45000 METAL2_531000_56000 0.088
R_VDD5_18780 METAL2_531000_56000 METAL2_531000_57000 0.008
R_VDD5_18781 METAL2_531000_57000 METAL2_531000_68000 0.088
R_VDD5_18782 METAL2_531000_68000 METAL2_531000_69000 0.008
R_VDD5_18783 METAL2_531000_69000 METAL2_531000_80000 0.088
R_VDD5_18784 METAL2_531000_80000 METAL2_531000_81000 0.008
R_VDD5_18785 METAL2_531000_81000 METAL2_531000_92000 0.088
R_VDD5_18786 METAL2_531000_92000 METAL2_524000_92000 0.056
R_VDD5_18787 METAL2_524000_92000 METAL2_522000_92000 0.016
R_VDD5_18788 METAL2_522000_92000 METAL2_520000_92000 0.016
R_VDD5_18789 METAL2_520000_92000 METAL2_520000_93000 0.008
R_VDD5_18790 METAL2_520000_93000 METAL2_520000_97000 0.032
R_VDD5_18791 METAL2_520000_97000 METAL2_520000_104000 0.056
R_VDD5_18792 METAL2_520000_104000 METAL2_519000_104000 0.008
R_VDD5_18793 METAL2_519000_104000 METAL2_519000_105000 0.008
R_VDD5_18794 METAL2_519000_105000 METAL2_519000_109000 0.032
R_VDD5_18795 METAL2_519000_109000 METAL2_519000_116000 0.056
R_VDD5_18796 METAL2_519000_116000 METAL2_519000_117000 0.008
R_VDD5_18797 METAL2_519000_117000 METAL2_519000_121000 0.032
R_VDD5_18798 METAL2_519000_121000 METAL2_519000_128000 0.056
R_VDD5_18799 METAL2_519000_128000 METAL2_519000_129000 0.008
R_VDD5_18800 METAL2_519000_129000 METAL2_519000_133000 0.032
R_VDD5_18801 METAL2_519000_133000 METAL2_519000_141000 0.064
R_VDD5_18802 METAL2_519000_141000 METAL2_519000_145000 0.032
R_VDD5_18803 METAL2_519000_145000 METAL2_519000_153000 0.064
R_VDD5_18804 METAL2_519000_153000 METAL2_519000_157000 0.032
R_VDD5_18805 METAL2_519000_157000 METAL2_519000_165000 0.064
R_VDD5_18806 METAL2_519000_165000 METAL2_519000_169000 0.032
R_VDD5_18807 METAL2_519000_169000 METAL2_519000_177000 0.064
R_VDD5_18808 METAL2_519000_177000 METAL2_519000_181000 0.032
R_VDD5_18809 METAL2_519000_181000 METAL2_519000_189000 0.064
R_VDD5_18810 METAL2_519000_189000 METAL2_519000_193000 0.032
R_VDD5_18811 METAL2_519000_193000 METAL2_519000_201000 0.064
R_VDD5_18812 METAL2_519000_201000 METAL2_519000_205000 0.032
R_VDD5_18813 METAL2_519000_205000 METAL2_519000_213000 0.064
R_VDD5_18814 METAL2_519000_213000 METAL2_519000_217000 0.032
R_VDD5_18815 METAL2_519000_217000 METAL2_519000_221000 0.032
R_VDD5_18816 METAL2_519000_221000 METAL2_519000_225000 0.032
R_VDD5_18817 METAL2_519000_225000 METAL2_519000_229000 0.032
R_VDD5_18818 METAL2_519000_229000 METAL2_519000_233000 0.032
R_VDD5_18819 METAL2_519000_233000 METAL2_519000_241000 0.064
R_VDD5_18820 METAL2_519000_241000 METAL2_519000_245000 0.032
R_VDD5_18821 METAL2_519000_245000 METAL2_519000_253000 0.064
R_VDD5_18822 METAL2_519000_253000 METAL2_519000_257000 0.032
R_VDD5_18823 METAL2_519000_257000 METAL2_519000_265000 0.064
R_VDD5_18824 METAL2_519000_265000 METAL2_519000_269000 0.032
R_VDD5_18825 METAL2_519000_269000 METAL2_519000_277000 0.064
R_VDD5_18826 METAL2_519000_277000 METAL2_519000_281000 0.032
R_VDD5_18827 METAL2_519000_281000 METAL2_519000_289000 0.064
R_VDD5_18828 METAL2_519000_289000 METAL2_519000_293000 0.032
R_VDD5_18829 METAL2_519000_293000 METAL2_519000_301000 0.064
R_VDD5_18830 METAL2_519000_301000 METAL2_519000_305000 0.032
R_VDD5_18831 METAL2_519000_305000 METAL2_519000_313000 0.064
R_VDD5_18832 METAL2_519000_313000 METAL2_519000_317000 0.032
R_VDD5_18833 METAL2_519000_317000 METAL2_519000_329000 0.096
R_VDD5_18834 METAL2_519000_329000 METAL2_519000_341000 0.096
R_VDD5_18835 METAL2_519000_341000 METAL2_519000_353000 0.096
R_VDD5_18836 METAL2_519000_353000 METAL2_519000_365000 0.096
R_VDD5_18837 METAL2_519000_365000 METAL2_519000_377000 0.096
R_VDD5_18838 METAL2_519000_377000 METAL2_519000_381000 0.032
R_VDD5_18839 METAL2_519000_381000 METAL2_519000_389000 0.064
R_VDD5_18840 METAL2_519000_389000 METAL2_519000_393000 0.032
R_VDD5_18841 METAL2_519000_393000 METAL2_519000_401000 0.064
R_VDD5_18842 METAL2_519000_401000 METAL2_519000_405000 0.032
R_VDD5_18843 METAL2_519000_405000 METAL2_519000_417000 0.096
R_VDD5_18844 METAL2_519000_417000 METAL2_519000_429000 0.096
R_VDD5_18845 METAL2_519000_429000 METAL2_519000_441000 0.096
R_VDD5_18846 METAL2_519000_441000 METAL2_519000_453000 0.096
R_VDD5_18847 METAL2_519000_453000 METAL2_519000_465000 0.096
R_VDD5_18848 METAL2_519000_465000 METAL2_519000_469000 0.032
R_VDD5_18849 METAL2_519000_469000 METAL2_519000_477000 0.064
R_VDD5_18850 METAL2_519000_477000 METAL2_519000_481000 0.032
R_VDD5_18851 METAL2_519000_481000 METAL2_519000_489000 0.064
R_VDD5_18852 METAL2_519000_489000 METAL2_519000_493000 0.032
R_VDD5_18853 METAL2_519000_493000 METAL2_519000_501000 0.064
R_VDD5_18854 METAL2_519000_501000 METAL2_519000_505000 0.032
R_VDD5_18855 METAL2_519000_505000 METAL2_519000_513000 0.064
R_VDD5_18856 METAL2_519000_513000 METAL2_519000_517000 0.032
R_VDD5_18857 METAL2_519000_517000 METAL2_519000_529000 0.096
R_VDD5_18858 METAL2_519000_529000 METAL2_519000_541000 0.096
R_VDD5_18859 METAL2_519000_541000 METAL2_519000_553000 0.096
R_VDD5_18860 METAL2_519000_553000 METAL2_519000_565000 0.096
R_VDD5_18861 METAL2_519000_565000 METAL2_519000_577000 0.096
R_VDD5_18862 METAL2_519000_577000 METAL2_519000_589000 0.096
R_VDD5_18863 METAL2_519000_589000 METAL2_519000_601000 0.096
R_VDD5_18864 METAL2_519000_601000 METAL2_519000_613000 0.096
R_VDD5_18865 METAL2_519000_613000 METAL2_519000_625000 0.096
R_VDD5_18866 METAL2_519000_625000 METAL2_519000_657000 0.256
R_VDD5_18867 METAL2_519000_657000 METAL2_519000_669000 0.096
R_VDD5_18868 METAL2_519000_669000 METAL2_519000_681000 0.096
R_VDD5_18869 METAL2_519000_681000 METAL2_519000_693000 0.096
R_VDD5_18870 METAL2_519000_693000 METAL2_519000_705000 0.096
R_VDD5_18871 METAL2_519000_705000 METAL2_519000_707000 0.016
R_VDD5_18872 METAL2_519000_707000 METAL2_519000_717000 0.08
R_VDD5_18873 METAL2_519000_717000 METAL3_519000_717000 0.1
R_VDD5_18874 METAL3_519000_717000 METAL3_519000_729000 0.096
R_VDD5_18875 METAL3_519000_729000 METAL3_519000_757000 0.224
R_VDD5_18876 METAL3_519000_757000 METAL3_519000_769000 0.096
R_VDD5_18877 METAL3_519000_769000 METAL3_519000_781000 0.096
R_VDD5_18878 METAL3_519000_781000 METAL3_519000_793000 0.096
R_VDD5_18879 METAL3_519000_793000 METAL3_519000_805000 0.096
R_VDD5_18880 METAL3_519000_805000 METAL3_519000_817000 0.096
R_VDD5_18881 METAL3_519000_817000 METAL3_519000_829000 0.096
R_VDD5_18882 METAL3_519000_829000 METAL3_519000_841000 0.096
R_VDD5_18883 METAL3_519000_841000 METAL3_519000_845000 0.032
R_VDD5_18884 METAL3_519000_845000 METAL3_519000_853000 0.064
R_VDD5_18885 METAL3_519000_853000 METAL3_519000_857000 0.032
R_VDD5_18886 METAL3_519000_857000 METAL3_519000_865000 0.064
R_VDD5_18887 METAL3_519000_865000 METAL3_519000_869000 0.032
R_VDD5_18888 METAL3_519000_869000 METAL3_519000_877000 0.064
R_VDD5_18889 METAL3_519000_877000 METAL3_519000_881000 0.032
R_VDD5_18890 METAL3_519000_881000 METAL3_519000_889000 0.064
R_VDD5_18891 METAL3_519000_889000 METAL3_519000_893000 0.032
R_VDD5_18892 METAL3_519000_893000 METAL3_519000_901000 0.064
R_VDD5_18893 METAL3_519000_901000 METAL3_519000_905000 0.032
R_VDD5_18894 METAL3_519000_905000 METAL3_519000_913000 0.064
R_VDD5_18895 METAL3_519000_913000 METAL3_519000_917000 0.032
R_VDD5_18896 METAL3_519000_917000 METAL3_519000_929000 0.096
R_VDD5_18897 METAL3_519000_929000 METAL3_519000_941000 0.096
R_VDD5_18898 METAL3_519000_941000 METAL3_519000_953000 0.096
R_VDD5_18899 METAL3_519000_953000 METAL3_519000_965000 0.096
R_VDD5_18900 METAL3_519000_965000 METAL3_519000_977000 0.096
R_VDD5_18901 METAL3_519000_977000 METAL3_519000_989000 0.096
R_VDD5_18902 METAL3_519000_989000 METAL3_519000_1001000 0.096
R_VDD5_18903 METAL3_519000_1001000 METAL3_519000_1013000 0.096
R_VDD5_18904 METAL3_519000_1013000 METAL3_519000_1025000 0.096
R_VDD5_18905 METAL3_519000_1025000 METAL3_519000_1029000 0.032
R_VDD5_18906 METAL3_519000_1029000 METAL3_519000_1037000 0.064
R_VDD5_18907 METAL3_519000_1037000 METAL3_519000_1041000 0.032
R_VDD5_18908 METAL3_519000_1041000 METAL3_519000_1053000 0.096
R_VDD5_18909 METAL3_519000_1053000 METAL3_519000_1065000 0.096
R_VDD5_18910 METAL3_519000_1065000 METAL3_519000_1077000 0.096
R_VDD5_18911 METAL3_519000_1077000 METAL3_519000_1089000 0.096
R_VDD5_18912 METAL3_519000_1089000 METAL3_519000_1101000 0.096
R_VDD5_18913 METAL3_519000_1101000 METAL3_519000_1113000 0.096
R_VDD5_18914 METAL3_519000_1113000 METAL3_519000_1141000 0.224
R_VDD5_18915 METAL3_519000_1141000 METAL3_519000_1153000 0.096
R_VDD5_18916 METAL3_519000_1153000 METAL3_519000_1165000 0.096
R_VDD5_18917 METAL3_519000_1165000 METAL3_519000_1177000 0.096
R_VDD5_18918 METAL3_519000_1177000 METAL3_519000_1189000 0.096
R_VDD5_18919 METAL3_519000_1189000 METAL3_520000_1189000 0.008
R_VDD5_18920 METAL3_520000_1189000 METAL3_522000_1189000 0.016
R_VDD5_18921 METAL3_522000_1189000 METAL3_524000_1189000 0.016
R_VDD5_18922 METAL3_524000_1189000 METAL3_531000_1189000 0.056
R_VDD5_18923 METAL3_531000_1189000 METAL3_532000_1189000 0.008
R_VDD5_18924 METAL3_532000_1189000 METAL3_536000_1189000 0.032
R_VDD5_18925 METAL3_536000_1189000 METAL3_543000_1189000 0.056
R_VDD5_18926 METAL3_543000_1189000 METAL4_543000_1189000 0.1
R_VDD5_18927 METAL4_543000_1189000 METAL5_543000_1189000 0.1
R_VDD5_18928 METAL5_543000_1189000 METAL5_543000_1201000 0.048
R_VDD5_18929 METAL5_543000_1201000 METAL5_543000_1205000 0.016
R_VDD5_18930 METAL5_543000_1205000 METAL5_543000_1213000 0.032
R_VDD5_18931 METAL5_543000_1213000 METAL5_543000_1217000 0.016
R_VDD5_18932 METAL5_543000_1217000 METAL5_543000_1229000 0.048
R_VDD5_18933 METAL5_543000_1229000 METAL5_543000_1241000 0.048
R_VDD5_18934 METAL5_543000_1241000 METAL5_543000_1253000 0.048
R_VDD5_18935 METAL5_543000_1253000 METAL5_543000_1265000 0.048
R_VDD5_18936 METAL5_543000_1265000 METAL6_543000_1265000 0.1
R_VDD5_18937 METAL5_500000_141000 METAL4_500000_141000 0.1
R_VDD5_18938 METAL4_500000_141000 METAL4_500000_145000 0.032
R_VDD5_18939 METAL4_500000_145000 METAL4_500000_153000 0.064
R_VDD5_18940 METAL4_500000_153000 METAL4_500000_157000 0.032
R_VDD5_18941 METAL4_500000_157000 METAL4_500000_165000 0.064
R_VDD5_18942 METAL4_500000_165000 METAL4_500000_169000 0.032
R_VDD5_18943 METAL4_500000_169000 METAL4_500000_177000 0.064
R_VDD5_18944 METAL4_500000_177000 METAL4_500000_181000 0.032
R_VDD5_18945 METAL4_500000_181000 METAL4_500000_189000 0.064
R_VDD5_18946 METAL4_500000_189000 METAL4_500000_193000 0.032
R_VDD5_18947 METAL4_500000_193000 METAL4_498000_193000 0.016
R_VDD5_18948 METAL4_498000_193000 METAL4_496000_193000 0.016
R_VDD5_18949 METAL4_496000_193000 METAL4_495000_193000 0.008
R_VDD5_18950 METAL4_495000_193000 METAL3_495000_193000 0.1
R_VDD5_18951 METAL3_495000_193000 METAL2_495000_193000 0.1
R_VDD5_18952 METAL2_495000_193000 METAL2_495000_201000 0.064
R_VDD5_18953 METAL2_495000_201000 METAL2_495000_205000 0.032
R_VDD5_18954 METAL2_495000_205000 METAL2_495000_213000 0.064
R_VDD5_18955 METAL2_495000_213000 METAL2_495000_217000 0.032
R_VDD5_18956 METAL2_495000_217000 METAL2_495000_221000 0.032
R_VDD5_18957 METAL2_495000_221000 METAL2_495000_225000 0.032
R_VDD5_18958 METAL2_495000_225000 METAL2_495000_229000 0.032
R_VDD5_18959 METAL2_495000_229000 METAL2_495000_233000 0.032
R_VDD5_18960 METAL2_495000_233000 METAL2_495000_241000 0.064
R_VDD5_18961 METAL2_495000_241000 METAL2_495000_245000 0.032
R_VDD5_18962 METAL2_495000_245000 METAL2_495000_253000 0.064
R_VDD5_18963 METAL2_495000_253000 METAL2_495000_257000 0.032
R_VDD5_18964 METAL2_495000_257000 METAL2_495000_265000 0.064
R_VDD5_18965 METAL2_495000_265000 METAL2_495000_269000 0.032
R_VDD5_18966 METAL2_495000_269000 METAL2_495000_277000 0.064
R_VDD5_18967 METAL2_495000_277000 METAL2_495000_281000 0.032
R_VDD5_18968 METAL2_495000_281000 METAL2_495000_289000 0.064
R_VDD5_18969 METAL2_495000_289000 METAL2_495000_293000 0.032
R_VDD5_18970 METAL2_495000_293000 METAL2_495000_301000 0.064
R_VDD5_18971 METAL2_495000_301000 METAL2_495000_305000 0.032
R_VDD5_18972 METAL2_495000_305000 METAL2_495000_313000 0.064
R_VDD5_18973 METAL2_495000_313000 METAL2_495000_317000 0.032
R_VDD5_18974 METAL2_495000_317000 METAL2_495000_329000 0.096
R_VDD5_18975 METAL2_495000_329000 METAL2_495000_341000 0.096
R_VDD5_18976 METAL2_495000_341000 METAL2_495000_353000 0.096
R_VDD5_18977 METAL2_495000_353000 METAL2_495000_365000 0.096
R_VDD5_18978 METAL2_495000_365000 METAL2_495000_377000 0.096
R_VDD5_18979 METAL2_495000_377000 METAL2_495000_381000 0.032
R_VDD5_18980 METAL2_495000_381000 METAL2_495000_389000 0.064
R_VDD5_18981 METAL2_495000_389000 METAL2_495000_393000 0.032
R_VDD5_18982 METAL2_495000_393000 METAL2_495000_401000 0.064
R_VDD5_18983 METAL2_495000_401000 METAL2_495000_405000 0.032
R_VDD5_18984 METAL2_495000_405000 METAL2_495000_417000 0.096
R_VDD5_18985 METAL2_495000_417000 METAL2_495000_429000 0.096
R_VDD5_18986 METAL2_495000_429000 METAL2_495000_441000 0.096
R_VDD5_18987 METAL2_495000_441000 METAL2_495000_453000 0.096
R_VDD5_18988 METAL2_495000_453000 METAL2_495000_465000 0.096
R_VDD5_18989 METAL2_495000_465000 METAL2_495000_469000 0.032
R_VDD5_18990 METAL2_495000_469000 METAL2_495000_477000 0.064
R_VDD5_18991 METAL2_495000_477000 METAL2_495000_481000 0.032
R_VDD5_18992 METAL2_495000_481000 METAL2_495000_489000 0.064
R_VDD5_18993 METAL2_495000_489000 METAL2_495000_493000 0.032
R_VDD5_18994 METAL2_495000_493000 METAL2_495000_501000 0.064
R_VDD5_18995 METAL2_495000_501000 METAL2_495000_505000 0.032
R_VDD5_18996 METAL2_495000_505000 METAL2_495000_513000 0.064
R_VDD5_18997 METAL2_495000_513000 METAL2_495000_517000 0.032
R_VDD5_18998 METAL2_495000_517000 METAL2_495000_529000 0.096
R_VDD5_18999 METAL2_495000_529000 METAL2_495000_541000 0.096
R_VDD5_19000 METAL2_495000_541000 METAL2_495000_553000 0.096
R_VDD5_19001 METAL2_495000_553000 METAL2_495000_565000 0.096
R_VDD5_19002 METAL2_495000_565000 METAL2_495000_577000 0.096
R_VDD5_19003 METAL2_495000_577000 METAL2_495000_589000 0.096
R_VDD5_19004 METAL2_495000_589000 METAL2_495000_601000 0.096
R_VDD5_19005 METAL2_495000_601000 METAL2_495000_613000 0.096
R_VDD5_19006 METAL2_495000_613000 METAL2_495000_625000 0.096
R_VDD5_19007 METAL2_495000_625000 METAL2_495000_657000 0.256
R_VDD5_19008 METAL2_495000_657000 METAL3_495000_657000 0.1
R_VDD5_19009 METAL3_495000_657000 METAL3_495000_669000 0.096
R_VDD5_19010 METAL3_495000_669000 METAL3_495000_681000 0.096
R_VDD5_19011 METAL3_495000_681000 METAL3_495000_693000 0.096
R_VDD5_19012 METAL3_495000_693000 METAL3_495000_705000 0.096
R_VDD5_19013 METAL3_495000_705000 METAL3_495000_707000 0.016
R_VDD5_19014 METAL3_495000_707000 METAL3_495000_717000 0.08
R_VDD5_19015 METAL3_495000_717000 METAL3_495000_729000 0.096
R_VDD5_19016 METAL3_495000_729000 METAL3_495000_757000 0.224
R_VDD5_19017 METAL3_495000_757000 METAL3_495000_769000 0.096
R_VDD5_19018 METAL3_495000_769000 METAL3_495000_781000 0.096
R_VDD5_19019 METAL3_495000_781000 METAL3_495000_793000 0.096
R_VDD5_19020 METAL3_495000_793000 METAL3_495000_805000 0.096
R_VDD5_19021 METAL3_495000_805000 METAL3_495000_817000 0.096
R_VDD5_19022 METAL3_495000_817000 METAL3_495000_829000 0.096
R_VDD5_19023 METAL3_495000_829000 METAL3_495000_841000 0.096
R_VDD5_19024 METAL3_495000_841000 METAL3_495000_845000 0.032
R_VDD5_19025 METAL3_495000_845000 METAL3_495000_853000 0.064
R_VDD5_19026 METAL3_495000_853000 METAL3_495000_857000 0.032
R_VDD5_19027 METAL3_495000_857000 METAL3_495000_865000 0.064
R_VDD5_19028 METAL3_495000_865000 METAL3_495000_869000 0.032
R_VDD5_19029 METAL3_495000_869000 METAL3_495000_877000 0.064
R_VDD5_19030 METAL3_495000_877000 METAL3_495000_881000 0.032
R_VDD5_19031 METAL3_495000_881000 METAL3_495000_889000 0.064
R_VDD5_19032 METAL3_495000_889000 METAL3_495000_893000 0.032
R_VDD5_19033 METAL3_495000_893000 METAL3_495000_901000 0.064
R_VDD5_19034 METAL3_495000_901000 METAL3_495000_905000 0.032
R_VDD5_19035 METAL3_495000_905000 METAL3_495000_913000 0.064
R_VDD5_19036 METAL3_495000_913000 METAL3_495000_917000 0.032
R_VDD5_19037 METAL3_495000_917000 METAL3_495000_929000 0.096
R_VDD5_19038 METAL3_495000_929000 METAL3_495000_941000 0.096
R_VDD5_19039 METAL3_495000_941000 METAL3_495000_953000 0.096
R_VDD5_19040 METAL3_495000_953000 METAL3_495000_965000 0.096
R_VDD5_19041 METAL3_495000_965000 METAL3_495000_977000 0.096
R_VDD5_19042 METAL3_495000_977000 METAL3_495000_989000 0.096
R_VDD5_19043 METAL3_495000_989000 METAL3_495000_1001000 0.096
R_VDD5_19044 METAL3_495000_1001000 METAL3_495000_1013000 0.096
R_VDD5_19045 METAL3_495000_1013000 METAL3_495000_1025000 0.096
R_VDD5_19046 METAL3_495000_1025000 METAL3_495000_1029000 0.032
R_VDD5_19047 METAL3_495000_1029000 METAL3_495000_1037000 0.064
R_VDD5_19048 METAL3_495000_1037000 METAL3_495000_1041000 0.032
R_VDD5_19049 METAL3_495000_1041000 METAL3_495000_1053000 0.096
R_VDD5_19050 METAL3_495000_1053000 METAL3_495000_1065000 0.096
R_VDD5_19051 METAL3_495000_1065000 METAL3_495000_1077000 0.096
R_VDD5_19052 METAL3_495000_1077000 METAL3_495000_1089000 0.096
R_VDD5_19053 METAL3_495000_1089000 METAL3_495000_1101000 0.096
R_VDD5_19054 METAL3_495000_1101000 METAL3_495000_1113000 0.096
R_VDD5_19055 METAL3_495000_1113000 METAL3_495000_1141000 0.224
R_VDD5_19056 METAL3_495000_1141000 METAL3_495000_1153000 0.096
R_VDD5_19057 METAL3_495000_1153000 METAL3_495000_1165000 0.096
R_VDD5_19058 METAL3_495000_1165000 METAL3_495000_1177000 0.096
R_VDD5_19059 METAL3_495000_1177000 METAL3_495000_1189000 0.096
R_VDD5_19060 METAL3_495000_1189000 METAL3_495000_1201000 0.096
R_VDD5_19061 METAL3_495000_1201000 METAL4_495000_1201000 0.1
R_VDD5_19062 METAL4_495000_1201000 METAL4_495000_1205000 0.032
R_VDD5_19063 METAL4_495000_1205000 METAL4_495000_1213000 0.064
R_VDD5_19064 METAL4_495000_1213000 METAL4_495000_1217000 0.032
R_VDD5_19065 METAL4_495000_1217000 METAL4_495000_1229000 0.096
R_VDD5_19066 METAL4_495000_1229000 METAL4_495000_1241000 0.096
R_VDD5_19067 METAL4_495000_1241000 METAL4_495000_1253000 0.096
R_VDD5_19068 METAL4_495000_1253000 METAL4_495000_1265000 0.096
R_VDD5_19069 METAL4_495000_1265000 METAL4_496000_1265000 0.008
R_VDD5_19070 METAL4_496000_1265000 METAL4_498000_1265000 0.016
R_VDD5_19071 METAL4_498000_1265000 METAL4_500000_1265000 0.016
R_VDD5_19072 METAL4_500000_1265000 METAL4_506000_1265000 0.048
R_VDD5_19073 METAL4_506000_1265000 METAL4_507000_1265000 0.008
R_VDD5_19074 METAL4_507000_1265000 METAL4_508000_1265000 0.008
R_VDD5_19075 METAL4_508000_1265000 METAL4_510000_1265000 0.016
R_VDD5_19076 METAL4_510000_1265000 METAL4_512000_1265000 0.016
R_VDD5_19077 METAL4_512000_1265000 METAL4_519000_1265000 0.056
R_VDD5_19078 METAL4_519000_1265000 METAL4_520000_1265000 0.008
R_VDD5_19079 METAL4_520000_1265000 METAL4_522000_1265000 0.016
R_VDD5_19080 METAL4_522000_1265000 METAL4_524000_1265000 0.016
R_VDD5_19081 METAL4_524000_1265000 METAL4_531000_1265000 0.056
R_VDD5_19082 METAL4_531000_1265000 METAL4_532000_1265000 0.008
R_VDD5_19083 METAL4_532000_1265000 METAL4_536000_1265000 0.032
R_VDD5_19084 METAL4_536000_1265000 METAL4_543000_1265000 0.056
R_VDD5_19085 METAL4_543000_1265000 METAL5_543000_1265000 0.1
R_VDD5_19086 METAL6_500000_177000 METAL5_500000_177000 0.1
R_VDD5_19087 METAL5_500000_177000 METAL5_500000_181000 0.016
R_VDD5_19088 METAL5_500000_181000 METAL5_500000_189000 0.032
R_VDD5_19089 METAL5_500000_189000 METAL5_500000_193000 0.016
R_VDD5_19090 METAL5_500000_193000 METAL5_500000_201000 0.032
R_VDD5_19091 METAL5_500000_201000 METAL5_500000_205000 0.016
R_VDD5_19092 METAL5_500000_205000 METAL5_500000_213000 0.032
R_VDD5_19093 METAL5_500000_213000 METAL5_500000_217000 0.016
R_VDD5_19094 METAL5_500000_217000 METAL5_498000_217000 0.008
R_VDD5_19095 METAL5_498000_217000 METAL5_496000_217000 0.008
R_VDD5_19096 METAL5_496000_217000 METAL5_495000_217000 0.004
R_VDD5_19097 METAL5_495000_217000 METAL5_494000_217000 0.004
R_VDD5_19098 METAL5_494000_217000 METAL5_488000_217000 0.024
R_VDD5_19099 METAL5_488000_217000 METAL5_486000_217000 0.008
R_VDD5_19100 METAL5_486000_217000 METAL5_484000_217000 0.008
R_VDD5_19101 METAL5_484000_217000 METAL4_484000_217000 0.1
R_VDD5_19102 METAL4_484000_217000 METAL3_484000_217000 0.1
R_VDD5_19103 METAL3_484000_217000 METAL3_484000_221000 0.032
R_VDD5_19104 METAL3_484000_221000 METAL3_484000_225000 0.032
R_VDD5_19105 METAL3_484000_225000 METAL3_484000_229000 0.032
R_VDD5_19106 METAL3_484000_229000 METAL3_484000_233000 0.032
R_VDD5_19107 METAL3_484000_233000 METAL3_484000_241000 0.064
R_VDD5_19108 METAL3_484000_241000 METAL3_484000_245000 0.032
R_VDD5_19109 METAL3_484000_245000 METAL3_484000_253000 0.064
R_VDD5_19110 METAL3_484000_253000 METAL3_484000_257000 0.032
R_VDD5_19111 METAL3_484000_257000 METAL3_484000_265000 0.064
R_VDD5_19112 METAL3_484000_265000 METAL3_484000_269000 0.032
R_VDD5_19113 METAL3_484000_269000 METAL3_484000_277000 0.064
R_VDD5_19114 METAL3_484000_277000 METAL3_484000_281000 0.032
R_VDD5_19115 METAL3_484000_281000 METAL3_484000_289000 0.064
R_VDD5_19116 METAL3_484000_289000 METAL3_484000_293000 0.032
R_VDD5_19117 METAL3_484000_293000 METAL3_484000_301000 0.064
R_VDD5_19118 METAL3_484000_301000 METAL3_484000_305000 0.032
R_VDD5_19119 METAL3_484000_305000 METAL3_484000_313000 0.064
R_VDD5_19120 METAL3_484000_313000 METAL3_484000_317000 0.032
R_VDD5_19121 METAL3_484000_317000 METAL3_484000_329000 0.096
R_VDD5_19122 METAL3_484000_329000 METAL3_484000_341000 0.096
R_VDD5_19123 METAL3_484000_341000 METAL3_484000_353000 0.096
R_VDD5_19124 METAL3_484000_353000 METAL3_484000_365000 0.096
R_VDD5_19125 METAL3_484000_365000 METAL3_484000_377000 0.096
R_VDD5_19126 METAL3_484000_377000 METAL3_484000_381000 0.032
R_VDD5_19127 METAL3_484000_381000 METAL3_483000_381000 0.008
R_VDD5_19128 METAL3_483000_381000 METAL2_483000_381000 0.1
R_VDD5_19129 METAL2_483000_381000 METAL2_483000_389000 0.064
R_VDD5_19130 METAL2_483000_389000 METAL2_483000_393000 0.032
R_VDD5_19131 METAL2_483000_393000 METAL2_483000_401000 0.064
R_VDD5_19132 METAL2_483000_401000 METAL2_483000_405000 0.032
R_VDD5_19133 METAL2_483000_405000 METAL2_483000_417000 0.096
R_VDD5_19134 METAL2_483000_417000 METAL2_483000_429000 0.096
R_VDD5_19135 METAL2_483000_429000 METAL2_483000_441000 0.096
R_VDD5_19136 METAL2_483000_441000 METAL2_483000_453000 0.096
R_VDD5_19137 METAL2_483000_453000 METAL2_483000_465000 0.096
R_VDD5_19138 METAL2_483000_465000 METAL2_483000_469000 0.032
R_VDD5_19139 METAL2_483000_469000 METAL2_483000_477000 0.064
R_VDD5_19140 METAL2_483000_477000 METAL2_483000_481000 0.032
R_VDD5_19141 METAL2_483000_481000 METAL2_483000_489000 0.064
R_VDD5_19142 METAL2_483000_489000 METAL2_483000_493000 0.032
R_VDD5_19143 METAL2_483000_493000 METAL2_483000_501000 0.064
R_VDD5_19144 METAL2_483000_501000 METAL2_483000_505000 0.032
R_VDD5_19145 METAL2_483000_505000 METAL2_483000_513000 0.064
R_VDD5_19146 METAL2_483000_513000 METAL2_483000_517000 0.032
R_VDD5_19147 METAL2_483000_517000 METAL2_483000_529000 0.096
R_VDD5_19148 METAL2_483000_529000 METAL2_483000_541000 0.096
R_VDD5_19149 METAL2_483000_541000 METAL2_483000_553000 0.096
R_VDD5_19150 METAL2_483000_553000 METAL2_483000_565000 0.096
R_VDD5_19151 METAL2_483000_565000 METAL2_483000_577000 0.096
R_VDD5_19152 METAL2_483000_577000 METAL2_483000_589000 0.096
R_VDD5_19153 METAL2_483000_589000 METAL2_483000_601000 0.096
R_VDD5_19154 METAL2_483000_601000 METAL2_483000_613000 0.096
R_VDD5_19155 METAL2_483000_613000 METAL2_483000_625000 0.096
R_VDD5_19156 METAL2_483000_625000 METAL2_483000_645000 0.16
R_VDD5_19157 METAL2_483000_645000 METAL2_483000_657000 0.096
R_VDD5_19158 METAL2_483000_657000 METAL2_483000_669000 0.096
R_VDD5_19159 METAL2_483000_669000 METAL2_483000_681000 0.096
R_VDD5_19160 METAL2_483000_681000 METAL2_483000_693000 0.096
R_VDD5_19161 METAL2_483000_693000 METAL2_483000_705000 0.096
R_VDD5_19162 METAL2_483000_705000 METAL2_483000_707000 0.016
R_VDD5_19163 METAL2_483000_707000 METAL2_483000_717000 0.08
R_VDD5_19164 METAL2_483000_717000 METAL2_483000_729000 0.096
R_VDD5_19165 METAL2_483000_729000 METAL2_483000_757000 0.224
R_VDD5_19166 METAL2_483000_757000 METAL2_483000_769000 0.096
R_VDD5_19167 METAL2_483000_769000 METAL2_483000_781000 0.096
R_VDD5_19168 METAL2_483000_781000 METAL2_483000_793000 0.096
R_VDD5_19169 METAL2_483000_793000 METAL2_483000_805000 0.096
R_VDD5_19170 METAL2_483000_805000 METAL2_483000_817000 0.096
R_VDD5_19171 METAL2_483000_817000 METAL2_483000_829000 0.096
R_VDD5_19172 METAL2_483000_829000 METAL2_483000_841000 0.096
R_VDD5_19173 METAL2_483000_841000 METAL2_483000_845000 0.032
R_VDD5_19174 METAL2_483000_845000 METAL2_483000_853000 0.064
R_VDD5_19175 METAL2_483000_853000 METAL2_483000_857000 0.032
R_VDD5_19176 METAL2_483000_857000 METAL2_483000_865000 0.064
R_VDD5_19177 METAL2_483000_865000 METAL2_483000_869000 0.032
R_VDD5_19178 METAL2_483000_869000 METAL2_483000_877000 0.064
R_VDD5_19179 METAL2_483000_877000 METAL2_483000_881000 0.032
R_VDD5_19180 METAL2_483000_881000 METAL2_483000_889000 0.064
R_VDD5_19181 METAL2_483000_889000 METAL2_483000_893000 0.032
R_VDD5_19182 METAL2_483000_893000 METAL2_483000_901000 0.064
R_VDD5_19183 METAL2_483000_901000 METAL2_483000_905000 0.032
R_VDD5_19184 METAL2_483000_905000 METAL2_483000_913000 0.064
R_VDD5_19185 METAL2_483000_913000 METAL2_483000_917000 0.032
R_VDD5_19186 METAL2_483000_917000 METAL2_483000_929000 0.096
R_VDD5_19187 METAL2_483000_929000 METAL2_483000_941000 0.096
R_VDD5_19188 METAL2_483000_941000 METAL2_483000_953000 0.096
R_VDD5_19189 METAL2_483000_953000 METAL2_483000_965000 0.096
R_VDD5_19190 METAL2_483000_965000 METAL2_483000_977000 0.096
R_VDD5_19191 METAL2_483000_977000 METAL2_483000_989000 0.096
R_VDD5_19192 METAL2_483000_989000 METAL2_483000_1001000 0.096
R_VDD5_19193 METAL2_483000_1001000 METAL2_483000_1013000 0.096
R_VDD5_19194 METAL2_483000_1013000 METAL2_483000_1025000 0.096
R_VDD5_19195 METAL2_483000_1025000 METAL2_483000_1029000 0.032
R_VDD5_19196 METAL2_483000_1029000 METAL2_483000_1037000 0.064
R_VDD5_19197 METAL2_483000_1037000 METAL2_483000_1041000 0.032
R_VDD5_19198 METAL2_483000_1041000 METAL2_483000_1053000 0.096
R_VDD5_19199 METAL2_483000_1053000 METAL2_483000_1065000 0.096
R_VDD5_19200 METAL2_483000_1065000 METAL2_483000_1077000 0.096
R_VDD5_19201 METAL2_483000_1077000 METAL2_483000_1089000 0.096
R_VDD5_19202 METAL2_483000_1089000 METAL2_483000_1101000 0.096
R_VDD5_19203 METAL2_483000_1101000 METAL2_483000_1113000 0.096
R_VDD5_19204 METAL2_483000_1113000 METAL2_483000_1141000 0.224
R_VDD5_19205 METAL2_483000_1141000 METAL2_483000_1153000 0.096
R_VDD5_19206 METAL2_483000_1153000 METAL2_483000_1165000 0.096
R_VDD5_19207 METAL2_483000_1165000 METAL2_483000_1177000 0.096
R_VDD5_19208 METAL2_483000_1177000 METAL2_483000_1189000 0.096
R_VDD5_19209 METAL2_483000_1189000 METAL2_483000_1201000 0.096
R_VDD5_19210 METAL2_483000_1201000 METAL2_483000_1205000 0.032
R_VDD5_19211 METAL2_483000_1205000 METAL2_483000_1213000 0.064
R_VDD5_19212 METAL2_483000_1213000 METAL2_483000_1217000 0.032
R_VDD5_19213 METAL2_483000_1217000 METAL2_483000_1229000 0.096
R_VDD5_19214 METAL2_483000_1229000 METAL2_483000_1241000 0.096
R_VDD5_19215 METAL2_483000_1241000 METAL2_483000_1253000 0.096
R_VDD5_19216 METAL2_483000_1253000 METAL2_483000_1265000 0.096
R_VDD5_19217 METAL2_483000_1265000 METAL2_484000_1265000 0.008
R_VDD5_19218 METAL2_484000_1265000 METAL2_486000_1265000 0.016
R_VDD5_19219 METAL2_486000_1265000 METAL2_488000_1265000 0.016
R_VDD5_19220 METAL2_488000_1265000 METAL2_494000_1265000 0.048
R_VDD5_19221 METAL2_494000_1265000 METAL2_495000_1265000 0.008
R_VDD5_19222 METAL2_495000_1265000 METAL2_496000_1265000 0.008
R_VDD5_19223 METAL2_496000_1265000 METAL2_498000_1265000 0.016
R_VDD5_19224 METAL2_498000_1265000 METAL2_500000_1265000 0.016
R_VDD5_19225 METAL2_500000_1265000 METAL2_506000_1265000 0.048
R_VDD5_19226 METAL2_506000_1265000 METAL2_507000_1265000 0.008
R_VDD5_19227 METAL2_507000_1265000 METAL2_508000_1265000 0.008
R_VDD5_19228 METAL2_508000_1265000 METAL2_510000_1265000 0.016
R_VDD5_19229 METAL2_510000_1265000 METAL2_512000_1265000 0.016
R_VDD5_19230 METAL2_512000_1265000 METAL2_519000_1265000 0.056
R_VDD5_19231 METAL2_519000_1265000 METAL3_519000_1265000 0.1
R_VDD5_19232 METAL3_519000_1265000 METAL3_520000_1265000 0.008
R_VDD5_19233 METAL3_520000_1265000 METAL3_522000_1265000 0.016
R_VDD5_19234 METAL3_522000_1265000 METAL3_524000_1265000 0.016
R_VDD5_19235 METAL3_524000_1265000 METAL3_531000_1265000 0.056
R_VDD5_19236 METAL3_531000_1265000 METAL3_532000_1265000 0.008
R_VDD5_19237 METAL3_532000_1265000 METAL3_536000_1265000 0.032
R_VDD5_19238 METAL3_536000_1265000 METAL3_543000_1265000 0.056
R_VDD5_19239 METAL3_543000_1265000 METAL4_543000_1265000 0.1
R_VDD5_19240 METAL6_531000_20000 METAL6_532000_20000 0.002
R_VDD5_19241 METAL6_532000_20000 METAL6_536000_20000 0.008
R_VDD5_19242 METAL6_536000_20000 METAL6_543000_20000 0.014
R_VDD5_19243 METAL6_543000_20000 METAL6_543000_21000 0.002
R_VDD5_19244 METAL6_543000_21000 METAL6_543000_32000 0.022
R_VDD5_19245 METAL6_543000_32000 METAL6_543000_33000 0.002
R_VDD5_19246 METAL6_543000_33000 METAL5_543000_33000 0.1
R_VDD5_19247 METAL5_543000_33000 METAL4_543000_33000 0.1
R_VDD5_19248 METAL4_543000_33000 METAL3_543000_33000 0.1
R_VDD5_19249 METAL3_543000_33000 METAL2_543000_33000 0.1
R_VDD5_19250 METAL2_543000_33000 METAL2_543000_44000 0.088
R_VDD5_19251 METAL2_543000_44000 METAL2_543000_45000 0.008
R_VDD5_19252 METAL2_543000_45000 METAL2_543000_56000 0.088
R_VDD5_19253 METAL2_543000_56000 METAL2_543000_57000 0.008
R_VDD5_19254 METAL2_543000_57000 METAL2_543000_68000 0.088
R_VDD5_19255 METAL2_543000_68000 METAL2_543000_69000 0.008
R_VDD5_19256 METAL2_543000_69000 METAL2_543000_80000 0.088
R_VDD5_19257 METAL2_543000_80000 METAL2_543000_81000 0.008
R_VDD5_19258 METAL2_543000_81000 METAL2_543000_92000 0.088
R_VDD5_19259 METAL2_543000_92000 METAL2_543000_93000 0.008
R_VDD5_19260 METAL2_543000_93000 METAL2_543000_97000 0.032
R_VDD5_19261 METAL2_543000_97000 METAL2_543000_104000 0.056
R_VDD5_19262 METAL2_543000_104000 METAL2_536000_104000 0.056
R_VDD5_19263 METAL2_536000_104000 METAL2_532000_104000 0.032
R_VDD5_19264 METAL2_532000_104000 METAL2_532000_105000 0.008
R_VDD5_19265 METAL2_532000_105000 METAL2_532000_109000 0.032
R_VDD5_19266 METAL2_532000_109000 METAL2_532000_116000 0.056
R_VDD5_19267 METAL2_532000_116000 METAL2_532000_117000 0.008
R_VDD5_19268 METAL2_532000_117000 METAL2_532000_121000 0.032
R_VDD5_19269 METAL2_532000_121000 METAL2_532000_128000 0.056
R_VDD5_19270 METAL2_532000_128000 METAL2_531000_128000 0.008
R_VDD5_19271 METAL2_531000_128000 METAL2_531000_129000 0.008
R_VDD5_19272 METAL2_531000_129000 METAL2_531000_133000 0.032
R_VDD5_19273 METAL2_531000_133000 METAL2_531000_141000 0.064
R_VDD5_19274 METAL2_531000_141000 METAL2_531000_145000 0.032
R_VDD5_19275 METAL2_531000_145000 METAL2_531000_153000 0.064
R_VDD5_19276 METAL2_531000_153000 METAL2_531000_157000 0.032
R_VDD5_19277 METAL2_531000_157000 METAL2_531000_165000 0.064
R_VDD5_19278 METAL2_531000_165000 METAL2_531000_169000 0.032
R_VDD5_19279 METAL2_531000_169000 METAL2_531000_177000 0.064
R_VDD5_19280 METAL2_531000_177000 METAL2_531000_181000 0.032
R_VDD5_19281 METAL2_531000_181000 METAL2_531000_189000 0.064
R_VDD5_19282 METAL2_531000_189000 METAL2_531000_193000 0.032
R_VDD5_19283 METAL2_531000_193000 METAL2_531000_201000 0.064
R_VDD5_19284 METAL2_531000_201000 METAL2_531000_205000 0.032
R_VDD5_19285 METAL2_531000_205000 METAL2_531000_213000 0.064
R_VDD5_19286 METAL2_531000_213000 METAL2_531000_217000 0.032
R_VDD5_19287 METAL2_531000_217000 METAL2_531000_221000 0.032
R_VDD5_19288 METAL2_531000_221000 METAL2_531000_225000 0.032
R_VDD5_19289 METAL2_531000_225000 METAL2_531000_229000 0.032
R_VDD5_19290 METAL2_531000_229000 METAL2_531000_233000 0.032
R_VDD5_19291 METAL2_531000_233000 METAL2_531000_241000 0.064
R_VDD5_19292 METAL2_531000_241000 METAL2_531000_245000 0.032
R_VDD5_19293 METAL2_531000_245000 METAL2_531000_253000 0.064
R_VDD5_19294 METAL2_531000_253000 METAL2_531000_257000 0.032
R_VDD5_19295 METAL2_531000_257000 METAL1_531000_257000 0.1
R_VDD5_19296 METAL1_531000_257000 METAL1_531000_265000 0.064
R_VDD5_19297 METAL1_531000_265000 METAL1_531000_269000 0.032
R_VDD5_19298 METAL1_531000_269000 METAL1_531000_277000 0.064
R_VDD5_19299 METAL1_531000_277000 METAL1_531000_281000 0.032
R_VDD5_19300 METAL1_531000_281000 METAL1_531000_289000 0.064
R_VDD5_19301 METAL1_531000_289000 METAL1_531000_293000 0.032
R_VDD5_19302 METAL1_531000_293000 METAL1_531000_301000 0.064
R_VDD5_19303 METAL1_531000_301000 METAL1_531000_305000 0.032
R_VDD5_19304 METAL1_531000_305000 METAL1_531000_313000 0.064
R_VDD5_19305 METAL1_531000_313000 METAL1_531000_317000 0.032
R_VDD5_19306 METAL1_531000_317000 METAL1_531000_329000 0.096
R_VDD5_19307 METAL1_531000_329000 METAL1_531000_341000 0.096
R_VDD5_19308 METAL1_531000_341000 METAL1_531000_353000 0.096
R_VDD5_19309 METAL1_531000_353000 METAL1_531000_365000 0.096
R_VDD5_19310 METAL1_531000_365000 METAL1_531000_369000 0.032
R_VDD5_19311 METAL1_531000_369000 METAL1_531000_377000 0.064
R_VDD5_19312 METAL1_531000_377000 METAL1_531000_381000 0.032
R_VDD5_19313 METAL1_531000_381000 METAL1_531000_389000 0.064
R_VDD5_19314 METAL1_531000_389000 METAL1_531000_393000 0.032
R_VDD5_19315 METAL1_531000_393000 METAL1_531000_401000 0.064
R_VDD5_19316 METAL1_531000_401000 METAL1_531000_405000 0.032
R_VDD5_19317 METAL1_531000_405000 METAL1_531000_417000 0.096
R_VDD5_19318 METAL1_531000_417000 METAL1_531000_429000 0.096
R_VDD5_19319 METAL1_531000_429000 METAL1_531000_441000 0.096
R_VDD5_19320 METAL1_531000_441000 METAL1_531000_453000 0.096
R_VDD5_19321 METAL1_531000_453000 METAL1_531000_465000 0.096
R_VDD5_19322 METAL1_531000_465000 METAL1_531000_469000 0.032
R_VDD5_19323 METAL1_531000_469000 METAL1_531000_477000 0.064
R_VDD5_19324 METAL1_531000_477000 METAL1_531000_481000 0.032
R_VDD5_19325 METAL1_531000_481000 METAL1_531000_489000 0.064
R_VDD5_19326 METAL1_531000_489000 METAL1_531000_493000 0.032
R_VDD5_19327 METAL1_531000_493000 METAL1_531000_501000 0.064
R_VDD5_19328 METAL1_531000_501000 METAL1_531000_505000 0.032
R_VDD5_19329 METAL1_531000_505000 METAL1_531000_513000 0.064
R_VDD5_19330 METAL1_531000_513000 METAL1_531000_517000 0.032
R_VDD5_19331 METAL1_531000_517000 METAL1_531000_529000 0.096
R_VDD5_19332 METAL1_531000_529000 METAL1_531000_541000 0.096
R_VDD5_19333 METAL1_531000_541000 METAL1_531000_553000 0.096
R_VDD5_19334 METAL1_531000_553000 METAL1_531000_565000 0.096
R_VDD5_19335 METAL1_531000_565000 METAL1_531000_577000 0.096
R_VDD5_19336 METAL1_531000_577000 METAL1_531000_589000 0.096
R_VDD5_19337 METAL1_531000_589000 METAL1_531000_601000 0.096
R_VDD5_19338 METAL1_531000_601000 METAL1_531000_613000 0.096
R_VDD5_19339 METAL1_531000_613000 METAL1_531000_625000 0.096
R_VDD5_19340 METAL1_531000_625000 METAL1_531000_645000 0.16
R_VDD5_19341 METAL1_531000_645000 METAL1_531000_657000 0.096
R_VDD5_19342 METAL1_531000_657000 METAL1_531000_669000 0.096
R_VDD5_19343 METAL1_531000_669000 METAL1_531000_681000 0.096
R_VDD5_19344 METAL1_531000_681000 METAL1_531000_693000 0.096
R_VDD5_19345 METAL1_531000_693000 METAL1_531000_705000 0.096
R_VDD5_19346 METAL1_531000_705000 METAL1_531000_707000 0.016
R_VDD5_19347 METAL1_531000_707000 METAL1_531000_717000 0.08
R_VDD5_19348 METAL1_531000_717000 METAL1_531000_729000 0.096
R_VDD5_19349 METAL1_531000_729000 METAL1_531000_757000 0.224
R_VDD5_19350 METAL1_531000_757000 METAL1_531000_769000 0.096
R_VDD5_19351 METAL1_531000_769000 METAL1_531000_781000 0.096
R_VDD5_19352 METAL1_531000_781000 METAL1_531000_793000 0.096
R_VDD5_19353 METAL1_531000_793000 METAL1_531000_805000 0.096
R_VDD5_19354 METAL1_531000_805000 METAL1_531000_817000 0.096
R_VDD5_19355 METAL1_531000_817000 METAL1_531000_829000 0.096
R_VDD5_19356 METAL1_531000_829000 METAL1_531000_841000 0.096
R_VDD5_19357 METAL1_531000_841000 METAL1_531000_845000 0.032
R_VDD5_19358 METAL1_531000_845000 METAL1_531000_853000 0.064
R_VDD5_19359 METAL1_531000_853000 METAL1_531000_857000 0.032
R_VDD5_19360 METAL1_531000_857000 METAL1_531000_865000 0.064
R_VDD5_19361 METAL1_531000_865000 METAL1_531000_869000 0.032
R_VDD5_19362 METAL1_531000_869000 METAL1_531000_877000 0.064
R_VDD5_19363 METAL1_531000_877000 METAL1_531000_881000 0.032
R_VDD5_19364 METAL1_531000_881000 METAL1_531000_889000 0.064
R_VDD5_19365 METAL1_531000_889000 METAL1_531000_893000 0.032
R_VDD5_19366 METAL1_531000_893000 METAL1_531000_901000 0.064
R_VDD5_19367 METAL1_531000_901000 METAL1_531000_905000 0.032
R_VDD5_19368 METAL1_531000_905000 METAL1_531000_913000 0.064
R_VDD5_19369 METAL1_531000_913000 METAL1_531000_917000 0.032
R_VDD5_19370 METAL1_531000_917000 METAL1_531000_929000 0.096
R_VDD5_19371 METAL1_531000_929000 METAL1_531000_941000 0.096
R_VDD5_19372 METAL1_531000_941000 METAL1_531000_953000 0.096
R_VDD5_19373 METAL1_531000_953000 METAL1_531000_965000 0.096
R_VDD5_19374 METAL1_531000_965000 METAL1_531000_977000 0.096
R_VDD5_19375 METAL1_531000_977000 METAL1_531000_989000 0.096
R_VDD5_19376 METAL1_531000_989000 METAL1_531000_1001000 0.096
R_VDD5_19377 METAL1_531000_1001000 METAL1_531000_1013000 0.096
R_VDD5_19378 METAL1_531000_1013000 METAL1_531000_1025000 0.096
R_VDD5_19379 METAL1_531000_1025000 METAL1_531000_1029000 0.032
R_VDD5_19380 METAL1_531000_1029000 METAL1_531000_1037000 0.064
R_VDD5_19381 METAL1_531000_1037000 METAL1_531000_1041000 0.032
R_VDD5_19382 METAL1_531000_1041000 METAL1_531000_1053000 0.096
R_VDD5_19383 METAL1_531000_1053000 METAL1_531000_1065000 0.096
R_VDD5_19384 METAL1_531000_1065000 METAL1_531000_1077000 0.096
R_VDD5_19385 METAL1_531000_1077000 METAL1_531000_1089000 0.096
R_VDD5_19386 METAL1_531000_1089000 METAL1_531000_1101000 0.096
R_VDD5_19387 METAL1_531000_1101000 METAL1_531000_1113000 0.096
R_VDD5_19388 METAL1_531000_1113000 METAL1_531000_1141000 0.224
R_VDD5_19389 METAL1_531000_1141000 METAL1_531000_1153000 0.096
R_VDD5_19390 METAL1_531000_1153000 METAL1_531000_1165000 0.096
R_VDD5_19391 METAL1_531000_1165000 METAL1_531000_1177000 0.096
R_VDD5_19392 METAL1_531000_1177000 METAL1_531000_1189000 0.096
R_VDD5_19393 METAL1_531000_1189000 METAL1_531000_1201000 0.096
R_VDD5_19394 METAL1_531000_1201000 METAL1_531000_1205000 0.032
R_VDD5_19395 METAL1_531000_1205000 METAL1_531000_1213000 0.064
R_VDD5_19396 METAL1_531000_1213000 METAL1_531000_1217000 0.032
R_VDD5_19397 METAL1_531000_1217000 METAL1_531000_1229000 0.096
R_VDD5_19398 METAL1_531000_1229000 METAL1_531000_1241000 0.096
R_VDD5_19399 METAL1_531000_1241000 METAL1_531000_1253000 0.096
R_VDD5_19400 METAL1_531000_1253000 METAL1_531000_1265000 0.096
R_VDD5_19401 METAL1_531000_1265000 METAL1_531000_1277000 0.096
R_VDD5_19402 METAL1_531000_1277000 METAL1_531000_1289000 0.096
R_VDD5_19403 METAL1_531000_1289000 METAL1_531000_1301000 0.096
R_VDD5_19404 METAL1_531000_1301000 METAL1_531000_1321000 0.16
R_VDD5_19405 METAL1_531000_1321000 METAL1_531000_1333000 0.096
R_VDD5_19406 METAL1_531000_1333000 METAL1_531000_1345000 0.096
R_VDD5_19407 METAL1_531000_1345000 METAL1_531000_1357000 0.096
R_VDD5_19408 METAL1_531000_1357000 METAL1_531000_1369000 0.096
R_VDD5_19409 METAL1_531000_1369000 METAL1_531000_1381000 0.096
R_VDD5_19410 METAL1_531000_1381000 METAL1_531000_1393000 0.096
R_VDD5_19411 METAL1_531000_1393000 METAL1_531000_1405000 0.096
R_VDD5_19412 METAL1_531000_1405000 METAL1_531000_1407000 0.016
R_VDD5_19413 METAL1_531000_1407000 METAL1_531000_1417000 0.08
R_VDD5_19414 METAL1_531000_1417000 METAL2_531000_1417000 0.1
R_VDD5_19415 METAL2_531000_1417000 METAL2_531000_1429000 0.096
R_VDD5_19416 METAL2_531000_1429000 METAL2_531000_1493000 0.512
R_VDD5_19417 METAL2_531000_1493000 METAL2_531000_1505000 0.096
R_VDD5_19418 METAL2_531000_1505000 METAL2_531000_1517000 0.096
R_VDD5_19419 METAL2_531000_1517000 METAL2_531000_1529000 0.096
R_VDD5_19420 METAL2_531000_1529000 METAL2_531000_1541000 0.096
R_VDD5_19421 METAL2_531000_1541000 METAL2_531000_1553000 0.096
R_VDD5_19422 METAL2_531000_1553000 METAL2_531000_1565000 0.096
R_VDD5_19423 METAL2_531000_1565000 METAL2_531000_1577000 0.096
R_VDD5_19424 METAL2_531000_1577000 METAL2_531000_1589000 0.096
R_VDD5_19425 METAL2_531000_1589000 METAL2_531000_1605000 0.128
R_VDD5_19426 METAL2_531000_1605000 METAL3_531000_1605000 0.1
R_VDD5_19427 METAL3_531000_1605000 METAL3_531000_1617000 0.096
R_VDD5_19428 METAL3_531000_1617000 METAL3_531000_1629000 0.096
R_VDD5_19429 METAL3_531000_1629000 METAL3_531000_1641000 0.096
R_VDD5_19430 METAL3_531000_1641000 METAL3_531000_1653000 0.096
R_VDD5_19431 METAL3_531000_1653000 METAL3_531000_1665000 0.096
R_VDD5_19432 METAL3_531000_1665000 METAL3_531000_1677000 0.096
R_VDD5_19433 METAL3_531000_1677000 METAL3_531000_1689000 0.096
R_VDD5_19434 METAL3_531000_1689000 METAL3_531000_1701000 0.096
R_VDD5_19435 METAL3_531000_1701000 METAL3_531000_1753000 0.416
R_VDD5_19436 METAL3_531000_1753000 METAL3_531000_1765000 0.096
R_VDD5_19437 METAL3_531000_1765000 METAL3_531000_1777000 0.096
R_VDD5_19438 METAL3_531000_1777000 METAL3_531000_1789000 0.096
R_VDD5_19439 METAL3_531000_1789000 METAL3_531000_1793000 0.032
R_VDD5_19440 METAL3_531000_1793000 METAL3_531000_1801000 0.064
R_VDD5_19441 METAL3_531000_1801000 METAL4_531000_1801000 0.1
R_VDD5_19442 METAL4_531000_1801000 METAL4_531000_1805000 0.032
R_VDD5_19443 METAL4_531000_1805000 METAL4_531000_1817000 0.096
R_VDD5_19444 METAL4_531000_1817000 METAL4_531000_1829000 0.096
R_VDD5_19445 METAL4_531000_1829000 METAL4_531000_1841000 0.096
R_VDD5_19446 METAL4_531000_1841000 METAL4_531000_1853000 0.096
R_VDD5_19447 METAL4_531000_1853000 METAL4_531000_1865000 0.096
R_VDD5_19448 METAL4_531000_1865000 METAL4_531000_1877000 0.096
R_VDD5_19449 METAL4_531000_1877000 METAL4_532000_1877000 0.008
R_VDD5_19450 METAL4_532000_1877000 METAL4_536000_1877000 0.032
R_VDD5_19451 METAL4_536000_1877000 METAL4_543000_1877000 0.056
R_VDD5_19452 METAL4_543000_1877000 METAL5_543000_1877000 0.1
R_VDD5_19453 METAL5_543000_1877000 METAL5_543000_1905000 0.112
R_VDD5_19454 METAL5_543000_1905000 METAL5_543000_1917000 0.048
R_VDD5_19455 METAL5_543000_1917000 METAL5_543000_1929000 0.048
R_VDD5_19456 METAL5_543000_1929000 METAL4_543000_1929000 0.1
R_VDD5_19457 METAL4_543000_1929000 METAL4_543000_1941000 0.096
R_VDD5_19458 METAL4_543000_1941000 METAL4_543000_1953000 0.096
R_VDD5_19459 METAL4_543000_1953000 METAL5_543000_1953000 0.1
R_VDD5_19460 METAL5_543000_1953000 METAL5_543000_1965000 0.048
R_VDD5_19461 METAL5_543000_1965000 METAL6_543000_1965000 0.1
R_VDD5_19462 METAL6_531000_20000 METAL5_531000_20000 0.1
R_VDD5_19463 METAL5_531000_20000 METAL5_532000_20000 0.004
R_VDD5_19464 METAL5_532000_20000 METAL5_536000_20000 0.016
R_VDD5_19465 METAL5_536000_20000 METAL5_543000_20000 0.028
R_VDD5_19466 METAL5_543000_20000 METAL5_543000_21000 0.004
R_VDD5_19467 METAL5_543000_21000 METAL4_543000_21000 0.1
R_VDD5_19468 METAL4_543000_21000 METAL3_543000_21000 0.1
R_VDD5_19469 METAL3_543000_21000 METAL2_543000_21000 0.1
R_VDD5_19470 METAL2_543000_21000 METAL1_543000_21000 0.1
R_VDD5_19471 METAL1_543000_21000 METAL1_543000_32000 0.088
R_VDD5_19472 METAL1_543000_32000 METAL1_543000_33000 0.008
R_VDD5_19473 METAL1_543000_33000 METAL1_543000_44000 0.088
R_VDD5_19474 METAL1_543000_44000 METAL1_543000_45000 0.008
R_VDD5_19475 METAL1_543000_45000 METAL1_543000_56000 0.088
R_VDD5_19476 METAL1_543000_56000 METAL1_543000_57000 0.008
R_VDD5_19477 METAL1_543000_57000 METAL1_543000_68000 0.088
R_VDD5_19478 METAL1_543000_68000 METAL1_543000_69000 0.008
R_VDD5_19479 METAL1_543000_69000 METAL1_543000_80000 0.088
R_VDD5_19480 METAL1_543000_80000 METAL1_543000_81000 0.008
R_VDD5_19481 METAL1_543000_81000 METAL1_543000_92000 0.088
R_VDD5_19482 METAL1_543000_92000 METAL1_543000_93000 0.008
R_VDD5_19483 METAL1_543000_93000 METAL1_543000_97000 0.032
R_VDD5_19484 METAL1_543000_97000 METAL1_543000_104000 0.056
R_VDD5_19485 METAL1_543000_104000 METAL1_543000_105000 0.008
R_VDD5_19486 METAL1_543000_105000 METAL1_543000_109000 0.032
R_VDD5_19487 METAL1_543000_109000 METAL1_543000_116000 0.056
R_VDD5_19488 METAL1_543000_116000 METAL1_543000_117000 0.008
R_VDD5_19489 METAL1_543000_117000 METAL1_543000_121000 0.032
R_VDD5_19490 METAL1_543000_121000 METAL1_543000_128000 0.056
R_VDD5_19491 METAL1_543000_128000 METAL1_543000_129000 0.008
R_VDD5_19492 METAL1_543000_129000 METAL1_543000_133000 0.032
R_VDD5_19493 METAL1_543000_133000 METAL1_543000_140000 0.056
R_VDD5_19494 METAL1_543000_140000 METAL2_543000_140000 0.1
R_VDD5_19495 METAL2_543000_140000 METAL3_543000_140000 0.1
R_VDD5_19496 METAL3_543000_140000 METAL3_543000_133000 0.056
R_VDD5_19497 METAL3_543000_133000 METAL3_536000_133000 0.056
R_VDD5_19498 METAL3_536000_133000 METAL3_536000_129000 0.032
R_VDD5_19499 METAL3_536000_129000 METAL3_532000_129000 0.032
R_VDD5_19500 METAL3_532000_129000 METAL3_532000_128000 0.008
R_VDD5_19501 METAL3_532000_128000 METAL3_532000_121000 0.056
R_VDD5_19502 METAL3_532000_121000 METAL3_532000_117000 0.032
R_VDD5_19503 METAL3_532000_117000 METAL3_532000_116000 0.008
R_VDD5_19504 METAL3_532000_116000 METAL3_532000_109000 0.056
R_VDD5_19505 METAL3_532000_109000 METAL3_532000_105000 0.032
R_VDD5_19506 METAL3_532000_105000 METAL3_532000_104000 0.008
R_VDD5_19507 METAL3_532000_104000 METAL3_532000_97000 0.056
R_VDD5_19508 METAL3_532000_97000 METAL3_532000_93000 0.032
R_VDD5_19509 METAL3_532000_93000 METAL3_532000_92000 0.008
R_VDD5_19510 METAL3_532000_92000 METAL3_532000_81000 0.088
R_VDD5_19511 METAL3_532000_81000 METAL3_532000_80000 0.008
R_VDD5_19512 METAL3_532000_80000 METAL3_532000_69000 0.088
R_VDD5_19513 METAL3_532000_69000 METAL3_532000_68000 0.008
R_VDD5_19514 METAL3_532000_68000 METAL4_532000_68000 0.1
R_VDD5_19515 METAL4_532000_68000 METAL4_531000_68000 0.008
R_VDD5_19516 METAL4_531000_68000 METAL4_524000_68000 0.056
R_VDD5_19517 METAL4_524000_68000 METAL4_522000_68000 0.016
R_VDD5_19518 METAL4_522000_68000 METAL4_520000_68000 0.016
R_VDD5_19519 METAL4_520000_68000 METAL4_519000_68000 0.008
R_VDD5_19520 METAL4_519000_68000 METAL4_512000_68000 0.056
R_VDD5_19521 METAL4_512000_68000 METAL4_510000_68000 0.016
R_VDD5_19522 METAL4_510000_68000 METAL4_508000_68000 0.016
R_VDD5_19523 METAL4_508000_68000 METAL4_507000_68000 0.008
R_VDD5_19524 METAL4_507000_68000 METAL4_506000_68000 0.008
R_VDD5_19525 METAL4_506000_68000 METAL4_500000_68000 0.048
R_VDD5_19526 METAL4_500000_68000 METAL4_498000_68000 0.016
R_VDD5_19527 METAL4_498000_68000 METAL4_496000_68000 0.016
R_VDD5_19528 METAL4_496000_68000 METAL4_495000_68000 0.008
R_VDD5_19529 METAL4_495000_68000 METAL4_494000_68000 0.008
R_VDD5_19530 METAL4_494000_68000 METAL4_488000_68000 0.048
R_VDD5_19531 METAL4_488000_68000 METAL4_486000_68000 0.016
R_VDD5_19532 METAL4_486000_68000 METAL4_484000_68000 0.016
R_VDD5_19533 METAL4_484000_68000 METAL4_483000_68000 0.008
R_VDD5_19534 METAL4_483000_68000 METAL4_482000_68000 0.008
R_VDD5_19535 METAL4_482000_68000 METAL4_476000_68000 0.048
R_VDD5_19536 METAL4_476000_68000 METAL4_474000_68000 0.016
R_VDD5_19537 METAL4_474000_68000 METAL4_472000_68000 0.016
R_VDD5_19538 METAL4_472000_68000 METAL4_471000_68000 0.008
R_VDD5_19539 METAL4_471000_68000 METAL4_470000_68000 0.008
R_VDD5_19540 METAL4_470000_68000 METAL4_464000_68000 0.048
R_VDD5_19541 METAL4_464000_68000 METAL4_462000_68000 0.016
R_VDD5_19542 METAL4_462000_68000 METAL4_460000_68000 0.016
R_VDD5_19543 METAL4_460000_68000 METAL4_458000_68000 0.016
R_VDD5_19544 METAL4_458000_68000 METAL5_458000_68000 0.1
R_VDD5_19545 METAL5_458000_68000 METAL5_458000_69000 0.004
R_VDD5_19546 METAL5_458000_69000 METAL5_458000_80000 0.044
R_VDD5_19547 METAL5_458000_80000 METAL5_458000_81000 0.004
R_VDD5_19548 METAL5_458000_81000 METAL5_458000_92000 0.044
R_VDD5_19549 METAL5_458000_92000 METAL5_458000_93000 0.004
R_VDD5_19550 METAL5_458000_93000 METAL5_458000_97000 0.016
R_VDD5_19551 METAL5_458000_97000 METAL5_458000_104000 0.028
R_VDD5_19552 METAL5_458000_104000 METAL5_458000_105000 0.004
R_VDD5_19553 METAL5_458000_105000 METAL4_458000_105000 0.1
R_VDD5_19554 METAL4_458000_105000 METAL3_458000_105000 0.1
R_VDD5_19555 METAL3_458000_105000 METAL2_458000_105000 0.1
R_VDD5_19556 METAL2_458000_105000 METAL2_458000_109000 0.032
R_VDD5_19557 METAL2_458000_109000 METAL2_458000_116000 0.056
R_VDD5_19558 METAL2_458000_116000 METAL2_460000_116000 0.016
R_VDD5_19559 METAL2_460000_116000 METAL2_462000_116000 0.016
R_VDD5_19560 METAL2_462000_116000 METAL2_464000_116000 0.016
R_VDD5_19561 METAL2_464000_116000 METAL2_470000_116000 0.048
R_VDD5_19562 METAL2_470000_116000 METAL2_471000_116000 0.008
R_VDD5_19563 METAL2_471000_116000 METAL2_471000_117000 0.008
R_VDD5_19564 METAL2_471000_117000 METAL2_471000_121000 0.032
R_VDD5_19565 METAL2_471000_121000 METAL2_471000_128000 0.056
R_VDD5_19566 METAL2_471000_128000 METAL2_471000_129000 0.008
R_VDD5_19567 METAL2_471000_129000 METAL2_471000_133000 0.032
R_VDD5_19568 METAL2_471000_133000 METAL2_471000_140000 0.056
R_VDD5_19569 METAL2_471000_140000 METAL2_471000_141000 0.008
R_VDD5_19570 METAL2_471000_141000 METAL2_471000_145000 0.032
R_VDD5_19571 METAL2_471000_145000 METAL2_471000_153000 0.064
R_VDD5_19572 METAL2_471000_153000 METAL2_471000_157000 0.032
R_VDD5_19573 METAL2_471000_157000 METAL2_471000_165000 0.064
R_VDD5_19574 METAL2_471000_165000 METAL2_471000_169000 0.032
R_VDD5_19575 METAL2_471000_169000 METAL2_471000_177000 0.064
R_VDD5_19576 METAL2_471000_177000 METAL2_471000_181000 0.032
R_VDD5_19577 METAL2_471000_181000 METAL2_471000_189000 0.064
R_VDD5_19578 METAL2_471000_189000 METAL2_471000_193000 0.032
R_VDD5_19579 METAL2_471000_193000 METAL2_471000_201000 0.064
R_VDD5_19580 METAL2_471000_201000 METAL2_471000_205000 0.032
R_VDD5_19581 METAL2_471000_205000 METAL2_471000_213000 0.064
R_VDD5_19582 METAL2_471000_213000 METAL2_471000_217000 0.032
R_VDD5_19583 METAL2_471000_217000 METAL2_471000_221000 0.032
R_VDD5_19584 METAL2_471000_221000 METAL2_471000_225000 0.032
R_VDD5_19585 METAL2_471000_225000 METAL2_471000_229000 0.032
R_VDD5_19586 METAL2_471000_229000 METAL2_471000_233000 0.032
R_VDD5_19587 METAL2_471000_233000 METAL2_471000_241000 0.064
R_VDD5_19588 METAL2_471000_241000 METAL2_471000_245000 0.032
R_VDD5_19589 METAL2_471000_245000 METAL2_471000_253000 0.064
R_VDD5_19590 METAL2_471000_253000 METAL2_471000_257000 0.032
R_VDD5_19591 METAL2_471000_257000 METAL2_471000_265000 0.064
R_VDD5_19592 METAL2_471000_265000 METAL2_471000_269000 0.032
R_VDD5_19593 METAL2_471000_269000 METAL2_471000_277000 0.064
R_VDD5_19594 METAL2_471000_277000 METAL2_471000_281000 0.032
R_VDD5_19595 METAL2_471000_281000 METAL2_471000_289000 0.064
R_VDD5_19596 METAL2_471000_289000 METAL2_471000_293000 0.032
R_VDD5_19597 METAL2_471000_293000 METAL2_471000_301000 0.064
R_VDD5_19598 METAL2_471000_301000 METAL2_471000_305000 0.032
R_VDD5_19599 METAL2_471000_305000 METAL2_471000_313000 0.064
R_VDD5_19600 METAL2_471000_313000 METAL2_471000_317000 0.032
R_VDD5_19601 METAL2_471000_317000 METAL2_471000_329000 0.096
R_VDD5_19602 METAL2_471000_329000 METAL2_471000_341000 0.096
R_VDD5_19603 METAL2_471000_341000 METAL2_471000_353000 0.096
R_VDD5_19604 METAL2_471000_353000 METAL2_471000_365000 0.096
R_VDD5_19605 METAL2_471000_365000 METAL2_471000_369000 0.032
R_VDD5_19606 METAL2_471000_369000 METAL2_471000_377000 0.064
R_VDD5_19607 METAL2_471000_377000 METAL2_471000_381000 0.032
R_VDD5_19608 METAL2_471000_381000 METAL2_471000_389000 0.064
R_VDD5_19609 METAL2_471000_389000 METAL2_471000_393000 0.032
R_VDD5_19610 METAL2_471000_393000 METAL2_471000_401000 0.064
R_VDD5_19611 METAL2_471000_401000 METAL2_471000_405000 0.032
R_VDD5_19612 METAL2_471000_405000 METAL2_471000_417000 0.096
R_VDD5_19613 METAL2_471000_417000 METAL2_471000_429000 0.096
R_VDD5_19614 METAL2_471000_429000 METAL2_471000_441000 0.096
R_VDD5_19615 METAL2_471000_441000 METAL2_471000_453000 0.096
R_VDD5_19616 METAL2_471000_453000 METAL2_471000_465000 0.096
R_VDD5_19617 METAL2_471000_465000 METAL2_471000_469000 0.032
R_VDD5_19618 METAL2_471000_469000 METAL2_471000_477000 0.064
R_VDD5_19619 METAL2_471000_477000 METAL2_471000_481000 0.032
R_VDD5_19620 METAL2_471000_481000 METAL2_471000_489000 0.064
R_VDD5_19621 METAL2_471000_489000 METAL2_471000_493000 0.032
R_VDD5_19622 METAL2_471000_493000 METAL2_471000_501000 0.064
R_VDD5_19623 METAL2_471000_501000 METAL2_471000_505000 0.032
R_VDD5_19624 METAL2_471000_505000 METAL2_471000_513000 0.064
R_VDD5_19625 METAL2_471000_513000 METAL2_471000_517000 0.032
R_VDD5_19626 METAL2_471000_517000 METAL2_471000_529000 0.096
R_VDD5_19627 METAL2_471000_529000 METAL2_471000_541000 0.096
R_VDD5_19628 METAL2_471000_541000 METAL2_471000_553000 0.096
R_VDD5_19629 METAL2_471000_553000 METAL2_471000_565000 0.096
R_VDD5_19630 METAL2_471000_565000 METAL2_471000_577000 0.096
R_VDD5_19631 METAL2_471000_577000 METAL2_471000_589000 0.096
R_VDD5_19632 METAL2_471000_589000 METAL2_471000_601000 0.096
R_VDD5_19633 METAL2_471000_601000 METAL2_471000_613000 0.096
R_VDD5_19634 METAL2_471000_613000 METAL2_471000_625000 0.096
R_VDD5_19635 METAL2_471000_625000 METAL2_471000_645000 0.16
R_VDD5_19636 METAL2_471000_645000 METAL2_471000_657000 0.096
R_VDD5_19637 METAL2_471000_657000 METAL2_471000_669000 0.096
R_VDD5_19638 METAL2_471000_669000 METAL2_471000_681000 0.096
R_VDD5_19639 METAL2_471000_681000 METAL2_471000_693000 0.096
R_VDD5_19640 METAL2_471000_693000 METAL2_471000_705000 0.096
R_VDD5_19641 METAL2_471000_705000 METAL2_471000_707000 0.016
R_VDD5_19642 METAL2_471000_707000 METAL2_471000_717000 0.08
R_VDD5_19643 METAL2_471000_717000 METAL2_471000_729000 0.096
R_VDD5_19644 METAL2_471000_729000 METAL2_471000_757000 0.224
R_VDD5_19645 METAL2_471000_757000 METAL2_471000_769000 0.096
R_VDD5_19646 METAL2_471000_769000 METAL2_471000_781000 0.096
R_VDD5_19647 METAL2_471000_781000 METAL2_471000_793000 0.096
R_VDD5_19648 METAL2_471000_793000 METAL2_471000_805000 0.096
R_VDD5_19649 METAL2_471000_805000 METAL2_471000_817000 0.096
R_VDD5_19650 METAL2_471000_817000 METAL2_471000_829000 0.096
R_VDD5_19651 METAL2_471000_829000 METAL2_471000_841000 0.096
R_VDD5_19652 METAL2_471000_841000 METAL2_471000_845000 0.032
R_VDD5_19653 METAL2_471000_845000 METAL2_471000_853000 0.064
R_VDD5_19654 METAL2_471000_853000 METAL2_471000_857000 0.032
R_VDD5_19655 METAL2_471000_857000 METAL2_471000_865000 0.064
R_VDD5_19656 METAL2_471000_865000 METAL2_471000_869000 0.032
R_VDD5_19657 METAL2_471000_869000 METAL2_471000_877000 0.064
R_VDD5_19658 METAL2_471000_877000 METAL2_471000_881000 0.032
R_VDD5_19659 METAL2_471000_881000 METAL2_471000_889000 0.064
R_VDD5_19660 METAL2_471000_889000 METAL2_471000_893000 0.032
R_VDD5_19661 METAL2_471000_893000 METAL2_471000_901000 0.064
R_VDD5_19662 METAL2_471000_901000 METAL2_471000_905000 0.032
R_VDD5_19663 METAL2_471000_905000 METAL2_471000_913000 0.064
R_VDD5_19664 METAL2_471000_913000 METAL2_471000_917000 0.032
R_VDD5_19665 METAL2_471000_917000 METAL2_471000_929000 0.096
R_VDD5_19666 METAL2_471000_929000 METAL2_471000_941000 0.096
R_VDD5_19667 METAL2_471000_941000 METAL2_471000_953000 0.096
R_VDD5_19668 METAL2_471000_953000 METAL2_471000_965000 0.096
R_VDD5_19669 METAL2_471000_965000 METAL2_471000_977000 0.096
R_VDD5_19670 METAL2_471000_977000 METAL2_471000_989000 0.096
R_VDD5_19671 METAL2_471000_989000 METAL2_471000_1001000 0.096
R_VDD5_19672 METAL2_471000_1001000 METAL2_471000_1013000 0.096
R_VDD5_19673 METAL2_471000_1013000 METAL2_471000_1025000 0.096
R_VDD5_19674 METAL2_471000_1025000 METAL2_471000_1029000 0.032
R_VDD5_19675 METAL2_471000_1029000 METAL2_471000_1037000 0.064
R_VDD5_19676 METAL2_471000_1037000 METAL2_471000_1041000 0.032
R_VDD5_19677 METAL2_471000_1041000 METAL2_471000_1053000 0.096
R_VDD5_19678 METAL2_471000_1053000 METAL2_471000_1065000 0.096
R_VDD5_19679 METAL2_471000_1065000 METAL2_471000_1077000 0.096
R_VDD5_19680 METAL2_471000_1077000 METAL2_471000_1089000 0.096
R_VDD5_19681 METAL2_471000_1089000 METAL2_471000_1101000 0.096
R_VDD5_19682 METAL2_471000_1101000 METAL2_471000_1113000 0.096
R_VDD5_19683 METAL2_471000_1113000 METAL2_471000_1141000 0.224
R_VDD5_19684 METAL2_471000_1141000 METAL2_471000_1153000 0.096
R_VDD5_19685 METAL2_471000_1153000 METAL2_471000_1165000 0.096
R_VDD5_19686 METAL2_471000_1165000 METAL2_471000_1177000 0.096
R_VDD5_19687 METAL2_471000_1177000 METAL2_471000_1189000 0.096
R_VDD5_19688 METAL2_471000_1189000 METAL2_471000_1201000 0.096
R_VDD5_19689 METAL2_471000_1201000 METAL2_471000_1205000 0.032
R_VDD5_19690 METAL2_471000_1205000 METAL2_471000_1213000 0.064
R_VDD5_19691 METAL2_471000_1213000 METAL2_471000_1217000 0.032
R_VDD5_19692 METAL2_471000_1217000 METAL2_471000_1229000 0.096
R_VDD5_19693 METAL2_471000_1229000 METAL2_471000_1241000 0.096
R_VDD5_19694 METAL2_471000_1241000 METAL2_471000_1253000 0.096
R_VDD5_19695 METAL2_471000_1253000 METAL2_471000_1265000 0.096
R_VDD5_19696 METAL2_471000_1265000 METAL2_471000_1277000 0.096
R_VDD5_19697 METAL2_471000_1277000 METAL2_471000_1289000 0.096
R_VDD5_19698 METAL2_471000_1289000 METAL2_471000_1301000 0.096
R_VDD5_19699 METAL2_471000_1301000 METAL2_471000_1321000 0.16
R_VDD5_19700 METAL2_471000_1321000 METAL2_471000_1333000 0.096
R_VDD5_19701 METAL2_471000_1333000 METAL2_471000_1345000 0.096
R_VDD5_19702 METAL2_471000_1345000 METAL2_471000_1357000 0.096
R_VDD5_19703 METAL2_471000_1357000 METAL2_471000_1369000 0.096
R_VDD5_19704 METAL2_471000_1369000 METAL2_471000_1381000 0.096
R_VDD5_19705 METAL2_471000_1381000 METAL2_471000_1393000 0.096
R_VDD5_19706 METAL2_471000_1393000 METAL2_471000_1405000 0.096
R_VDD5_19707 METAL2_471000_1405000 METAL2_471000_1407000 0.016
R_VDD5_19708 METAL2_471000_1407000 METAL2_471000_1417000 0.08
R_VDD5_19709 METAL2_471000_1417000 METAL2_471000_1429000 0.096
R_VDD5_19710 METAL2_471000_1429000 METAL2_471000_1493000 0.512
R_VDD5_19711 METAL2_471000_1493000 METAL2_471000_1505000 0.096
R_VDD5_19712 METAL2_471000_1505000 METAL2_471000_1517000 0.096
R_VDD5_19713 METAL2_471000_1517000 METAL2_471000_1529000 0.096
R_VDD5_19714 METAL2_471000_1529000 METAL2_471000_1541000 0.096
R_VDD5_19715 METAL2_471000_1541000 METAL2_471000_1553000 0.096
R_VDD5_19716 METAL2_471000_1553000 METAL2_471000_1565000 0.096
R_VDD5_19717 METAL2_471000_1565000 METAL2_471000_1577000 0.096
R_VDD5_19718 METAL2_471000_1577000 METAL2_471000_1589000 0.096
R_VDD5_19719 METAL2_471000_1589000 METAL2_471000_1593000 0.032
R_VDD5_19720 METAL2_471000_1593000 METAL2_471000_1605000 0.096
R_VDD5_19721 METAL2_471000_1605000 METAL2_471000_1617000 0.096
R_VDD5_19722 METAL2_471000_1617000 METAL2_471000_1629000 0.096
R_VDD5_19723 METAL2_471000_1629000 METAL2_471000_1641000 0.096
R_VDD5_19724 METAL2_471000_1641000 METAL2_471000_1653000 0.096
R_VDD5_19725 METAL2_471000_1653000 METAL2_471000_1665000 0.096
R_VDD5_19726 METAL2_471000_1665000 METAL2_471000_1677000 0.096
R_VDD5_19727 METAL2_471000_1677000 METAL2_471000_1689000 0.096
R_VDD5_19728 METAL2_471000_1689000 METAL2_471000_1701000 0.096
R_VDD5_19729 METAL2_471000_1701000 METAL2_471000_1753000 0.416
R_VDD5_19730 METAL2_471000_1753000 METAL2_471000_1765000 0.096
R_VDD5_19731 METAL2_471000_1765000 METAL2_471000_1777000 0.096
R_VDD5_19732 METAL2_471000_1777000 METAL2_471000_1789000 0.096
R_VDD5_19733 METAL2_471000_1789000 METAL2_471000_1793000 0.032
R_VDD5_19734 METAL2_471000_1793000 METAL2_471000_1801000 0.064
R_VDD5_19735 METAL2_471000_1801000 METAL2_471000_1805000 0.032
R_VDD5_19736 METAL2_471000_1805000 METAL2_471000_1813000 0.064
R_VDD5_19737 METAL2_471000_1813000 METAL2_471000_1817000 0.032
R_VDD5_19738 METAL2_471000_1817000 METAL2_471000_1829000 0.096
R_VDD5_19739 METAL2_471000_1829000 METAL2_471000_1841000 0.096
R_VDD5_19740 METAL2_471000_1841000 METAL2_471000_1853000 0.096
R_VDD5_19741 METAL2_471000_1853000 METAL2_471000_1865000 0.096
R_VDD5_19742 METAL2_471000_1865000 METAL2_471000_1877000 0.096
R_VDD5_19743 METAL2_471000_1877000 METAL2_471000_1889000 0.096
R_VDD5_19744 METAL2_471000_1889000 METAL2_471000_1905000 0.128
R_VDD5_19745 METAL2_471000_1905000 METAL2_471000_1917000 0.096
R_VDD5_19746 METAL2_471000_1917000 METAL2_471000_1929000 0.096
R_VDD5_19747 METAL2_471000_1929000 METAL2_471000_1941000 0.096
R_VDD5_19748 METAL2_471000_1941000 METAL2_471000_1953000 0.096
R_VDD5_19749 METAL2_471000_1953000 METAL2_471000_1965000 0.096
R_VDD5_19750 METAL2_471000_1965000 METAL2_472000_1965000 0.008
R_VDD5_19751 METAL2_472000_1965000 METAL2_474000_1965000 0.016
R_VDD5_19752 METAL2_474000_1965000 METAL2_476000_1965000 0.016
R_VDD5_19753 METAL2_476000_1965000 METAL2_482000_1965000 0.048
R_VDD5_19754 METAL2_482000_1965000 METAL2_483000_1965000 0.008
R_VDD5_19755 METAL2_483000_1965000 METAL2_484000_1965000 0.008
R_VDD5_19756 METAL2_484000_1965000 METAL2_486000_1965000 0.016
R_VDD5_19757 METAL2_486000_1965000 METAL2_488000_1965000 0.016
R_VDD5_19758 METAL2_488000_1965000 METAL2_494000_1965000 0.048
R_VDD5_19759 METAL2_494000_1965000 METAL2_495000_1965000 0.008
R_VDD5_19760 METAL2_495000_1965000 METAL2_496000_1965000 0.008
R_VDD5_19761 METAL2_496000_1965000 METAL2_498000_1965000 0.016
R_VDD5_19762 METAL2_498000_1965000 METAL2_500000_1965000 0.016
R_VDD5_19763 METAL2_500000_1965000 METAL2_506000_1965000 0.048
R_VDD5_19764 METAL2_506000_1965000 METAL2_507000_1965000 0.008
R_VDD5_19765 METAL2_507000_1965000 METAL2_508000_1965000 0.008
R_VDD5_19766 METAL2_508000_1965000 METAL2_510000_1965000 0.016
R_VDD5_19767 METAL2_510000_1965000 METAL2_512000_1965000 0.016
R_VDD5_19768 METAL2_512000_1965000 METAL2_519000_1965000 0.056
R_VDD5_19769 METAL2_519000_1965000 METAL3_519000_1965000 0.1
R_VDD5_19770 METAL3_519000_1965000 METAL3_520000_1965000 0.008
R_VDD5_19771 METAL3_520000_1965000 METAL3_522000_1965000 0.016
R_VDD5_19772 METAL3_522000_1965000 METAL3_524000_1965000 0.016
R_VDD5_19773 METAL3_524000_1965000 METAL3_531000_1965000 0.056
R_VDD5_19774 METAL3_531000_1965000 METAL3_532000_1965000 0.008
R_VDD5_19775 METAL3_532000_1965000 METAL3_536000_1965000 0.032
R_VDD5_19776 METAL3_536000_1965000 METAL3_543000_1965000 0.056
R_VDD5_19777 METAL3_543000_1965000 METAL4_543000_1965000 0.1
R_VDD5_19778 METAL4_543000_1965000 METAL5_543000_1965000 0.1
R_VDD5_19779 METAL6_531000_277000 METAL6_532000_277000 0.002
R_VDD5_19780 METAL6_532000_277000 METAL6_536000_277000 0.008
R_VDD5_19781 METAL6_536000_277000 METAL6_543000_277000 0.014
R_VDD5_19782 METAL6_543000_277000 METAL6_543000_281000 0.008
R_VDD5_19783 METAL6_543000_281000 METAL5_543000_281000 0.1
R_VDD5_19784 METAL5_543000_281000 METAL4_543000_281000 0.1
R_VDD5_19785 METAL4_543000_281000 METAL3_543000_281000 0.1
R_VDD5_19786 METAL3_543000_281000 METAL2_543000_281000 0.1
R_VDD5_19787 METAL2_543000_281000 METAL2_543000_289000 0.064
R_VDD5_19788 METAL2_543000_289000 METAL2_536000_289000 0.056
R_VDD5_19789 METAL2_536000_289000 METAL2_532000_289000 0.032
R_VDD5_19790 METAL2_532000_289000 METAL2_532000_293000 0.032
R_VDD5_19791 METAL2_532000_293000 METAL2_532000_301000 0.064
R_VDD5_19792 METAL2_532000_301000 METAL2_532000_305000 0.032
R_VDD5_19793 METAL2_532000_305000 METAL2_532000_313000 0.064
R_VDD5_19794 METAL2_532000_313000 METAL2_532000_317000 0.032
R_VDD5_19795 METAL2_532000_317000 METAL2_532000_329000 0.096
R_VDD5_19796 METAL2_532000_329000 METAL2_532000_341000 0.096
R_VDD5_19797 METAL2_532000_341000 METAL2_532000_353000 0.096
R_VDD5_19798 METAL2_532000_353000 METAL2_531000_353000 0.008
R_VDD5_19799 METAL2_531000_353000 METAL2_531000_365000 0.096
R_VDD5_19800 METAL2_531000_365000 METAL2_531000_369000 0.032
R_VDD5_19801 METAL2_531000_369000 METAL2_531000_377000 0.064
R_VDD5_19802 METAL2_531000_377000 METAL2_531000_381000 0.032
R_VDD5_19803 METAL2_531000_381000 METAL2_531000_389000 0.064
R_VDD5_19804 METAL2_531000_389000 METAL2_531000_393000 0.032
R_VDD5_19805 METAL2_531000_393000 METAL2_531000_401000 0.064
R_VDD5_19806 METAL2_531000_401000 METAL2_531000_405000 0.032
R_VDD5_19807 METAL2_531000_405000 METAL2_531000_417000 0.096
R_VDD5_19808 METAL2_531000_417000 METAL2_531000_429000 0.096
R_VDD5_19809 METAL2_531000_429000 METAL2_531000_441000 0.096
R_VDD5_19810 METAL2_531000_441000 METAL2_531000_453000 0.096
R_VDD5_19811 METAL2_531000_453000 METAL2_531000_465000 0.096
R_VDD5_19812 METAL2_531000_465000 METAL2_531000_469000 0.032
R_VDD5_19813 METAL2_531000_469000 METAL2_531000_477000 0.064
R_VDD5_19814 METAL2_531000_477000 METAL2_531000_481000 0.032
R_VDD5_19815 METAL2_531000_481000 METAL2_531000_489000 0.064
R_VDD5_19816 METAL2_531000_489000 METAL2_531000_493000 0.032
R_VDD5_19817 METAL2_531000_493000 METAL2_531000_501000 0.064
R_VDD5_19818 METAL2_531000_501000 METAL2_531000_505000 0.032
R_VDD5_19819 METAL2_531000_505000 METAL2_531000_513000 0.064
R_VDD5_19820 METAL2_531000_513000 METAL2_531000_517000 0.032
R_VDD5_19821 METAL2_531000_517000 METAL2_531000_529000 0.096
R_VDD5_19822 METAL2_531000_529000 METAL2_531000_541000 0.096
R_VDD5_19823 METAL2_531000_541000 METAL2_531000_553000 0.096
R_VDD5_19824 METAL2_531000_553000 METAL2_531000_565000 0.096
R_VDD5_19825 METAL2_531000_565000 METAL2_531000_577000 0.096
R_VDD5_19826 METAL2_531000_577000 METAL2_531000_589000 0.096
R_VDD5_19827 METAL2_531000_589000 METAL2_531000_601000 0.096
R_VDD5_19828 METAL2_531000_601000 METAL2_531000_613000 0.096
R_VDD5_19829 METAL2_531000_613000 METAL2_531000_625000 0.096
R_VDD5_19830 METAL2_531000_625000 METAL2_531000_645000 0.16
R_VDD5_19831 METAL2_531000_645000 METAL2_531000_657000 0.096
R_VDD5_19832 METAL2_531000_657000 METAL2_531000_669000 0.096
R_VDD5_19833 METAL2_531000_669000 METAL2_531000_681000 0.096
R_VDD5_19834 METAL2_531000_681000 METAL2_531000_693000 0.096
R_VDD5_19835 METAL2_531000_693000 METAL2_531000_705000 0.096
R_VDD5_19836 METAL2_531000_705000 METAL2_531000_707000 0.016
R_VDD5_19837 METAL2_531000_707000 METAL2_531000_717000 0.08
R_VDD5_19838 METAL2_531000_717000 METAL2_531000_729000 0.096
R_VDD5_19839 METAL2_531000_729000 METAL2_531000_757000 0.224
R_VDD5_19840 METAL2_531000_757000 METAL2_531000_769000 0.096
R_VDD5_19841 METAL2_531000_769000 METAL2_531000_781000 0.096
R_VDD5_19842 METAL2_531000_781000 METAL2_531000_793000 0.096
R_VDD5_19843 METAL2_531000_793000 METAL2_531000_805000 0.096
R_VDD5_19844 METAL2_531000_805000 METAL2_531000_817000 0.096
R_VDD5_19845 METAL2_531000_817000 METAL2_531000_829000 0.096
R_VDD5_19846 METAL2_531000_829000 METAL2_524000_829000 0.056
R_VDD5_19847 METAL2_524000_829000 METAL2_522000_829000 0.016
R_VDD5_19848 METAL2_522000_829000 METAL2_520000_829000 0.016
R_VDD5_19849 METAL2_520000_829000 METAL2_519000_829000 0.008
R_VDD5_19850 METAL2_519000_829000 METAL1_519000_829000 0.1
R_VDD5_19851 METAL1_519000_829000 METAL1_519000_841000 0.096
R_VDD5_19852 METAL1_519000_841000 METAL1_519000_845000 0.032
R_VDD5_19853 METAL1_519000_845000 METAL1_519000_853000 0.064
R_VDD5_19854 METAL1_519000_853000 METAL1_519000_857000 0.032
R_VDD5_19855 METAL1_519000_857000 METAL1_519000_865000 0.064
R_VDD5_19856 METAL1_519000_865000 METAL1_519000_869000 0.032
R_VDD5_19857 METAL1_519000_869000 METAL1_519000_877000 0.064
R_VDD5_19858 METAL1_519000_877000 METAL1_519000_881000 0.032
R_VDD5_19859 METAL1_519000_881000 METAL1_519000_889000 0.064
R_VDD5_19860 METAL1_519000_889000 METAL1_519000_893000 0.032
R_VDD5_19861 METAL1_519000_893000 METAL1_519000_901000 0.064
R_VDD5_19862 METAL1_519000_901000 METAL1_519000_905000 0.032
R_VDD5_19863 METAL1_519000_905000 METAL1_519000_913000 0.064
R_VDD5_19864 METAL1_519000_913000 METAL1_519000_917000 0.032
R_VDD5_19865 METAL1_519000_917000 METAL1_519000_929000 0.096
R_VDD5_19866 METAL1_519000_929000 METAL1_519000_941000 0.096
R_VDD5_19867 METAL1_519000_941000 METAL1_519000_953000 0.096
R_VDD5_19868 METAL1_519000_953000 METAL1_519000_965000 0.096
R_VDD5_19869 METAL1_519000_965000 METAL1_519000_977000 0.096
R_VDD5_19870 METAL1_519000_977000 METAL1_519000_989000 0.096
R_VDD5_19871 METAL1_519000_989000 METAL1_519000_1001000 0.096
R_VDD5_19872 METAL1_519000_1001000 METAL1_519000_1013000 0.096
R_VDD5_19873 METAL1_519000_1013000 METAL1_519000_1025000 0.096
R_VDD5_19874 METAL1_519000_1025000 METAL1_519000_1029000 0.032
R_VDD5_19875 METAL1_519000_1029000 METAL1_519000_1037000 0.064
R_VDD5_19876 METAL1_519000_1037000 METAL1_519000_1041000 0.032
R_VDD5_19877 METAL1_519000_1041000 METAL1_519000_1053000 0.096
R_VDD5_19878 METAL1_519000_1053000 METAL1_519000_1065000 0.096
R_VDD5_19879 METAL1_519000_1065000 METAL1_519000_1077000 0.096
R_VDD5_19880 METAL1_519000_1077000 METAL1_519000_1089000 0.096
R_VDD5_19881 METAL1_519000_1089000 METAL1_519000_1101000 0.096
R_VDD5_19882 METAL1_519000_1101000 METAL1_519000_1113000 0.096
R_VDD5_19883 METAL1_519000_1113000 METAL1_519000_1141000 0.224
R_VDD5_19884 METAL1_519000_1141000 METAL1_519000_1153000 0.096
R_VDD5_19885 METAL1_519000_1153000 METAL1_519000_1165000 0.096
R_VDD5_19886 METAL1_519000_1165000 METAL1_519000_1177000 0.096
R_VDD5_19887 METAL1_519000_1177000 METAL1_519000_1189000 0.096
R_VDD5_19888 METAL1_519000_1189000 METAL1_519000_1201000 0.096
R_VDD5_19889 METAL1_519000_1201000 METAL1_519000_1205000 0.032
R_VDD5_19890 METAL1_519000_1205000 METAL1_519000_1213000 0.064
R_VDD5_19891 METAL1_519000_1213000 METAL1_519000_1217000 0.032
R_VDD5_19892 METAL1_519000_1217000 METAL1_519000_1229000 0.096
R_VDD5_19893 METAL1_519000_1229000 METAL1_519000_1241000 0.096
R_VDD5_19894 METAL1_519000_1241000 METAL1_519000_1253000 0.096
R_VDD5_19895 METAL1_519000_1253000 METAL1_519000_1265000 0.096
R_VDD5_19896 METAL1_519000_1265000 METAL1_519000_1277000 0.096
R_VDD5_19897 METAL1_519000_1277000 METAL2_519000_1277000 0.1
R_VDD5_19898 METAL2_519000_1277000 METAL3_519000_1277000 0.1
R_VDD5_19899 METAL3_519000_1277000 METAL3_519000_1289000 0.096
R_VDD5_19900 METAL3_519000_1289000 METAL3_519000_1301000 0.096
R_VDD5_19901 METAL3_519000_1301000 METAL3_519000_1321000 0.16
R_VDD5_19902 METAL3_519000_1321000 METAL3_519000_1333000 0.096
R_VDD5_19903 METAL3_519000_1333000 METAL3_519000_1345000 0.096
R_VDD5_19904 METAL3_519000_1345000 METAL3_519000_1357000 0.096
R_VDD5_19905 METAL3_519000_1357000 METAL3_519000_1369000 0.096
R_VDD5_19906 METAL3_519000_1369000 METAL3_519000_1381000 0.096
R_VDD5_19907 METAL3_519000_1381000 METAL3_519000_1393000 0.096
R_VDD5_19908 METAL3_519000_1393000 METAL3_519000_1405000 0.096
R_VDD5_19909 METAL3_519000_1405000 METAL3_519000_1407000 0.016
R_VDD5_19910 METAL3_519000_1407000 METAL3_519000_1417000 0.08
R_VDD5_19911 METAL3_519000_1417000 METAL3_519000_1429000 0.096
R_VDD5_19912 METAL3_519000_1429000 METAL3_519000_1493000 0.512
R_VDD5_19913 METAL3_519000_1493000 METAL3_519000_1505000 0.096
R_VDD5_19914 METAL3_519000_1505000 METAL3_519000_1517000 0.096
R_VDD5_19915 METAL3_519000_1517000 METAL3_519000_1529000 0.096
R_VDD5_19916 METAL3_519000_1529000 METAL3_519000_1541000 0.096
R_VDD5_19917 METAL3_519000_1541000 METAL3_519000_1553000 0.096
R_VDD5_19918 METAL3_519000_1553000 METAL3_519000_1565000 0.096
R_VDD5_19919 METAL3_519000_1565000 METAL3_519000_1577000 0.096
R_VDD5_19920 METAL3_519000_1577000 METAL3_519000_1589000 0.096
R_VDD5_19921 METAL3_519000_1589000 METAL3_519000_1593000 0.032
R_VDD5_19922 METAL3_519000_1593000 METAL3_519000_1605000 0.096
R_VDD5_19923 METAL3_519000_1605000 METAL3_519000_1617000 0.096
R_VDD5_19924 METAL3_519000_1617000 METAL3_519000_1629000 0.096
R_VDD5_19925 METAL3_519000_1629000 METAL3_519000_1641000 0.096
R_VDD5_19926 METAL3_519000_1641000 METAL3_519000_1653000 0.096
R_VDD5_19927 METAL3_519000_1653000 METAL3_519000_1665000 0.096
R_VDD5_19928 METAL3_519000_1665000 METAL3_519000_1677000 0.096
R_VDD5_19929 METAL3_519000_1677000 METAL3_519000_1689000 0.096
R_VDD5_19930 METAL3_519000_1689000 METAL3_519000_1701000 0.096
R_VDD5_19931 METAL3_519000_1701000 METAL3_519000_1753000 0.416
R_VDD5_19932 METAL3_519000_1753000 METAL3_519000_1765000 0.096
R_VDD5_19933 METAL3_519000_1765000 METAL3_519000_1777000 0.096
R_VDD5_19934 METAL3_519000_1777000 METAL3_519000_1789000 0.096
R_VDD5_19935 METAL3_519000_1789000 METAL3_519000_1793000 0.032
R_VDD5_19936 METAL3_519000_1793000 METAL3_519000_1801000 0.064
R_VDD5_19937 METAL3_519000_1801000 METAL3_519000_1805000 0.032
R_VDD5_19938 METAL3_519000_1805000 METAL3_519000_1813000 0.064
R_VDD5_19939 METAL3_519000_1813000 METAL3_519000_1817000 0.032
R_VDD5_19940 METAL3_519000_1817000 METAL3_519000_1829000 0.096
R_VDD5_19941 METAL3_519000_1829000 METAL3_519000_1841000 0.096
R_VDD5_19942 METAL3_519000_1841000 METAL3_519000_1853000 0.096
R_VDD5_19943 METAL3_519000_1853000 METAL3_519000_1865000 0.096
R_VDD5_19944 METAL3_519000_1865000 METAL3_519000_1877000 0.096
R_VDD5_19945 METAL3_519000_1877000 METAL3_519000_1889000 0.096
R_VDD5_19946 METAL3_519000_1889000 METAL3_519000_1905000 0.128
R_VDD5_19947 METAL3_519000_1905000 METAL3_519000_1917000 0.096
R_VDD5_19948 METAL3_519000_1917000 METAL3_519000_1929000 0.096
R_VDD5_19949 METAL3_519000_1929000 METAL3_519000_1941000 0.096
R_VDD5_19950 METAL3_519000_1941000 METAL3_519000_1953000 0.096
R_VDD5_19951 METAL3_519000_1953000 METAL3_520000_1953000 0.008
R_VDD5_19952 METAL3_520000_1953000 METAL3_522000_1953000 0.016
R_VDD5_19953 METAL3_522000_1953000 METAL3_524000_1953000 0.016
R_VDD5_19954 METAL3_524000_1953000 METAL3_531000_1953000 0.056
R_VDD5_19955 METAL3_531000_1953000 METAL3_532000_1953000 0.008
R_VDD5_19956 METAL3_532000_1953000 METAL3_536000_1953000 0.032
R_VDD5_19957 METAL3_536000_1953000 METAL3_543000_1953000 0.056
R_VDD5_19958 METAL3_543000_1953000 METAL3_543000_1965000 0.096
R_VDD5_19959 METAL6_531000_577000 METAL5_531000_577000 0.1
R_VDD5_19960 METAL5_531000_577000 METAL5_531000_589000 0.048
R_VDD5_19961 METAL5_531000_589000 METAL5_532000_589000 0.004
R_VDD5_19962 METAL5_532000_589000 METAL5_536000_589000 0.016
R_VDD5_19963 METAL5_536000_589000 METAL5_543000_589000 0.028
R_VDD5_19964 METAL5_543000_589000 METAL4_543000_589000 0.1
R_VDD5_19965 METAL4_543000_589000 METAL3_543000_589000 0.1
R_VDD5_19966 METAL3_543000_589000 METAL2_543000_589000 0.1
R_VDD5_19967 METAL2_543000_589000 METAL2_543000_601000 0.096
R_VDD5_19968 METAL2_543000_601000 METAL2_543000_613000 0.096
R_VDD5_19969 METAL2_543000_613000 METAL2_543000_625000 0.096
R_VDD5_19970 METAL2_543000_625000 METAL2_543000_645000 0.16
R_VDD5_19971 METAL2_543000_645000 METAL3_543000_645000 0.1
R_VDD5_19972 METAL3_543000_645000 METAL3_543000_657000 0.096
R_VDD5_19973 METAL3_543000_657000 METAL3_543000_669000 0.096
R_VDD5_19974 METAL3_543000_669000 METAL3_543000_681000 0.096
R_VDD5_19975 METAL3_543000_681000 METAL3_543000_693000 0.096
R_VDD5_19976 METAL3_543000_693000 METAL4_543000_693000 0.1
R_VDD5_19977 METAL4_543000_693000 METAL4_543000_705000 0.096
R_VDD5_19978 METAL4_543000_705000 METAL4_536000_705000 0.056
R_VDD5_19979 METAL4_536000_705000 METAL4_532000_705000 0.032
R_VDD5_19980 METAL4_532000_705000 METAL4_532000_707000 0.016
R_VDD5_19981 METAL4_532000_707000 METAL4_532000_717000 0.08
R_VDD5_19982 METAL4_532000_717000 METAL4_532000_729000 0.096
R_VDD5_19983 METAL4_532000_729000 METAL4_532000_757000 0.224
R_VDD5_19984 METAL4_532000_757000 METAL4_531000_757000 0.008
R_VDD5_19985 METAL4_531000_757000 METAL4_524000_757000 0.056
R_VDD5_19986 METAL4_524000_757000 METAL4_522000_757000 0.016
R_VDD5_19987 METAL4_522000_757000 METAL4_520000_757000 0.016
R_VDD5_19988 METAL4_520000_757000 METAL4_519000_757000 0.008
R_VDD5_19989 METAL4_519000_757000 METAL4_512000_757000 0.056
R_VDD5_19990 METAL4_512000_757000 METAL4_510000_757000 0.016
R_VDD5_19991 METAL4_510000_757000 METAL4_508000_757000 0.016
R_VDD5_19992 METAL4_508000_757000 METAL4_507000_757000 0.008
R_VDD5_19993 METAL4_507000_757000 METAL3_507000_757000 0.1
R_VDD5_19994 METAL3_507000_757000 METAL2_507000_757000 0.1
R_VDD5_19995 METAL2_507000_757000 METAL1_507000_757000 0.1
R_VDD5_19996 METAL1_507000_757000 METAL1_507000_769000 0.096
R_VDD5_19997 METAL1_507000_769000 METAL1_507000_781000 0.096
R_VDD5_19998 METAL1_507000_781000 METAL1_507000_793000 0.096
R_VDD5_19999 METAL1_507000_793000 METAL1_507000_805000 0.096
R_VDD5_20000 METAL1_507000_805000 METAL1_507000_817000 0.096
R_VDD5_20001 METAL1_507000_817000 METAL1_507000_829000 0.096
R_VDD5_20002 METAL1_507000_829000 METAL1_507000_841000 0.096
R_VDD5_20003 METAL1_507000_841000 METAL1_507000_845000 0.032
R_VDD5_20004 METAL1_507000_845000 METAL1_507000_853000 0.064
R_VDD5_20005 METAL1_507000_853000 METAL1_507000_857000 0.032
R_VDD5_20006 METAL1_507000_857000 METAL1_507000_865000 0.064
R_VDD5_20007 METAL1_507000_865000 METAL1_507000_869000 0.032
R_VDD5_20008 METAL1_507000_869000 METAL1_507000_877000 0.064
R_VDD5_20009 METAL1_507000_877000 METAL1_507000_881000 0.032
R_VDD5_20010 METAL1_507000_881000 METAL1_507000_889000 0.064
R_VDD5_20011 METAL1_507000_889000 METAL1_507000_893000 0.032
R_VDD5_20012 METAL1_507000_893000 METAL1_507000_901000 0.064
R_VDD5_20013 METAL1_507000_901000 METAL1_507000_905000 0.032
R_VDD5_20014 METAL1_507000_905000 METAL1_507000_913000 0.064
R_VDD5_20015 METAL1_507000_913000 METAL1_507000_917000 0.032
R_VDD5_20016 METAL1_507000_917000 METAL1_507000_929000 0.096
R_VDD5_20017 METAL1_507000_929000 METAL1_507000_941000 0.096
R_VDD5_20018 METAL1_507000_941000 METAL1_507000_953000 0.096
R_VDD5_20019 METAL1_507000_953000 METAL1_507000_965000 0.096
R_VDD5_20020 METAL1_507000_965000 METAL1_507000_977000 0.096
R_VDD5_20021 METAL1_507000_977000 METAL1_507000_989000 0.096
R_VDD5_20022 METAL1_507000_989000 METAL1_507000_1001000 0.096
R_VDD5_20023 METAL1_507000_1001000 METAL1_507000_1013000 0.096
R_VDD5_20024 METAL1_507000_1013000 METAL1_507000_1025000 0.096
R_VDD5_20025 METAL1_507000_1025000 METAL1_507000_1029000 0.032
R_VDD5_20026 METAL1_507000_1029000 METAL1_507000_1037000 0.064
R_VDD5_20027 METAL1_507000_1037000 METAL1_507000_1041000 0.032
R_VDD5_20028 METAL1_507000_1041000 METAL1_507000_1053000 0.096
R_VDD5_20029 METAL1_507000_1053000 METAL1_507000_1065000 0.096
R_VDD5_20030 METAL1_507000_1065000 METAL1_507000_1077000 0.096
R_VDD5_20031 METAL1_507000_1077000 METAL1_507000_1089000 0.096
R_VDD5_20032 METAL1_507000_1089000 METAL1_507000_1101000 0.096
R_VDD5_20033 METAL1_507000_1101000 METAL1_507000_1113000 0.096
R_VDD5_20034 METAL1_507000_1113000 METAL1_507000_1141000 0.224
R_VDD5_20035 METAL1_507000_1141000 METAL1_507000_1153000 0.096
R_VDD5_20036 METAL1_507000_1153000 METAL1_507000_1165000 0.096
R_VDD5_20037 METAL1_507000_1165000 METAL1_507000_1177000 0.096
R_VDD5_20038 METAL1_507000_1177000 METAL1_507000_1189000 0.096
R_VDD5_20039 METAL1_507000_1189000 METAL1_507000_1201000 0.096
R_VDD5_20040 METAL1_507000_1201000 METAL1_507000_1205000 0.032
R_VDD5_20041 METAL1_507000_1205000 METAL1_507000_1213000 0.064
R_VDD5_20042 METAL1_507000_1213000 METAL1_507000_1217000 0.032
R_VDD5_20043 METAL1_507000_1217000 METAL1_507000_1229000 0.096
R_VDD5_20044 METAL1_507000_1229000 METAL1_507000_1241000 0.096
R_VDD5_20045 METAL1_507000_1241000 METAL1_507000_1253000 0.096
R_VDD5_20046 METAL1_507000_1253000 METAL1_507000_1265000 0.096
R_VDD5_20047 METAL1_507000_1265000 METAL1_507000_1277000 0.096
R_VDD5_20048 METAL1_507000_1277000 METAL2_507000_1277000 0.1
R_VDD5_20049 METAL2_507000_1277000 METAL2_507000_1289000 0.096
R_VDD5_20050 METAL2_507000_1289000 METAL2_507000_1301000 0.096
R_VDD5_20051 METAL2_507000_1301000 METAL2_507000_1321000 0.16
R_VDD5_20052 METAL2_507000_1321000 METAL2_507000_1333000 0.096
R_VDD5_20053 METAL2_507000_1333000 METAL2_507000_1345000 0.096
R_VDD5_20054 METAL2_507000_1345000 METAL2_507000_1357000 0.096
R_VDD5_20055 METAL2_507000_1357000 METAL2_507000_1369000 0.096
R_VDD5_20056 METAL2_507000_1369000 METAL2_507000_1381000 0.096
R_VDD5_20057 METAL2_507000_1381000 METAL2_507000_1393000 0.096
R_VDD5_20058 METAL2_507000_1393000 METAL2_507000_1405000 0.096
R_VDD5_20059 METAL2_507000_1405000 METAL2_507000_1407000 0.016
R_VDD5_20060 METAL2_507000_1407000 METAL2_507000_1417000 0.08
R_VDD5_20061 METAL2_507000_1417000 METAL2_507000_1429000 0.096
R_VDD5_20062 METAL2_507000_1429000 METAL2_507000_1493000 0.512
R_VDD5_20063 METAL2_507000_1493000 METAL2_507000_1505000 0.096
R_VDD5_20064 METAL2_507000_1505000 METAL2_507000_1517000 0.096
R_VDD5_20065 METAL2_507000_1517000 METAL2_507000_1529000 0.096
R_VDD5_20066 METAL2_507000_1529000 METAL2_507000_1541000 0.096
R_VDD5_20067 METAL2_507000_1541000 METAL2_507000_1553000 0.096
R_VDD5_20068 METAL2_507000_1553000 METAL2_507000_1565000 0.096
R_VDD5_20069 METAL2_507000_1565000 METAL2_507000_1577000 0.096
R_VDD5_20070 METAL2_507000_1577000 METAL2_507000_1589000 0.096
R_VDD5_20071 METAL2_507000_1589000 METAL2_507000_1593000 0.032
R_VDD5_20072 METAL2_507000_1593000 METAL2_507000_1605000 0.096
R_VDD5_20073 METAL2_507000_1605000 METAL2_507000_1617000 0.096
R_VDD5_20074 METAL2_507000_1617000 METAL2_507000_1629000 0.096
R_VDD5_20075 METAL2_507000_1629000 METAL2_507000_1641000 0.096
R_VDD5_20076 METAL2_507000_1641000 METAL2_507000_1653000 0.096
R_VDD5_20077 METAL2_507000_1653000 METAL2_507000_1665000 0.096
R_VDD5_20078 METAL2_507000_1665000 METAL2_507000_1677000 0.096
R_VDD5_20079 METAL2_507000_1677000 METAL2_507000_1689000 0.096
R_VDD5_20080 METAL2_507000_1689000 METAL2_507000_1701000 0.096
R_VDD5_20081 METAL2_507000_1701000 METAL2_507000_1753000 0.416
R_VDD5_20082 METAL2_507000_1753000 METAL2_507000_1765000 0.096
R_VDD5_20083 METAL2_507000_1765000 METAL2_507000_1777000 0.096
R_VDD5_20084 METAL2_507000_1777000 METAL2_507000_1789000 0.096
R_VDD5_20085 METAL2_507000_1789000 METAL2_507000_1793000 0.032
R_VDD5_20086 METAL2_507000_1793000 METAL2_507000_1801000 0.064
R_VDD5_20087 METAL2_507000_1801000 METAL2_507000_1805000 0.032
R_VDD5_20088 METAL2_507000_1805000 METAL2_507000_1813000 0.064
R_VDD5_20089 METAL2_507000_1813000 METAL2_507000_1817000 0.032
R_VDD5_20090 METAL2_507000_1817000 METAL2_507000_1829000 0.096
R_VDD5_20091 METAL2_507000_1829000 METAL2_507000_1841000 0.096
R_VDD5_20092 METAL2_507000_1841000 METAL2_507000_1853000 0.096
R_VDD5_20093 METAL2_507000_1853000 METAL2_507000_1865000 0.096
R_VDD5_20094 METAL2_507000_1865000 METAL2_507000_1877000 0.096
R_VDD5_20095 METAL2_507000_1877000 METAL2_507000_1889000 0.096
R_VDD5_20096 METAL2_507000_1889000 METAL2_507000_1905000 0.128
R_VDD5_20097 METAL2_507000_1905000 METAL2_507000_1917000 0.096
R_VDD5_20098 METAL2_507000_1917000 METAL2_507000_1929000 0.096
R_VDD5_20099 METAL2_507000_1929000 METAL2_507000_1941000 0.096
R_VDD5_20100 METAL2_507000_1941000 METAL2_507000_1953000 0.096
R_VDD5_20101 METAL2_507000_1953000 METAL2_508000_1953000 0.008
R_VDD5_20102 METAL2_508000_1953000 METAL2_510000_1953000 0.016
R_VDD5_20103 METAL2_510000_1953000 METAL2_512000_1953000 0.016
R_VDD5_20104 METAL2_512000_1953000 METAL2_519000_1953000 0.056
R_VDD5_20105 METAL2_519000_1953000 METAL2_520000_1953000 0.008
R_VDD5_20106 METAL2_520000_1953000 METAL2_522000_1953000 0.016
R_VDD5_20107 METAL2_522000_1953000 METAL2_524000_1953000 0.016
R_VDD5_20108 METAL2_524000_1953000 METAL2_531000_1953000 0.056
R_VDD5_20109 METAL2_531000_1953000 METAL2_531000_1965000 0.096
R_VDD5_20110 METAL2_531000_1965000 METAL2_532000_1965000 0.008
R_VDD5_20111 METAL2_532000_1965000 METAL2_536000_1965000 0.032
R_VDD5_20112 METAL2_536000_1965000 METAL2_543000_1965000 0.056
R_VDD5_20113 METAL2_543000_1965000 METAL3_543000_1965000 0.1
R_VDD5_20114 METAL5_531000_877000 METAL5_531000_881000 0.016
R_VDD5_20115 METAL5_531000_881000 METAL5_531000_889000 0.032
R_VDD5_20116 METAL5_531000_889000 METAL5_531000_893000 0.016
R_VDD5_20117 METAL5_531000_893000 METAL5_531000_901000 0.032
R_VDD5_20118 METAL5_531000_901000 METAL5_531000_905000 0.016
R_VDD5_20119 METAL5_531000_905000 METAL5_531000_913000 0.032
R_VDD5_20120 METAL5_531000_913000 METAL5_531000_917000 0.016
R_VDD5_20121 METAL5_531000_917000 METAL5_532000_917000 0.004
R_VDD5_20122 METAL5_532000_917000 METAL5_536000_917000 0.016
R_VDD5_20123 METAL5_536000_917000 METAL5_543000_917000 0.028
R_VDD5_20124 METAL5_543000_917000 METAL5_543000_929000 0.048
R_VDD5_20125 METAL5_543000_929000 METAL4_543000_929000 0.1
R_VDD5_20126 METAL4_543000_929000 METAL3_543000_929000 0.1
R_VDD5_20127 METAL3_543000_929000 METAL3_543000_941000 0.096
R_VDD5_20128 METAL3_543000_941000 METAL3_543000_953000 0.096
R_VDD5_20129 METAL3_543000_953000 METAL3_536000_953000 0.056
R_VDD5_20130 METAL3_536000_953000 METAL3_532000_953000 0.032
R_VDD5_20131 METAL3_532000_953000 METAL3_531000_953000 0.008
R_VDD5_20132 METAL3_531000_953000 METAL3_531000_965000 0.096
R_VDD5_20133 METAL3_531000_965000 METAL3_531000_977000 0.096
R_VDD5_20134 METAL3_531000_977000 METAL3_531000_989000 0.096
R_VDD5_20135 METAL3_531000_989000 METAL3_531000_1001000 0.096
R_VDD5_20136 METAL3_531000_1001000 METAL4_531000_1001000 0.1
R_VDD5_20137 METAL4_531000_1001000 METAL4_531000_1013000 0.096
R_VDD5_20138 METAL4_531000_1013000 METAL4_531000_1025000 0.096
R_VDD5_20139 METAL4_531000_1025000 METAL4_524000_1025000 0.056
R_VDD5_20140 METAL4_524000_1025000 METAL4_524000_1029000 0.032
R_VDD5_20141 METAL4_524000_1029000 METAL4_524000_1037000 0.064
R_VDD5_20142 METAL4_524000_1037000 METAL4_524000_1041000 0.032
R_VDD5_20143 METAL4_524000_1041000 METAL4_524000_1053000 0.096
R_VDD5_20144 METAL4_524000_1053000 METAL4_522000_1053000 0.016
R_VDD5_20145 METAL4_522000_1053000 METAL4_520000_1053000 0.016
R_VDD5_20146 METAL4_520000_1053000 METAL4_519000_1053000 0.008
R_VDD5_20147 METAL4_519000_1053000 METAL4_512000_1053000 0.056
R_VDD5_20148 METAL4_512000_1053000 METAL4_510000_1053000 0.016
R_VDD5_20149 METAL4_510000_1053000 METAL4_508000_1053000 0.016
R_VDD5_20150 METAL4_508000_1053000 METAL4_507000_1053000 0.008
R_VDD5_20151 METAL4_507000_1053000 METAL4_506000_1053000 0.008
R_VDD5_20152 METAL4_506000_1053000 METAL4_500000_1053000 0.048
R_VDD5_20153 METAL4_500000_1053000 METAL4_498000_1053000 0.016
R_VDD5_20154 METAL4_498000_1053000 METAL4_496000_1053000 0.016
R_VDD5_20155 METAL4_496000_1053000 METAL4_495000_1053000 0.008
R_VDD5_20156 METAL4_495000_1053000 METAL4_494000_1053000 0.008
R_VDD5_20157 METAL4_494000_1053000 METAL4_488000_1053000 0.048
R_VDD5_20158 METAL4_488000_1053000 METAL4_486000_1053000 0.016
R_VDD5_20159 METAL4_486000_1053000 METAL4_484000_1053000 0.016
R_VDD5_20160 METAL4_484000_1053000 METAL4_483000_1053000 0.008
R_VDD5_20161 METAL4_483000_1053000 METAL3_483000_1053000 0.1
R_VDD5_20162 METAL3_483000_1053000 METAL3_483000_1065000 0.096
R_VDD5_20163 METAL3_483000_1065000 METAL3_483000_1077000 0.096
R_VDD5_20164 METAL3_483000_1077000 METAL3_483000_1089000 0.096
R_VDD5_20165 METAL3_483000_1089000 METAL3_483000_1101000 0.096
R_VDD5_20166 METAL3_483000_1101000 METAL3_483000_1113000 0.096
R_VDD5_20167 METAL3_483000_1113000 METAL3_483000_1141000 0.224
R_VDD5_20168 METAL3_483000_1141000 METAL3_483000_1153000 0.096
R_VDD5_20169 METAL3_483000_1153000 METAL3_483000_1165000 0.096
R_VDD5_20170 METAL3_483000_1165000 METAL3_483000_1177000 0.096
R_VDD5_20171 METAL3_483000_1177000 METAL3_483000_1189000 0.096
R_VDD5_20172 METAL3_483000_1189000 METAL3_483000_1201000 0.096
R_VDD5_20173 METAL3_483000_1201000 METAL3_483000_1205000 0.032
R_VDD5_20174 METAL3_483000_1205000 METAL3_483000_1213000 0.064
R_VDD5_20175 METAL3_483000_1213000 METAL3_483000_1217000 0.032
R_VDD5_20176 METAL3_483000_1217000 METAL3_483000_1229000 0.096
R_VDD5_20177 METAL3_483000_1229000 METAL3_483000_1241000 0.096
R_VDD5_20178 METAL3_483000_1241000 METAL3_483000_1253000 0.096
R_VDD5_20179 METAL3_483000_1253000 METAL3_483000_1265000 0.096
R_VDD5_20180 METAL3_483000_1265000 METAL3_483000_1277000 0.096
R_VDD5_20181 METAL3_483000_1277000 METAL3_483000_1289000 0.096
R_VDD5_20182 METAL3_483000_1289000 METAL3_483000_1301000 0.096
R_VDD5_20183 METAL3_483000_1301000 METAL3_483000_1321000 0.16
R_VDD5_20184 METAL3_483000_1321000 METAL3_483000_1333000 0.096
R_VDD5_20185 METAL3_483000_1333000 METAL3_483000_1345000 0.096
R_VDD5_20186 METAL3_483000_1345000 METAL3_483000_1357000 0.096
R_VDD5_20187 METAL3_483000_1357000 METAL3_483000_1369000 0.096
R_VDD5_20188 METAL3_483000_1369000 METAL3_483000_1381000 0.096
R_VDD5_20189 METAL3_483000_1381000 METAL3_483000_1393000 0.096
R_VDD5_20190 METAL3_483000_1393000 METAL3_483000_1405000 0.096
R_VDD5_20191 METAL3_483000_1405000 METAL3_483000_1407000 0.016
R_VDD5_20192 METAL3_483000_1407000 METAL3_483000_1417000 0.08
R_VDD5_20193 METAL3_483000_1417000 METAL3_483000_1429000 0.096
R_VDD5_20194 METAL3_483000_1429000 METAL3_483000_1493000 0.512
R_VDD5_20195 METAL3_483000_1493000 METAL3_483000_1505000 0.096
R_VDD5_20196 METAL3_483000_1505000 METAL3_483000_1517000 0.096
R_VDD5_20197 METAL3_483000_1517000 METAL3_483000_1529000 0.096
R_VDD5_20198 METAL3_483000_1529000 METAL3_483000_1541000 0.096
R_VDD5_20199 METAL3_483000_1541000 METAL3_483000_1553000 0.096
R_VDD5_20200 METAL3_483000_1553000 METAL3_483000_1565000 0.096
R_VDD5_20201 METAL3_483000_1565000 METAL3_483000_1577000 0.096
R_VDD5_20202 METAL3_483000_1577000 METAL3_483000_1589000 0.096
R_VDD5_20203 METAL3_483000_1589000 METAL3_483000_1593000 0.032
R_VDD5_20204 METAL3_483000_1593000 METAL3_483000_1605000 0.096
R_VDD5_20205 METAL3_483000_1605000 METAL3_483000_1617000 0.096
R_VDD5_20206 METAL3_483000_1617000 METAL3_483000_1629000 0.096
R_VDD5_20207 METAL3_483000_1629000 METAL3_483000_1641000 0.096
R_VDD5_20208 METAL3_483000_1641000 METAL3_483000_1653000 0.096
R_VDD5_20209 METAL3_483000_1653000 METAL3_483000_1665000 0.096
R_VDD5_20210 METAL3_483000_1665000 METAL3_483000_1677000 0.096
R_VDD5_20211 METAL3_483000_1677000 METAL3_483000_1689000 0.096
R_VDD5_20212 METAL3_483000_1689000 METAL3_483000_1701000 0.096
R_VDD5_20213 METAL3_483000_1701000 METAL3_483000_1753000 0.416
R_VDD5_20214 METAL3_483000_1753000 METAL3_483000_1765000 0.096
R_VDD5_20215 METAL3_483000_1765000 METAL3_483000_1777000 0.096
R_VDD5_20216 METAL3_483000_1777000 METAL3_483000_1789000 0.096
R_VDD5_20217 METAL3_483000_1789000 METAL3_483000_1793000 0.032
R_VDD5_20218 METAL3_483000_1793000 METAL3_483000_1801000 0.064
R_VDD5_20219 METAL3_483000_1801000 METAL3_483000_1805000 0.032
R_VDD5_20220 METAL3_483000_1805000 METAL3_483000_1813000 0.064
R_VDD5_20221 METAL3_483000_1813000 METAL3_483000_1817000 0.032
R_VDD5_20222 METAL3_483000_1817000 METAL3_483000_1829000 0.096
R_VDD5_20223 METAL3_483000_1829000 METAL3_483000_1841000 0.096
R_VDD5_20224 METAL3_483000_1841000 METAL3_483000_1853000 0.096
R_VDD5_20225 METAL3_483000_1853000 METAL3_483000_1865000 0.096
R_VDD5_20226 METAL3_483000_1865000 METAL3_483000_1877000 0.096
R_VDD5_20227 METAL3_483000_1877000 METAL3_483000_1889000 0.096
R_VDD5_20228 METAL3_483000_1889000 METAL3_483000_1905000 0.128
R_VDD5_20229 METAL3_483000_1905000 METAL3_483000_1917000 0.096
R_VDD5_20230 METAL3_483000_1917000 METAL3_483000_1929000 0.096
R_VDD5_20231 METAL3_483000_1929000 METAL3_483000_1941000 0.096
R_VDD5_20232 METAL3_483000_1941000 METAL3_483000_1953000 0.096
R_VDD5_20233 METAL3_483000_1953000 METAL3_483000_1965000 0.096
R_VDD5_20234 METAL3_483000_1965000 METAL3_483000_1977000 0.096
R_VDD5_20235 METAL3_483000_1977000 METAL2_483000_1977000 0.1
R_VDD5_20236 METAL2_483000_1977000 METAL2_484000_1977000 0.008
R_VDD5_20237 METAL2_484000_1977000 METAL2_486000_1977000 0.016
R_VDD5_20238 METAL2_486000_1977000 METAL2_488000_1977000 0.016
R_VDD5_20239 METAL2_488000_1977000 METAL2_494000_1977000 0.048
R_VDD5_20240 METAL2_494000_1977000 METAL2_495000_1977000 0.008
R_VDD5_20241 METAL2_495000_1977000 METAL2_496000_1977000 0.008
R_VDD5_20242 METAL2_496000_1977000 METAL2_498000_1977000 0.016
R_VDD5_20243 METAL2_498000_1977000 METAL2_500000_1977000 0.016
R_VDD5_20244 METAL2_500000_1977000 METAL2_506000_1977000 0.048
R_VDD5_20245 METAL2_506000_1977000 METAL2_507000_1977000 0.008
R_VDD5_20246 METAL2_507000_1977000 METAL2_508000_1977000 0.008
R_VDD5_20247 METAL2_508000_1977000 METAL2_510000_1977000 0.016
R_VDD5_20248 METAL2_510000_1977000 METAL2_512000_1977000 0.016
R_VDD5_20249 METAL2_512000_1977000 METAL2_519000_1977000 0.056
R_VDD5_20250 METAL2_519000_1977000 METAL3_519000_1977000 0.1
R_VDD5_20251 METAL3_519000_1977000 METAL3_520000_1977000 0.008
R_VDD5_20252 METAL3_520000_1977000 METAL3_522000_1977000 0.016
R_VDD5_20253 METAL3_522000_1977000 METAL3_524000_1977000 0.016
R_VDD5_20254 METAL3_524000_1977000 METAL3_531000_1977000 0.056
R_VDD5_20255 METAL3_531000_1977000 METAL3_532000_1977000 0.008
R_VDD5_20256 METAL3_532000_1977000 METAL3_536000_1977000 0.032
R_VDD5_20257 METAL3_536000_1977000 METAL3_543000_1977000 0.056
R_VDD5_20258 METAL3_543000_1977000 METAL4_543000_1977000 0.1
R_VDD5_20259 METAL4_543000_1977000 METAL4_543000_1965000 0.096
R_VDD5_20260 METAL6_448000_3177000 METAL5_448000_3177000 0.1
R_VDD5_20261 METAL5_448000_3177000 METAL5_448000_3189000 0.048
R_VDD5_20262 METAL5_448000_3189000 METAL5_448000_3253000 0.256
R_VDD5_20263 METAL5_448000_3253000 METAL5_448000_3265000 0.048
R_VDD5_20264 METAL5_448000_3265000 METAL5_448000_3277000 0.048
R_VDD5_20265 METAL5_448000_3277000 METAL5_450000_3277000 0.008
R_VDD5_20266 METAL5_450000_3277000 METAL5_452000_3277000 0.008
R_VDD5_20267 METAL5_452000_3277000 METAL5_458000_3277000 0.024
R_VDD5_20268 METAL5_458000_3277000 METAL5_459000_3277000 0.004
R_VDD5_20269 METAL5_459000_3277000 METAL5_460000_3277000 0.004
R_VDD5_20270 METAL5_460000_3277000 METAL5_462000_3277000 0.008
R_VDD5_20271 METAL5_462000_3277000 METAL5_464000_3277000 0.008
R_VDD5_20272 METAL5_464000_3277000 METAL5_470000_3277000 0.024
R_VDD5_20273 METAL5_470000_3277000 METAL5_471000_3277000 0.004
R_VDD5_20274 METAL5_471000_3277000 METAL4_471000_3277000 0.1
R_VDD5_20275 METAL4_471000_3277000 METAL4_472000_3277000 0.008
R_VDD5_20276 METAL4_472000_3277000 METAL4_474000_3277000 0.016
R_VDD5_20277 METAL4_474000_3277000 METAL4_476000_3277000 0.016
R_VDD5_20278 METAL4_476000_3277000 METAL4_482000_3277000 0.048
R_VDD5_20279 METAL4_482000_3277000 METAL4_483000_3277000 0.008
R_VDD5_20280 METAL4_483000_3277000 METAL4_484000_3277000 0.008
R_VDD5_20281 METAL4_484000_3277000 METAL4_486000_3277000 0.016
R_VDD5_20282 METAL4_486000_3277000 METAL4_488000_3277000 0.016
R_VDD5_20283 METAL4_488000_3277000 METAL4_494000_3277000 0.048
R_VDD5_20284 METAL4_494000_3277000 METAL4_495000_3277000 0.008
R_VDD5_20285 METAL4_495000_3277000 METAL4_496000_3277000 0.008
R_VDD5_20286 METAL4_496000_3277000 METAL4_498000_3277000 0.016
R_VDD5_20287 METAL4_498000_3277000 METAL4_500000_3277000 0.016
R_VDD5_20288 METAL4_500000_3277000 METAL4_506000_3277000 0.048
R_VDD5_20289 METAL4_506000_3277000 METAL4_507000_3277000 0.008
R_VDD5_20290 METAL4_507000_3277000 METAL4_508000_3277000 0.008
R_VDD5_20291 METAL4_508000_3277000 METAL4_510000_3277000 0.016
R_VDD5_20292 METAL4_510000_3277000 METAL4_512000_3277000 0.016
R_VDD5_20293 METAL4_512000_3277000 METAL4_519000_3277000 0.056
R_VDD5_20294 METAL4_519000_3277000 METAL5_519000_3277000 0.1
R_VDD5_20295 METAL5_519000_3277000 METAL5_520000_3277000 0.004
R_VDD5_20296 METAL5_520000_3277000 METAL5_522000_3277000 0.008
R_VDD5_20297 METAL5_522000_3277000 METAL5_524000_3277000 0.008
R_VDD5_20298 METAL5_524000_3277000 METAL5_531000_3277000 0.028
R_VDD5_20299 METAL5_531000_3277000 METAL5_532000_3277000 0.004
R_VDD5_20300 METAL5_532000_3277000 METAL5_536000_3277000 0.016
R_VDD5_20301 METAL5_536000_3277000 METAL5_543000_3277000 0.028
R_VDD5_20302 METAL5_543000_3277000 METAL6_543000_3277000 0.1
R_VDD5_20303 METAL6_543000_3277000 METAL6_543000_3289000 0.024
R_VDD5_20304 METAL6_543000_3289000 METAL6_543000_3329000 0.08
R_VDD5_20305 METAL6_543000_3329000 METAL6_543000_3341000 0.024
R_VDD5_20306 METAL6_543000_3341000 METAL6_543000_3353000 0.024
R_VDD5_20307 METAL6_543000_3353000 METAL6_543000_3365000 0.024
I_VDD5_81 METAL6_245000_6865000 gnd 0.01
I_VDD5_82 METAL6_555000_6865000 gnd 0.01
I_VDD5_83 METAL6_245000_6165000 gnd 0.01
I_VDD5_84 METAL6_555000_6165000 gnd 0.01
I_VDD5_85 METAL6_245000_5465000 gnd 0.01
I_VDD5_86 METAL6_555000_5465000 gnd 0.01
I_VDD5_87 METAL6_245000_4765000 gnd 0.01
I_VDD5_88 METAL6_555000_4765000 gnd 0.01
I_VDD5_89 METAL6_245000_4065000 gnd 0.01
I_VDD5_90 METAL6_555000_4065000 gnd 0.01
I_VDD5_91 METAL6_245000_3365000 gnd 0.01
I_VDD5_92 METAL6_555000_3365000 gnd 0.01
I_VDD5_93 METAL6_245000_2665000 gnd 0.01
I_VDD5_94 METAL6_555000_2665000 gnd 0.01
I_VDD5_95 METAL6_245000_1965000 gnd 0.01
I_VDD5_96 METAL6_555000_1965000 gnd 0.01
I_VDD5_97 METAL6_245000_1265000 gnd 0.01
I_VDD5_98 METAL6_555000_1265000 gnd 0.01
I_VDD5_99 METAL6_245000_565000 gnd 0.01
I_VDD5_100 METAL6_555000_565000 gnd 0.01

.tran 1ns 1ns
.end
.control
set noaskquit
run
quit
.enddc
